# This was autogenerated! Do not modify
SUMMARY = "CLI application of Eclipse Ankaios"
DESCRIPTION = "Eclipse Ankaios provides workload and container orchestration for automotive \
High Performance Computing Platforms (HPCs). It offers a slim yet powerful \
solution to manage containerized applications across multiple nodes and \
virtual machines via a single API. \
 \
This package contains the Ankaios CLI which represents a way for users to \
access directly the state of the Ankaios cluster through the GRPC interface."
SECTION = "embedded"
SOURCE_PACKAGE = "ankaios"
HOMEPAGE = "https://github.com/eclipse-ankaios/ankaios"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_ANKAIOS_APT}/pool/a/ank/ank_1.0.4_amd64.deb;name=deb0 \
    ${REPO_ANKAIOS_APT}/pool/a/ank/ank_1.0.4_arm64.deb;name=deb1 \
"

SRC_URI[deb0.sha1sum] = "7161bafe97b0097980e73009d4fdeb9aecb53a5e"
SRC_URI[deb0.sha256sum] = "9ec4d43b6dc54542432a5026b575a8f8a9fef90825e2037558a1c3dabeb0ca64"
SRC_URI[deb1.sha1sum] = "faf95a53207f36d2a3c182a75e043ec914fa981c"
SRC_URI[deb1.sha256sum] = "966903a89ffbf671d90aee5842b107115676b50742575b41522980534a0a9c61"

RDEPENDS = " \
    libc6 \
    libgcc-s1 \
"

