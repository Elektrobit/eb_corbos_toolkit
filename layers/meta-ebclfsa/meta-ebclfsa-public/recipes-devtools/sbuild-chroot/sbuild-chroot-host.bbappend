# Copyright 2026 Elektrobit. All rights reserved.

require sbuild-chroot-corbos.inc
