# Copyright 2026 Elektrobit. All rights reserved.

inherit dpkg

# Dependencies which should be defined in both the BitBake and Debian dependencies
COMMON_BUILD_DEPENDS ?= "pybuild-plugin-pyproject"

# BitBake build dependencies
DEPENDS:append = " \
    dh-python \
    python3-all \
    python3-semantic-version \
    python3-license-expression \
    python3-rdflib \
    python3-uritools \
    python3-ply \
    python3-click \
    python3-xmltodict \
    python3-debian \
    python3-requests \
    python3-zstandard \
    python3-poetry \
    python3-poetry-core \
    python3-lxml \
    python3-defusedxml \
    python3-sortedcontainers \
    python3-ddt \
    python3-jsonschema \
    python3-hatchling \
    python3-setuptools \
    python3-apt \
    python3-yaml \
    xmldiff \
    ${COMMON_BUILD_DEPENDS} \
"

# Build dependencies for the debian/control file
DEBIAN_BUILD_DEPENDS:append = " , \
    dh-sequence-python3, \
    python3-all:any, \
    ${@ ', '.join(d.getVar('COMMON_BUILD_DEPENDS').split())} \
"

# Add dependencies automatically generated by debhelper
DEBIAN_DEPENDS:append = " , \
    \${misc:Depends}, \
    \${python3:Depends}, \
"

# Let Isar know that it can build architecture-independent Python packages natively
DPKG_ARCH = "all"

# Automatically create Debian build scripts
do_prepare_build[cleandirs] += "${S}/debian"
do_prepare_build() {
    deb_debianize
}

# The build rules do not require root
DEBIAN_RULES_REQUIRES_ROOT = "no"
