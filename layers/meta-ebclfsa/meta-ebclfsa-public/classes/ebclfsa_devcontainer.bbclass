# Copyright 2026 Elektrobit. All rights reserved.

inherit ebclfsa_base

COMPATIBLE_MACHINE = "container-amd64"
IMAGE_FSTYPES = "docker-archive.zst"
