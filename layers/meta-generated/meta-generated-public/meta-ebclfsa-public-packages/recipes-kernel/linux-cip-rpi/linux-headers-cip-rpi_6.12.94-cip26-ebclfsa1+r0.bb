# This was autogenerated! Do not modify
SUMMARY = "cip-rpi Linux kernel headers for 6.12.94-cip26"
DESCRIPTION = "This package provides kernel header files for 6.12.94-cip26 on arm64 \
 \
This is useful for people who need to build external modules"
SECTION = "kernel"
SOURCE_PACKAGE = "linux-cip-rpi"
HOMEPAGE = "http://www.kernel.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_EBCLFSA_PUBLIC}/pool/main/l/linux-cip-rpi/linux-headers-cip-rpi_6.12.94-cip26-ebclfsa1+r0_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "b2a9c0fb60132bdc0c7bc55f16dc4eca"
SRC_URI[deb0.sha1sum] = "df558460fb441f7ffef391e80998860cf6cadaca"
SRC_URI[deb0.sha256sum] = "27bbc1148940b77f65fb7cc05746c6d7ea8254335a6927fe6bd7c59c622c4f0d"

RDEPENDS = " \
    linux-kbuild-cip-rpi \
    perl \
"

