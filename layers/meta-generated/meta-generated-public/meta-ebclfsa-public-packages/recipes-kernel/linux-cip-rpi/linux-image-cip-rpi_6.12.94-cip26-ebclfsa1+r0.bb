# This was autogenerated! Do not modify
SUMMARY = "cip-rpi Linux kernel, version 6.12.94-cip26"
DESCRIPTION = "This package contains the Linux kernel, modules and corresponding other \
files, version: 6.12.94-cip26."
SECTION = "kernel"
SOURCE_PACKAGE = "linux-cip-rpi"
HOMEPAGE = "http://www.kernel.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_EBCLFSA_PUBLIC}/pool/main/l/linux-cip-rpi/linux-image-cip-rpi_6.12.94-cip26-ebclfsa1+r0_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "d1ed3b42f290698f053fc5f5a5820bb8"
SRC_URI[deb0.sha1sum] = "b41aadb91cf19c2229915c676a290a1b5ecd998b"
SRC_URI[deb0.sha256sum] = "06490608698d3254eb06d0f82dec86adb961a068a92ec2ac309f1c742fb4c5c6"

RDEPENDS = " \
    kmod \
    linux-base \
"

