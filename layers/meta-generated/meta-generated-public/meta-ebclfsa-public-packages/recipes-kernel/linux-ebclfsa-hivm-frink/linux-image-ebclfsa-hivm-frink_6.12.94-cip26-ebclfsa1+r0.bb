# This was autogenerated! Do not modify
SUMMARY = "ebclfsa-hivm-frink Linux kernel, version 6.12.94-cip26-ebclfsa1"
DESCRIPTION = "This package contains the Linux kernel, modules and corresponding other \
files, version: 6.12.94-cip26-ebclfsa1."
SECTION = "kernel"
SOURCE_PACKAGE = "linux-ebclfsa-hivm-frink"
HOMEPAGE = "http://www.kernel.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_EBCLFSA_PUBLIC_BINARY}/pool/main/l/linux-ebclfsa-hivm-frink/linux-image-ebclfsa-hivm-frink_6.12.94-cip26-ebclfsa1+r0_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "159b614a778cfbac06e34298a3b3839c"
SRC_URI[deb0.sha1sum] = "6a127c966ffd8915a458e486aa9383947a48a137"
SRC_URI[deb0.sha256sum] = "fcf719a576f75fe2e9017379f4317598ea81358dba4a67364c55ba9358f8c428"

RDEPENDS = " \
    kmod \
    linux-base \
"

