# This was autogenerated! Do not modify
SUMMARY = "lisa-frink-rpi Linux kernel, version 5.15.193"
DESCRIPTION = "This package contains the Linux kernel, modules and corresponding other \
files, version: 5.15.193."
SECTION = "kernel"
SOURCE_PACKAGE = "linux-lisa-frink-rpi"
HOMEPAGE = "http://www.kernel.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_EBCLFSA_PUBLIC_BINARY}/pool/main/l/linux-lisa-frink-rpi/linux-image-lisa-frink-rpi_5.15.193-499b5599+r0_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "a23939edb4e1630cec790554e798c072"
SRC_URI[deb0.sha1sum] = "afbe75b6c04540e3280ba53bc177b472587283d3"
SRC_URI[deb0.sha256sum] = "d207d5cfe02226e668fc5724628dea5823071abdc16f1dd2bf16a31724717943"

RDEPENDS = " \
    kmod \
    linux-base \
"

