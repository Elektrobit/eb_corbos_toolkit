# This was autogenerated! Do not modify
SUMMARY = "ebclfsa-fastdev-rpi Linux kernel headers for 6.12.94-cip26"
DESCRIPTION = "This package provides kernel header files for 6.12.94-cip26 on arm64 \
 \
This is useful for people who need to build external modules"
SECTION = "kernel"
SOURCE_PACKAGE = "linux-ebclfsa-fastdev-rpi"
HOMEPAGE = "http://www.kernel.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_EBCLFSA_PUBLIC}/pool/main/l/linux-ebclfsa-fastdev-rpi/linux-headers-ebclfsa-fastdev-rpi_6.12.94-cip26-ebclfsa1+r0_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "44950f61af55f1ecb357cc4d4cac47bd"
SRC_URI[deb0.sha1sum] = "e30b776ae5445299c52de7bc0bbd9f83babbab0c"
SRC_URI[deb0.sha256sum] = "986637f773e6abbb0f7f3d92d0dd3cf5267305dab1ff72af41e98e95948696e0"

RDEPENDS = " \
    linux-kbuild-ebclfsa-fastdev-rpi \
    perl \
"

