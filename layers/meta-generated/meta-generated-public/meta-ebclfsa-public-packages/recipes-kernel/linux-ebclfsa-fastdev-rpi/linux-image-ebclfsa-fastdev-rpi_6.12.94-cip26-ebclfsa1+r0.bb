# This was autogenerated! Do not modify
SUMMARY = "ebclfsa-fastdev-rpi Linux kernel, version 6.12.94-cip26"
DESCRIPTION = "This package contains the Linux kernel, modules and corresponding other \
files, version: 6.12.94-cip26."
SECTION = "kernel"
SOURCE_PACKAGE = "linux-ebclfsa-fastdev-rpi"
HOMEPAGE = "http://www.kernel.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_EBCLFSA_PUBLIC}/pool/main/l/linux-ebclfsa-fastdev-rpi/linux-image-ebclfsa-fastdev-rpi_6.12.94-cip26-ebclfsa1+r0_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "9639ea1da68da87e4d053d43986d64e8"
SRC_URI[deb0.sha1sum] = "bb6c50f37d4ae29dcb208af34694ff162b61f662"
SRC_URI[deb0.sha256sum] = "366aa64bd18e715b64a00654fe88a36dff04fc225fe10df58df43c29ec8b564d"

RDEPENDS = " \
    kmod \
    linux-base \
"

