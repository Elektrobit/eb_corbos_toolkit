# This was autogenerated! Do not modify
SUMMARY = "lisa-frink Linux kernel, version 5.15.193"
DESCRIPTION = "This package contains the Linux kernel, modules and corresponding other \
files, version: 5.15.193."
SECTION = "kernel"
SOURCE_PACKAGE = "linux-lisa-frink"
HOMEPAGE = "http://www.kernel.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_EBCLFSA_PUBLIC_BINARY}/pool/main/l/linux-lisa-frink/linux-image-lisa-frink_5.15.193-499b5599+r0_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "cfe10be7e6e45c476b83efd885d0ceda"
SRC_URI[deb0.sha1sum] = "3fa29a8b275cd6cfaf1710b878021f51f56c7e59"
SRC_URI[deb0.sha256sum] = "70944d5b554705b2b46f60e8594c2b09b1d04a0922c085b91572c93d78699981"

RDEPENDS = " \
    kmod \
    linux-base \
"

