# This was autogenerated! Do not modify
SUMMARY = "ebclfsa-fastdev Linux kernel, version 6.12.94-cip26-ebclfsa1"
DESCRIPTION = "This package contains the Linux kernel, modules and corresponding other \
files, version: 6.12.94-cip26-ebclfsa1."
SECTION = "kernel"
SOURCE_PACKAGE = "linux-ebclfsa-fastdev"
HOMEPAGE = "http://www.kernel.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_EBCLFSA_PUBLIC}/pool/main/l/linux-ebclfsa-fastdev/linux-image-ebclfsa-fastdev_6.12.94-cip26-ebclfsa1+r0_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "73b0179e84f8e0915816f5185bbfa91f"
SRC_URI[deb0.sha1sum] = "a3a197a76734654a0bf724eb80906da134bcc299"
SRC_URI[deb0.sha256sum] = "e040f7a4d3b455752429e6f40a7c4cb9655b9756d79a49a2a79b93131b5729a8"

RDEPENDS = " \
    kmod \
    linux-base \
"

