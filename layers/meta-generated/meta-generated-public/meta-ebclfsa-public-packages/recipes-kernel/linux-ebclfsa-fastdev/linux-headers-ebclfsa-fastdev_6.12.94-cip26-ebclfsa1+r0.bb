# This was autogenerated! Do not modify
SUMMARY = "ebclfsa-fastdev Linux kernel headers for 6.12.94-cip26-ebclfsa1"
DESCRIPTION = "This package provides kernel header files for 6.12.94-cip26-ebclfsa1 on arm64 \
 \
This is useful for people who need to build external modules"
SECTION = "kernel"
SOURCE_PACKAGE = "linux-ebclfsa-fastdev"
HOMEPAGE = "http://www.kernel.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_EBCLFSA_PUBLIC}/pool/main/l/linux-ebclfsa-fastdev/linux-headers-ebclfsa-fastdev_6.12.94-cip26-ebclfsa1+r0_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "8b3143af82db23650adf4259e4feea31"
SRC_URI[deb0.sha1sum] = "a4fd612c73ac1b7b35461ab5ebd3acac89a29d03"
SRC_URI[deb0.sha256sum] = "48a2c639657bd6fb836aedb48a11006fc950b356ba4eaa3e5e497091d8db573a"

RDEPENDS = " \
    linux-kbuild-ebclfsa-fastdev \
    perl \
"

