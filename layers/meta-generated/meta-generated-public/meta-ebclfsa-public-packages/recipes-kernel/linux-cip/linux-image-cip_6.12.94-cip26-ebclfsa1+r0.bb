# This was autogenerated! Do not modify
SUMMARY = "cip Linux kernel, version 6.12.94-cip26-ebclfsa"
DESCRIPTION = "This package contains the Linux kernel, modules and corresponding other \
files, version: 6.12.94-cip26-ebclfsa."
SECTION = "kernel"
SOURCE_PACKAGE = "linux-cip"
HOMEPAGE = "http://www.kernel.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_EBCLFSA_PUBLIC}/pool/main/l/linux-cip/linux-image-cip_6.12.94-cip26-ebclfsa1+r0_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "0bed039b4a31780b41f3fc3901658d28"
SRC_URI[deb0.sha1sum] = "f62f458030d6c878456210679a235001e9273bbc"
SRC_URI[deb0.sha256sum] = "cb7416b458f7febe47590a8673f90e49a6c3dfbe4c97521bde28336692839a73"

RDEPENDS = " \
    kmod \
    linux-base \
"

