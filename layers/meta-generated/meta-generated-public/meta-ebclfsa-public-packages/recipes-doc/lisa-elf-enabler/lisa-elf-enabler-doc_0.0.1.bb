# This was autogenerated! Do not modify
SUMMARY = "HTML documentation for lisa-elf-enabler"
DESCRIPTION = "The ELF Enabler adds a special lisa section containing CRC32 checksums for all \
PT_LOAD segments of the ELF file. \
 \
HTML documentation package."
SECTION = "doc"
SOURCE_PACKAGE = "lisa-elf-enabler"
HOMEPAGE = "https://gitext.elektrobitautomotive.com/EB-Linux/lisa-elf-enabler"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EBCLFSA_PUBLIC_BINARY}/pool/main/l/lisa-elf-enabler/lisa-elf-enabler-doc_0.0.1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "df98d165acd3c4a678065082503dfe18"
SRC_URI[deb0.sha1sum] = "e1824acba19a44ad95c070d26d0c42fcef38cfa7"
SRC_URI[deb0.sha256sum] = "c467be7f6f32a7977a7206e2688d4ce812b4cd31615cdbefc47d608ef2b04a1e"


