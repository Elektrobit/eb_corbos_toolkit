# This was autogenerated! Do not modify
SUMMARY = "Linux kernel debugging symbols for 6.12.94-cip26"
DESCRIPTION = "This package will come in handy if you need to debug the kernel. It provides \
all the necessary debug symbols for the kernel and its modules."
SECTION = "debug"
SOURCE_PACKAGE = "linux-cip-rpi"
HOMEPAGE = "http://www.kernel.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_EBCLFSA_PUBLIC}/pool/main/l/linux-cip-rpi/linux-image-cip-rpi-dbg_6.12.94-cip26-ebclfsa1+r0_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "a696fafc4b78cecfd97eae607d4b6257"
SRC_URI[deb0.sha1sum] = "76c355bc3050acb0b9fad17fec60a3182fcc2b23"
SRC_URI[deb0.sha256sum] = "6bcb7ed8d361ffbb05df184cc65f973a0d92174368c9ebe6e3c45f64bd959ac3"


