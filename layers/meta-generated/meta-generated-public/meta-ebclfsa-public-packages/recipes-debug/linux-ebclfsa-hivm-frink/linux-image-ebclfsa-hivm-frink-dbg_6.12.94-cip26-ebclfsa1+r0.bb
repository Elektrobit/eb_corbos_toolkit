# This was autogenerated! Do not modify
SUMMARY = "Linux kernel debugging symbols for 6.12.94-cip26-ebclfsa1"
DESCRIPTION = "This package will come in handy if you need to debug the kernel. It provides \
all the necessary debug symbols for the kernel and its modules."
SECTION = "debug"
SOURCE_PACKAGE = "linux-ebclfsa-hivm-frink"
HOMEPAGE = "http://www.kernel.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_EBCLFSA_PUBLIC_BINARY}/pool/main/l/linux-ebclfsa-hivm-frink/linux-image-ebclfsa-hivm-frink-dbg_6.12.94-cip26-ebclfsa1+r0_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "2a4758340c31d63312d0d7411bf31753"
SRC_URI[deb0.sha1sum] = "7fff31992548b499bf348023f187ecdb050a14b9"
SRC_URI[deb0.sha256sum] = "fe6a1f36aaacf9508a32d10b3fb149edd0f05052df5d15e34200c7e313c524aa"


