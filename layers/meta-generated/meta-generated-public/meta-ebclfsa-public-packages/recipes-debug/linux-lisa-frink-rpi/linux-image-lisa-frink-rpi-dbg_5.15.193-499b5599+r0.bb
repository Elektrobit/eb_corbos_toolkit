# This was autogenerated! Do not modify
SUMMARY = "Linux kernel debugging symbols for 5.15.193"
DESCRIPTION = "This package will come in handy if you need to debug the kernel. It provides \
all the necessary debug symbols for the kernel and its modules."
SECTION = "debug"
SOURCE_PACKAGE = "linux-lisa-frink-rpi"
HOMEPAGE = "http://www.kernel.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_EBCLFSA_PUBLIC_BINARY}/pool/main/l/linux-lisa-frink-rpi/linux-image-lisa-frink-rpi-dbg_5.15.193-499b5599+r0_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "cbf912abd749a14d5df84ff5324eb80c"
SRC_URI[deb0.sha1sum] = "23a2b41409f3fe94113dc98d08ce674998f38dd0"
SRC_URI[deb0.sha256sum] = "28cec47e1ce4e3fa4a7e58e93759fb016778f0475c83fcde3a15cad33f69c4a8"


