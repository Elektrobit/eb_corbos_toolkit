# This was autogenerated! Do not modify
SUMMARY = "comfwdlib header files for LI applications"
DESCRIPTION = "Header files for communication over shared memory and network sockets \
 \
Dynamically linked binary for LI environments."
SECTION = "libdevel"
SOURCE_PACKAGE = "ebcl-userland-utils"
HOMEPAGE = "https://gitext.elektrobitautomotive.com/EB-Linux/ebcl-userland-utils"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_EBCLFSA_PUBLIC_BINARY}/pool/main/e/ebcl-userland-utils/libcomfwdlib-li-dev_0.0.1_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "5f8db8fa7b3452428bd38110918adb18"
SRC_URI[deb0.sha1sum] = "4b9ee4f6687c1699956518e630c76502040be549"
SRC_URI[deb0.sha256sum] = "b840bf7756ce7c29ec31f9057d135a962a8158a31d7158bd6cc36e2e7e8807ca"

RDEPENDS = " \
    libcomfwdlib-li1 \
"

