# This was autogenerated! Do not modify
SUMMARY = "EB corbos Linux for Safety Applications Muslc Tools for using muslc"
DESCRIPTION = "Tools for building applications using lisa-libc."
SECTION = "devel"
SOURCE_PACKAGE = "lisa-libc"
HOMEPAGE = "https://gitext.elektrobitautomotive.com/EB-Linux/lisa-libc"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_EBCLFSA_PUBLIC}/pool/main/l/lisa-libc/lisa-libc-tools_1.2.5_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "bc4fbd2eb2f663ca6d76764af21bfe0b"
SRC_URI[deb0.sha1sum] = "73b6dd6f11fbad2f8bb1b54733ce795d5d427aed"
SRC_URI[deb0.sha256sum] = "fb3ca5bce94e20769946cb5e647564a20eae60418917722a5c4050f4a41ed785"

RDEPENDS = " \
    lisa-libc-dev \
"

