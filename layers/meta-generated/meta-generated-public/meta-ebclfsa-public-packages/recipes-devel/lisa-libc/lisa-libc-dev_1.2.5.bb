# This was autogenerated! Do not modify
SUMMARY = "EB corbos Linux for Safety Applications Muslc Dev"
DESCRIPTION = "Static libraries and headers for compiling and linking an application \
against lisa-libc."
SECTION = "devel"
SOURCE_PACKAGE = "lisa-libc"
HOMEPAGE = "https://gitext.elektrobitautomotive.com/EB-Linux/lisa-libc"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_EBCLFSA_PUBLIC}/pool/main/l/lisa-libc/lisa-libc-dev_1.2.5_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "9c0a10a24e3458d64f343b4c92a0caa9"
SRC_URI[deb0.sha1sum] = "44ae687d7e6c8629801237f4501919e4501c5027"
SRC_URI[deb0.sha256sum] = "36b9d29eacc46ae2e423fc79f0fce87379b476756736f2057b5bb62bae6adf26"


