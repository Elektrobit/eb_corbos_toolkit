# This was autogenerated! Do not modify
SUMMARY = "Rebuild of libc++ from the "Arm Toolchain for Embedded" against lisa-libc,"
DESCRIPTION = "for use by HI C++ Applications in EBcLfSA."
SECTION = "devel"
SOURCE_PACKAGE = "lisa-libcxx"
HOMEPAGE = "https://github.com/arm/arm-toolchain/tree/arm-software/arm-software/embedded"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_EBCLFSA_PUBLIC}/pool/main/l/lisa-libcxx/lisa-libcxx-dev_20.1.0+ATfE_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "ebc98f818313654566211537db757810"
SRC_URI[deb0.sha1sum] = "eeba98e70d2531b95b2cf4410a7341e444822ed1"
SRC_URI[deb0.sha256sum] = "191d519c8abc39193958515938d0587890b11ae28e7b4e0b67622418095c8c79"


