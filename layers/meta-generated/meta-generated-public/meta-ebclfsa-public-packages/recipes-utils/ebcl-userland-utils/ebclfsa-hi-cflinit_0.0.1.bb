# This was autogenerated! Do not modify
SUMMARY = "HI init application for EBcLfSA using comfwdlib"
DESCRIPTION = "Demo HI init application for demonstrating and testing EBcLfSA functionality. \
 \
Statically linked binaries for HI environments."
SECTION = "utils"
SOURCE_PACKAGE = "ebcl-userland-utils"
HOMEPAGE = "https://gitext.elektrobitautomotive.com/EB-Linux/ebcl-userland-utils"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_EBCLFSA_PUBLIC_BINARY}/pool/main/e/ebcl-userland-utils/ebclfsa-hi-cflinit_0.0.1_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "53c9fddfa738a84bfc5b43c8212f96a9"
SRC_URI[deb0.sha1sum] = "d4b73b9f10d234ae806ca5c4a28e2021c5d577e6"
SRC_URI[deb0.sha256sum] = "dd807e8982bd812e459b4ae740966699853a048f0074b0cc913c841a5345e2d8"

RDEPENDS = " \
    musl \
"

