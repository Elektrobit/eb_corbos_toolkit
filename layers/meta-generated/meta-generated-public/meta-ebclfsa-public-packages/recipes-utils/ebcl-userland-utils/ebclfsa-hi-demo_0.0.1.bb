# This was autogenerated! Do not modify
SUMMARY = "HI demo applications for EBcLfSA"
DESCRIPTION = "Demo applications for demonstrating and testing EBcLfSA functionality. \
 \
Statically linked binaries for HI environments."
SECTION = "utils"
SOURCE_PACKAGE = "ebcl-userland-utils"
HOMEPAGE = "https://gitext.elektrobitautomotive.com/EB-Linux/ebcl-userland-utils"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_EBCLFSA_PUBLIC_BINARY}/pool/main/e/ebcl-userland-utils/ebclfsa-hi-demo_0.0.1_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "0a163d21524133bde912851f6fbd6cd5"
SRC_URI[deb0.sha1sum] = "e275072e60c518ff08cebce1d31f3e2f713d2f73"
SRC_URI[deb0.sha256sum] = "8603acf09cf48d58ce5bc5253799b878bfd590e0b0b494a16ac079e5175500b3"

RDEPENDS = " \
    musl \
"

