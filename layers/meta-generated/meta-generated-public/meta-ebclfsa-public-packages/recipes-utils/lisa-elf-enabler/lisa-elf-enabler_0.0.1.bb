# This was autogenerated! Do not modify
SUMMARY = "Patch an ELF binary file to enable EBcLfSA compliant HI app startup"
DESCRIPTION = "The ELF Enabler adds a special lisa section containing CRC32 checksums for all \
PT_LOAD segments of the ELF file."
SECTION = "utils"
SOURCE_PACKAGE = "lisa-elf-enabler"
HOMEPAGE = "https://gitext.elektrobitautomotive.com/EB-Linux/lisa-elf-enabler"

inherit dpkg-prebuilt

DPKG_ARCH = "amd64"
SRC_URI = " \
    ${REPO_EBCLFSA_PUBLIC_BINARY}/pool/main/l/lisa-elf-enabler/lisa-elf-enabler_0.0.1_amd64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "4d0f35a420b89918d53016442981c7c9"
SRC_URI[deb0.sha1sum] = "6923ed04647b9f1d9e96ed9fcc4656b8e34aa42c"
SRC_URI[deb0.sha256sum] = "4440d22637da56f3a51921795663ad3b024ce41eeec54a29dc12efd7cf831cc3"

RDEPENDS = " \
    libc6 \
    libgcc-s1 \
    libstdc++6 \
"

