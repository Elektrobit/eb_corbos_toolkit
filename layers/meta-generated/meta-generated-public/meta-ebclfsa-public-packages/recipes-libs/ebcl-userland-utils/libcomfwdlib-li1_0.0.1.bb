# This was autogenerated! Do not modify
SUMMARY = "comfwdlib library package for LI applications"
DESCRIPTION = "Library for communication over shared memory and network sockets \
 \
Dynamically linked binary for LI environments."
SECTION = "libs"
SOURCE_PACKAGE = "ebcl-userland-utils"
HOMEPAGE = "https://gitext.elektrobitautomotive.com/EB-Linux/ebcl-userland-utils"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_EBCLFSA_PUBLIC_BINARY}/pool/main/e/ebcl-userland-utils/libcomfwdlib-li1_0.0.1_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "bd8ca799beca4da331cf670e1a44b0d9"
SRC_URI[deb0.sha1sum] = "178363ca2ef0262866c41c4b0242920e12757e95"
SRC_URI[deb0.sha256sum] = "55fed468ea65ef0b94f3f1a563127003138b0b96cafe399eb2ab8ceb986455a0"

RDEPENDS = " \
    libc6 \
"

