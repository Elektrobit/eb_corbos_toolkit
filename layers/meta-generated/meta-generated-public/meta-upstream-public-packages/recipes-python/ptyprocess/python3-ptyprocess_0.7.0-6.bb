# This was autogenerated! Do not modify
SUMMARY = "Run a subprocess in a pseudo terminal from Python 3"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "ptyprocess"
HOMEPAGE = "https://github.com/pexpect/ptyprocess"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/ptyprocess/python3-ptyprocess_0.7.0-6_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "34441fc9b8d3086b8164e9df33e5d33f"
SRC_URI[deb0.sha1sum] = "8fd3d2b361fdbbb5d8e377b16a888dbbfc4d0ba2"
SRC_URI[deb0.sha256sum] = "6886f538ee2b2affcc4e2a1e359a9143ca4a2a068d12298116e294687f6290f0"
SRC_URI[deb0.sha512sum] = "d8655dcfd70e096c46ccea7048790b10e8869b531d1edc9c6b0d6fd5cf1baa670abfe0687a4369d84ac74ea35f334a599e6333d67a7050bf73d4ba46512667d0"

RDEPENDS = " \
    python3 \
"

