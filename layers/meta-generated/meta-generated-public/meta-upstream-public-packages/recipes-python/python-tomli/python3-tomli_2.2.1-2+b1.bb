# This was autogenerated! Do not modify
SUMMARY = "lil' TOML parser for Python"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "python-tomli"
HOMEPAGE = "https://github.com/hukkin/tomli"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python-tomli/python3-tomli_2.2.1-2+b1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python-tomli/python3-tomli_2.2.1-2+b1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "11a06ca67e6e481185b4cc088b614cf8"
SRC_URI[deb0.sha1sum] = "fa9ac88a2a5fd37f48cb64506df51a71f11cd66b"
SRC_URI[deb0.sha256sum] = "57d5ee29234ba145e298a36e4530ff261bf2e706e9df95d08cfeee1d7e8362a9"
SRC_URI[deb0.sha512sum] = "89d5fd8f23e447e0e2cae4bce50b226907744d1b7cbdc4850c3878796729b8633ea7db9f92a0ae84ac6d116689dc2bd39f111d601cf4dd43b2df2c71b6785df6"
SRC_URI[deb1.md5sum] = "dc6e485ad5bb3917085cfef42670266c"
SRC_URI[deb1.sha1sum] = "c91f8264df19c8645de54a23148627a51f16fead"
SRC_URI[deb1.sha256sum] = "f6284758231e4565aee5f81bc5b01e59f5ddfb0af644507abb357f5407eadd8d"
SRC_URI[deb1.sha512sum] = "599b2c87b2dea7f78a3e14ec9c66533073d175f71c06dcfb4672b9949a6166c9f2f8b4dcb41f29ce521eef3ba58bb7c9cc511a618708eda5248e1bba089b8bd5"

RDEPENDS = " \
    libc6 \
    python3 \
"

