# This was autogenerated! Do not modify
SUMMARY = "Python library to interact with Git repositories"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "python-git"
HOMEPAGE = "https://github.com/gitpython-developers/GitPython"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python-git/python3-git_3.1.44-1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "58984843ca82605d0b8052934ca41e5e"
SRC_URI[deb0.sha1sum] = "e1fc2517e61f7e6dc643212f4d11c9ead645c32a"
SRC_URI[deb0.sha256sum] = "e79b5f4e6ddf8fe54e006f33420d9ab7a5b1cda5b4919e8cd4850380d573519c"
SRC_URI[deb0.sha512sum] = "6f2e9ead285e4380945daefb4c3480c47c6c18e068e973ab68de3e2cb39d107430f69a081b385636b8a88472d24e1c7591527e4ff1663623ad25747333cb3696"

RDEPENDS = " \
    git \
    python3 \
    python3-gitdb \
"

