# This was autogenerated! Do not modify
SUMMARY = "decorators, wrappers and monkey patching. - Python 3.x"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "python-wrapt"
HOMEPAGE = "https://github.com/GrahamDumpleton/wrapt"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python-wrapt/python3-wrapt_1.15.0-4+b1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python-wrapt/python3-wrapt_1.15.0-4+b1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "1f7ae58751ced787e297a75ab597c4f7"
SRC_URI[deb0.sha1sum] = "228bc48df4295e991eb142ededbe526f81672a1e"
SRC_URI[deb0.sha256sum] = "b21010b18f4e33f98b47502711239df887bffe8d2913611499e97ffa18818646"
SRC_URI[deb0.sha512sum] = "eb157d9c2c2442503c46e59e276f44c5a2a95a97f189557303ea618791eb132b1816fe1eeedea56aa8dad42f99ecb1f3d4ecbc7b6a6bd1388a801d65ac81398a"
SRC_URI[deb1.md5sum] = "c88a8d157ebd2d3e923eedb73552d446"
SRC_URI[deb1.sha1sum] = "cf87f5d047433e6725521f3e4e34a59bd440d662"
SRC_URI[deb1.sha256sum] = "efe6718eca5eda919bc4c4158008b35aea7e90823605c2791f69be48af1843f3"
SRC_URI[deb1.sha512sum] = "01b42ef2564242b33deee1d281134f4c9cfa4dcecedc62796e12f7fb6c90c9de40cc42ee94fc12d11baf15539158b39e852f6197aa30c7512454528d1eb9f476"

RDEPENDS = " \
    libc6 \
    python3 \
"

