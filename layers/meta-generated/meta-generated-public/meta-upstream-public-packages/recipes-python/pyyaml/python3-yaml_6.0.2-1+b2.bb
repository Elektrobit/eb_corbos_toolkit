# This was autogenerated! Do not modify
SUMMARY = "YAML parser and emitter for Python3"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "pyyaml"
HOMEPAGE = "https://github.com/yaml/pyyaml"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/pyyaml/python3-yaml_6.0.2-1+b2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/pyyaml/python3-yaml_6.0.2-1+b2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "2da533d6dfb9652f7a26ec30546ce20f"
SRC_URI[deb0.sha1sum] = "597b10ee515aa84b6d70ea0a0995734eec762e56"
SRC_URI[deb0.sha256sum] = "0019c4e7848c83a0d6bcb78cca902b5cdb1714aa6370ba01955b1fed6f667056"
SRC_URI[deb0.sha512sum] = "e40be1126dc5a3e705981455bfa189893fceb47f7ea65114fb55f0ad48ac28f96563fbfde0866921a912e3512df0143cdecb5d1196a920fe77217866fa0f75fe"
SRC_URI[deb1.md5sum] = "c9384ba5d38338a2f6126c17b2c462b2"
SRC_URI[deb1.sha1sum] = "aa06b96edf82d8a8f5159020e1f1efd1a4f4d571"
SRC_URI[deb1.sha256sum] = "b83a9ccdc2d1d1f2e36c7c333d36b0151cc89f1d45568e28bcab1f00c72a3498"
SRC_URI[deb1.sha512sum] = "5247d526bc817aaa33c4ef175803c8bb395ab8545cfe93c7e579c353dacf6b7a7c55414fff3929d4cd5d802b5c17789297310c663ce4071b8d32cb093b0233ce"

RDEPENDS = " \
    libc6 \
    libyaml-0-2 \
    python3 \
"

