# This was autogenerated! Do not modify
SUMMARY = "Sphinx extension for argparse commands and options (Python 3)"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "sphinx-argparse"
HOMEPAGE = "https://github.com/ashb/sphinx-argparse"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/sphinx-argparse/python3-sphinx-argparse_0.5.2-1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "20c562636b36b73edabae85c89dee71a"
SRC_URI[deb0.sha1sum] = "7d5f194cf4ad7fd1986c2e437db8813c2091036d"
SRC_URI[deb0.sha256sum] = "64ef93957e1d2212bdeafc2aec74c37979b76d4d71b192b280e582ff036bdf7c"
SRC_URI[deb0.sha512sum] = "52cb3ac75c95e45188c6876b0b284d3515033c246d0d175b0b3e82638be03dd0975e2e7145609fd8ee8fcf594ae28741202617caa34fe7a41c3a67f9b47e3020"

RDEPENDS = " \
    libjs-sphinxdoc \
    python3 \
    python3-docutils \
    python3-sphinx \
"

