# This was autogenerated! Do not modify
SUMMARY = "SETools Python bindings"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "setools"
HOMEPAGE = "https://github.com/SELinuxProject/setools/wiki"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/setools/python3-setools_4.5.1-1.1+b1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/setools/python3-setools_4.5.1-1.1+b1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "1a2cb2e5c4c94cf2fa082a9fb2c2253f"
SRC_URI[deb0.sha1sum] = "197cca1a7edd2fd1906cc7cde67657bec1d6c0af"
SRC_URI[deb0.sha256sum] = "a223aeade276fd2fd9764e4917e6fae0189cd9f989c3d12e4720ceac986f7ee8"
SRC_URI[deb0.sha512sum] = "0cc9ba255b71598ed4d23364b4cba430df10a3976297f6f6ee671bb5e041c6bad834914b607de6d1408cbd1ececf892eb6839453787436494b4c8652f19c6066"
SRC_URI[deb1.md5sum] = "a28f192ec5e5fd8d20b9592db96e7897"
SRC_URI[deb1.sha1sum] = "6c2a3628c2a7eb8fe206bdd9f088de7ff5a05f7d"
SRC_URI[deb1.sha256sum] = "f162d61c1dd1aa8b8ed30b79bc454109c03f955644c3fb403cf4a98248ce5010"
SRC_URI[deb1.sha512sum] = "af9e570c362d82f29309c93fbc3b87295ca31fc60909d07a1af5d4fc75050b1ee64fb35e388f64509fb6120f736bf20091c6dd2257d84e49dd570c72724869ad"

RDEPENDS = " \
    libc6 \
    libselinux1 \
    libsepol2 \
    python3 \
    python3-networkx \
    python3-pkg-resources \
"

