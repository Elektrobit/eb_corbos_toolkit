# This was autogenerated! Do not modify
SUMMARY = "HTML/XHTML/XML string library"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "markupsafe"
HOMEPAGE = "https://palletsprojects.com/p/markupsafe/"

inherit dpkg-prebuilt

DPKG_ARCH = "amd64"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/m/markupsafe/python3-markupsafe_2.1.5-1+b3_amd64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "d75edc67b533a19f56dc1ba699c4eeff"
SRC_URI[deb0.sha1sum] = "fbeb91c9d3c02a07930d8d571965e8dd226740c7"
SRC_URI[deb0.sha256sum] = "f82dbd759e6b9c111dc764b3ce7744633d0c97948aaa77294984b80e9db44a24"
SRC_URI[deb0.sha512sum] = "2268b50d5baf67bf246c466481ef13907604118494405d8f400daceb2cf8c64ab60ed8f69a02e4c68a2c14bc4e81e3807b59d6a2298d74b9801d1a15872be247"

RDEPENDS = " \
    libc6 \
    python3 \
"

