# This was autogenerated! Do not modify
SUMMARY = "HTML/XHTML/XML string library"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "markupsafe"
HOMEPAGE = "https://palletsprojects.com/p/markupsafe/"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/m/markupsafe/python3-markupsafe_2.1.5-1+b4_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "a5736cebf2927f111f545a706cfe3a19"
SRC_URI[deb0.sha1sum] = "6c22adb76c63eb8f2c30e92acdc09598ff5758c7"
SRC_URI[deb0.sha256sum] = "2fd29191e4509b87d6b826097f2380381d58a685ab8fb8fc709445cfb42197c9"
SRC_URI[deb0.sha512sum] = "55080800b01cc1146e2c91c437e69208caa0e21e6262830729e4a352f87cee9eb376f453a2f956f651de1c03774648f8886603fa8023198b9e221f113a7876c3"

RDEPENDS = " \
    libc6 \
    python3 \
"

