# This was autogenerated! Do not modify
SUMMARY = "Rapid fuzzy string matching library (Python library)"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "rapidfuzz"
HOMEPAGE = "https://github.com/maxbachmann/RapidFuzz"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/r/rapidfuzz/python3-rapidfuzz_3.12.2+ds-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/r/rapidfuzz/python3-rapidfuzz_3.12.2+ds-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "5905e899503fb23893d98a64ee54724c"
SRC_URI[deb0.sha1sum] = "db88b03d4e390dad0d7248e4f69e883c32554fa0"
SRC_URI[deb0.sha256sum] = "a03f0ed0a2e2ff6cf13ec2bea4883055834f573749639addf7d0ae67c47d819a"
SRC_URI[deb0.sha512sum] = "58d69b8ec8d401206e954059e0853a2164882036d7d4d19dd7858ff92a8405dfeb832b1d3cbffde5cad5b66070cf01028b4ecc30d372f568f7197dea8a586dd8"
SRC_URI[deb1.md5sum] = "b0a9aa7cf030237549522493424e0936"
SRC_URI[deb1.sha1sum] = "ed8ce0ca929a04dd65c0ab91042091b1105db438"
SRC_URI[deb1.sha256sum] = "6d849845ef3b2b97cf7952aae0625f3fd3fd9a94b30c5c4e949c4dd4c1d2b5e0"
SRC_URI[deb1.sha512sum] = "37b30951108a81174367d82c15aa8fe222db36dfebaec0b97e6bc3351293e44ec1205f4c4fc4a5403f16942d0766b406b3ff85f4a0049fe053abc0350b25f7df"

RDEPENDS = " \
    libc6 \
    libgcc-s1 \
    libstdc++6 \
    python3 \
"

