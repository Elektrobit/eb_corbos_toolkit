# This was autogenerated! Do not modify
SUMMARY = "Read resources from Python packages"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "importlib-resources"
HOMEPAGE = "https://github.com/python/importlib_resources"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/i/importlib-resources/python3-importlib-resources_6.5.2-1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "aa153a1ac73d1f3967da983adef08209"
SRC_URI[deb0.sha1sum] = "1287b9e03b2cd81dabd9cbceb934e011024bfc77"
SRC_URI[deb0.sha256sum] = "7f6c49804f85cfbe94dcb51d1c34e64795a475e69ab8f4c33bb6100e8c37fc6f"
SRC_URI[deb0.sha512sum] = "7522ffae0e9a3ee40e72b9c7bfbb03729738567bb8cc378d3a468e77b1f927db923b9c137c039a1a0f1ea02322851378bbc2d51d1f1b69d0f7194c46440b2670"

RDEPENDS = " \
    python3 \
    python3-zipp \
"

