# This was autogenerated! Do not modify
SUMMARY = "Python 3 module for automating interactive applications"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "pexpect"
HOMEPAGE = "https://github.com/pexpect/pexpect"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/pexpect/python3-pexpect_4.9-3_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "179902f397681739e72be91367df9c06"
SRC_URI[deb0.sha1sum] = "2780e12c5c4854c2a3df7f73c759eb20b249ab6a"
SRC_URI[deb0.sha256sum] = "e7a8a968b671d59156ee47a3713fde58e0ab645e6285bb50f3b0a532b8643f15"
SRC_URI[deb0.sha512sum] = "d456ac20434cffb3491f8054632f9e5eaf297aab8212d92f95917a7b633aae17de871fd7806eaea940acd1c3ccf8b8bba10a689b436b4f83209c7b43709edde7"

RDEPENDS = " \
    python3 \
    python3-ptyprocess \
"

