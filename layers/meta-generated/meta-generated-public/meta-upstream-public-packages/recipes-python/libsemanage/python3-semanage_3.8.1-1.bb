# This was autogenerated! Do not modify
SUMMARY = "Python3 bindings for SELinux policy management"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "libsemanage"
HOMEPAGE = "https://selinuxproject.org"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libs/libsemanage/python3-semanage_3.8.1-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libs/libsemanage/python3-semanage_3.8.1-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "59a6f21877516da6e137101ef0073d33"
SRC_URI[deb0.sha1sum] = "9f32d229ed9f8e4933e4e50d862792e06da82dea"
SRC_URI[deb0.sha256sum] = "eadae4b03547c5601cfef5a0574571f403a87eef614d0843a8d784b721e2c283"
SRC_URI[deb0.sha512sum] = "42dd5ef84765de32302fd0a2c99e8441bc7d3c8a1eb74e996f5759ae2fce04986c4be1727e2b1aba577d2bb637b0999f4514f71e46ad9f513c6cc7857c05a795"
SRC_URI[deb1.md5sum] = "77092c1d09bb583195eb8d520f4e822f"
SRC_URI[deb1.sha1sum] = "b7ba5fb6b0ba0c7cfde5e5d556309a098e1421ee"
SRC_URI[deb1.sha256sum] = "2564bc567eea397e45c4e4d3294430a628f77d272fce27f4ed5aaef63d32046b"
SRC_URI[deb1.sha512sum] = "73395fca50a0098a56765b9e4be69a192270f8ac18b6098859b5f01cf1b087283d00c0678f2c24790d54e0120cecb22914e9f267d570c904cf98c5434639672d"

RDEPENDS = " \
    libc6 \
    libsemanage2 \
    python3 \
"

