# This was autogenerated! Do not modify
SUMMARY = "command-line interface description language (Python3)"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "docopt"
HOMEPAGE = "http://docopt.org"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/d/docopt/python3-docopt_0.6.2-6_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "ef992432338b13b8cd9078f49747a867"
SRC_URI[deb0.sha1sum] = "9342ccd4de9479b3f268785c5cf0eddbe4aafc59"
SRC_URI[deb0.sha256sum] = "050eea17a7b755192f0f1b387ff79c6d2c4057af5efaa9be83ff32460b237a26"
SRC_URI[deb0.sha512sum] = "4d6099a2c5b10248f1614deca2a4a37a1556ed2f7ccff92b01d347ae0d31f99e8a08cfac32ef90cd7465f548e5427642160bca69d8546b424c97ec7b15d5cea2"

RDEPENDS = " \
    python3 \
"

