# This was autogenerated! Do not modify
SUMMARY = "Implementation-agnostic implementation of JSON reference resolution"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "referencing"
HOMEPAGE = "https://github.com/python-jsonschema/referencing"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/r/referencing/python3-referencing_0.36.2-1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "e972208ce8ea6f503dceb087133b4a0d"
SRC_URI[deb0.sha1sum] = "9ff2ac7d3ab598e8ddf943e944174ef3d91f6df8"
SRC_URI[deb0.sha256sum] = "225df288973a2930418f95d71f6ab075c0f0a1fbb5f42c44f53330738de9d89b"
SRC_URI[deb0.sha512sum] = "b828b07d9883d0f61df9a391312523ea938f5b44a04c1b2c419761161468b2009c329b110ae4ff1bd02d69298068203442b43f1e6b079afbeb32ab1be5036bd7"

RDEPENDS = " \
    python3 \
    python3-attr \
    python3-rpds-py \
    python3-typing-extensions \
"

