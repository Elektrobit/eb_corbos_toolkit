# This was autogenerated! Do not modify
SUMMARY = "Generate plurals, singular nouns, ordinals, indefinite articles (Python 3)"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "python-inflect"
HOMEPAGE = "https://github.com/jaraco/inflect"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python-inflect/python3-inflect_7.3.1-2_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "d6bac5268c01bf60ac7d69b1f3872ef5"
SRC_URI[deb0.sha1sum] = "ef426ce534d956caaa9ebf402ba3d71842502429"
SRC_URI[deb0.sha256sum] = "6c10dca4d4aa0eb0b4e16e8b62b74a073a8d22be8809c3f61c56b06fdd1451f8"
SRC_URI[deb0.sha512sum] = "8d49e40c573ad4169d57eeeb60da3e803f7b05cc50c41bbe511a64834df08ba9b7bb7d30fd105bf5c87b664125e69da4d26f92ebd5385d9e1224e6ae623b1f6f"

RDEPENDS = " \
    python3 \
    python3-more-itertools \
    python3-typeguard \
    python3-typing-extensions \
"

