# This was autogenerated! Do not modify
SUMMARY = "Debian helper tools for packaging Python libraries using PEP517"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "dh-python"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/d/dh-python/pybuild-plugin-pyproject_6.20250414_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "7d81534654afe75da2c09f73c6d06856"
SRC_URI[deb0.sha1sum] = "9bc46bb3e62417f5049e498b7edee05e030481ad"
SRC_URI[deb0.sha256sum] = "0d6dbc871eb80465d4d5bb28f250a64cbafe13eb639f942cde209ea6fa9960dc"
SRC_URI[deb0.sha512sum] = "366231741c29b192ff10526a32cc9b6ce318bd2a96b6b3276b49a587791e539c734ce49393fd4d9e58127f7d1673c55b5631214a03e27cb899f82c838b555693"

RDEPENDS = " \
    dh-python \
    python3 \
    python3-build \
    python3-installer \
"

