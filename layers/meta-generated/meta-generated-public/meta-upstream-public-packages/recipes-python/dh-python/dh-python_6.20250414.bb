# This was autogenerated! Do not modify
SUMMARY = "Debian helper tools for packaging Python libraries and applications"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "dh-python"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/d/dh-python/dh-python_6.20250414_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "f8607c682fcbe76def599cd75391ee90"
SRC_URI[deb0.sha1sum] = "611ae946658b292f35d3dba12a3a7cb39ea00e2a"
SRC_URI[deb0.sha256sum] = "9c93fc01e8ce00dffcbc37966569692dd7179af713b575e592892c0ed06201eb"
SRC_URI[deb0.sha512sum] = "a65a0cb0cc112ed2e545c8337efeeb83679eef759efd616396f4b59f6612d5af2bca275503d77eeeaf0c07081b2293cb72ead1a1c0095317e6e3c89b10919eca"

RDEPENDS = " \
    python3 \
"

RPROVIDES = " \
    dh-sequence-python3 \
"
