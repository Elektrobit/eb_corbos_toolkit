# This was autogenerated! Do not modify
SUMMARY = "library with routines for operating on iterables, beyond itertools (Python 3)"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "more-itertools"
HOMEPAGE = "https://github.com/more-itertools/more-itertools/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/m/more-itertools/python3-more-itertools_10.7.0-1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "f78708d4874fdc5c7c11f422ddb349dc"
SRC_URI[deb0.sha1sum] = "d1834339da2a1d07fa9e7cceb2b57e483f5e5321"
SRC_URI[deb0.sha256sum] = "385d785fa84261838732ec97627b4e95ec7399fc449d8a2aaaef66fb5f961c25"
SRC_URI[deb0.sha512sum] = "d46df7e45333121635d7fdbb3323cc3eefe61db7ee3faefa5f6b34973d7392c28e69ce204e5ef270ebf022864b1602d8722ba39e331270a70e99d509b58e6b18"

RDEPENDS = " \
    python3 \
"

