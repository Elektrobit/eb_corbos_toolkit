# This was autogenerated! Do not modify
SUMMARY = "Python 3 implementation of MessagePack format"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "python-msgpack"
HOMEPAGE = "https://pypi.python.org/pypi/msgpack"

inherit dpkg-prebuilt

DPKG_ARCH = "amd64"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python-msgpack/python3-msgpack_1.0.3-3+b4_amd64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "b5892df164868e09c9b99a4e0a9df19a"
SRC_URI[deb0.sha1sum] = "36f63b2cec298f848483163b8994d1662976cb2f"
SRC_URI[deb0.sha256sum] = "83e8cf382150fbc53397ef4bbb9a40cf5a5ed7e7d2865da6fe71985812af0957"
SRC_URI[deb0.sha512sum] = "94ea8442e9a6f3afa4b266cb7d426e6aecb93e3c31decb982d4b78f89e341c52ccb608474120bf8ba83f882f05d76c2bd54205e2fd08a8cc7ca3065a2b37d9e5"

RDEPENDS = " \
    libc6 \
    python3 \
"

