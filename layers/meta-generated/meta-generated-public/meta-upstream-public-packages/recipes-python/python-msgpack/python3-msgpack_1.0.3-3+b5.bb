# This was autogenerated! Do not modify
SUMMARY = "Python 3 implementation of MessagePack format"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "python-msgpack"
HOMEPAGE = "https://pypi.python.org/pypi/msgpack"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python-msgpack/python3-msgpack_1.0.3-3+b5_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "0575b25ebb954ff3e5083fbcd3e2d83e"
SRC_URI[deb0.sha1sum] = "184136ac0046052345e48c0def81db244f41bac1"
SRC_URI[deb0.sha256sum] = "1618ad9c6bcf3ec94872f56c150bc5e5daf2f21ea472964d534da0e6f99c1770"
SRC_URI[deb0.sha512sum] = "c4aadf081e54122c8862b471378e9a0e4d8a2ad121dba1b09cab2e77d724f250e6d48ea308bd42dc11ddbeaa023ec9d7a28446006eb28cd56fbd46eaff18abb6"

RDEPENDS = " \
    libc6 \
    python3 \
"

