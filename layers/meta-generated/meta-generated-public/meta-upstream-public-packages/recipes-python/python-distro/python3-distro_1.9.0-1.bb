# This was autogenerated! Do not modify
SUMMARY = "Linux OS platform information API"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "python-distro"
HOMEPAGE = "https://github.com/python-distro/distro"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python-distro/python3-distro_1.9.0-1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "20765f65ed43a8b444424add8564f2ab"
SRC_URI[deb0.sha1sum] = "3c6896c43817ee27c24eb3edcd401cecb35ffdff"
SRC_URI[deb0.sha256sum] = "b48975ae9c1c6fcc06301a3febeee390a817b21604576228807f7f37af458473"
SRC_URI[deb0.sha512sum] = "da6f5263785d0e2a716e351b0d2295334bb4d5688ee416822549cea6fccb9c7262970a6e6ac960130a95af1e88e45501af786334b9eef456c9600a969916f3f0"

RDEPENDS = " \
    lsb-release \
    python3 \
"

