# This was autogenerated! Do not modify
SUMMARY = "store and access your passwords safely"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "python-keyring"
HOMEPAGE = "https://github.com/jaraco/keyring"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python-keyring/python3-keyring_25.6.0-2_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "d2190d1066f27230f296c16600e8efa2"
SRC_URI[deb0.sha1sum] = "b72e8c88fac182c13eddd17eb5045763437a3b28"
SRC_URI[deb0.sha256sum] = "1b182df0202a422640fb8fa4391650ae1e8d14bc9235363c80a0ffd9651e6d01"
SRC_URI[deb0.sha512sum] = "e37300eef26197f946bc767cb50a9fb1f4f4664c275a88c807c38117212d512cfa6c12c17d4e78d850a99fcd5832d112cc6b8e7adcbee2417e7414f3c1b72675"

RDEPENDS = " \
    python3 \
    python3-importlib-metadata \
    python3-jaraco.classes \
    python3-jaraco.context \
    python3-jaraco.functools \
    python3-jeepney \
    python3-secretstorage \
"

