# This was autogenerated! Do not modify
SUMMARY = "Python3 module used in SELinux policy generation"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "selinux-python"
HOMEPAGE = "https://selinuxproject.org"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/selinux-python/python3-sepolgen_3.8.1-2_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "90f4ff471848d16845aefdfb6817b791"
SRC_URI[deb0.sha1sum] = "f661871d0cd53a2db0582eebb9cfccb7b41cb02a"
SRC_URI[deb0.sha256sum] = "e2ef5424b3f1c75d8b09716276ab9c9ddb8baac88ad51ae89709e82cfe9fa0e4"
SRC_URI[deb0.sha512sum] = "08849767b32a9b390ce77987c47dec19cefc728165a2b81d20dd833454402afa5ac185b8dba89bb63a65f3d18fe5c23dd2940f01f00badd4d74d1631b31de708"

RDEPENDS = " \
    checkpolicy \
    make \
    python3 \
    python3-selinux \
    python3-setools \
    semodule-utils \
"

