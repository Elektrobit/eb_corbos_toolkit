# This was autogenerated! Do not modify
SUMMARY = "Cross-platform colored terminal text in Python - Python 3.x"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "python-colorama"
HOMEPAGE = "https://github.com/tartley/colorama"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python-colorama/python3-colorama_0.4.6-4_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "59390c58d6a517265cd305dadee3578c"
SRC_URI[deb0.sha1sum] = "68bd153f902013ddfc0c8826974be04210eedabb"
SRC_URI[deb0.sha256sum] = "9b9b0991ea7a97312f9f74db9bc801c26120049ccf3f63c00c3f94025fc99fd6"
SRC_URI[deb0.sha512sum] = "c2a8617e8d56dc8481f74ad436fe46adf20a41e23cce36c3b63885b0b23caa2f9eb46cbbf46d7089d7ae927a7e6253f39c20574e11b76606924d24b7a641dc1a"

RDEPENDS = " \
    python3 \
"

