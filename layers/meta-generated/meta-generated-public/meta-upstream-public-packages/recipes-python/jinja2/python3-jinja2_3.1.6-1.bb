# This was autogenerated! Do not modify
SUMMARY = "small but fast and easy to use stand-alone template engine"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "jinja2"
HOMEPAGE = "http://jinja.pocoo.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/j/jinja2/python3-jinja2_3.1.6-1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "a858820d6d2cff1db2efc9de3ca8b8b6"
SRC_URI[deb0.sha1sum] = "72a91ddeaf42ad5c296ba50753b570e48eb41812"
SRC_URI[deb0.sha256sum] = "3271804134e18dbc8dbd146f58399817789373e86a58be44d10ce159cf8c4600"
SRC_URI[deb0.sha512sum] = "32415deab28077ab8a9844cb0bcfe64543392b31771974e8ba8ad229d6b4a55f1b4d9b483c418d993c35ec5d4fef663ed87611fa9d2854c38bb41ed19c5cd813"

RDEPENDS = " \
    python3 \
    python3-markupsafe \
"

