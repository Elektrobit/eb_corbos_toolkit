# This was autogenerated! Do not modify
SUMMARY = "Backport of PEP 654 (exception groups)"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "python-exceptiongroup"
HOMEPAGE = "https://github.com/agronholm/exceptiongroup/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python-exceptiongroup/python3-exceptiongroup_1.2.2-1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "40bc994db8de0192fb96810bddc93b53"
SRC_URI[deb0.sha1sum] = "939d1a784e40651cb9f6048bd75d13738b34fbd8"
SRC_URI[deb0.sha256sum] = "bbe83be6442ce748b060ab4968b672054479c02840f5ee16e7308c858731f900"
SRC_URI[deb0.sha512sum] = "d2fc1f3082e2269e75fcc4ea04ab8947bb1763c231b8b91abd95b37d0c8301bd8b71cf1096fc5b29f5cbe943ef56e33f06008aa8dbcef6d993c1f8f856b00a4f"

RDEPENDS = " \
    python3 \
"

