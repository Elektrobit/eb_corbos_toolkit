# This was autogenerated! Do not modify
SUMMARY = "Installer library for pbs (python-build-standalone)"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "python-pbs-installer"
HOMEPAGE = "https://github.com/frostming/pbs-installer"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python-pbs-installer/python3-pbs-installer_2025.04.09-1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "63872460b7f2d66b7d0d317bc2a904be"
SRC_URI[deb0.sha1sum] = "e3b438a31ee7ffd61d93fbe9ddec0c4814750730"
SRC_URI[deb0.sha256sum] = "24474f8e1afb4e9c5ffc1d0823eb08c08822d4a5cc60c837fa1b94560d781592"
SRC_URI[deb0.sha512sum] = "8f8d49dd12e57049cd253bef594e23972bad9ec41ba48f8d7386a686c843468dd9bd3eea654b232de1b07be236cc1c35f9367c1a9fa4e7911bbdc8a2256541cb"

RDEPENDS = " \
    python3 \
"

