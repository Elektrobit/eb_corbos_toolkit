# This was autogenerated! Do not modify
SUMMARY = "Python bindings for interfacing with Zstandard library"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "python-zstandard"
HOMEPAGE = "https://github.com/indygreg/python-zstandard"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python-zstandard/python3-zstandard_0.23.0-4_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python-zstandard/python3-zstandard_0.23.0-4_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "88b88a8ba5b6c2db0dd9e2e83a945ec9"
SRC_URI[deb0.sha1sum] = "d3ba0d36a009868b0c00cf0becc629b13ee3acb2"
SRC_URI[deb0.sha256sum] = "f1c14068258a19023e7b265c6673b0cbcd915c01a27e6cd77775b0408eca9b98"
SRC_URI[deb0.sha512sum] = "c2472c1133806daa4ba39ca248bf7f92a8aeaa26728af6755cb628d27d73a9016d6c328d9de3a34a682a25a4f0b8811a3d0b1f0279ae6c12fa0b841380237447"
SRC_URI[deb1.md5sum] = "a044882805e47ca4ff918c0cfe775727"
SRC_URI[deb1.sha1sum] = "9ede5664ebb31714ac81f0cd3208855efbf79044"
SRC_URI[deb1.sha256sum] = "22d9f435033af52971744e7a848d0091bb6215776373b7485854903fb58d2adf"
SRC_URI[deb1.sha512sum] = "9772e0081c13577eb8753d31c89da5e4827d58bc4c662cebbf48c9d3e65c54da3121e7099625929a63e590def9d59342af84272f3906986eb203cea6c3a7a744"

RDEPENDS = " \
    libc6 \
    libzstd1 \
    python3 \
    python3-cffi-backend-api-max \
    python3-cffi-backend-api-min \
"

