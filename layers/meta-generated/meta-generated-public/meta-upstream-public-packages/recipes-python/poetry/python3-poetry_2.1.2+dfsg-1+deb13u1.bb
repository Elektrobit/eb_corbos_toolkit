# This was autogenerated! Do not modify
SUMMARY = "Python dependency management and packaging made easy (Python 3)"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "poetry"
HOMEPAGE = "https://python-poetry.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/poetry/python3-poetry_2.1.2+dfsg-1+deb13u1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "4ff06cc905c33bfd799076138c7dffff"
SRC_URI[deb0.sha1sum] = "58e66136921e7155862b6b80cb5d7409a036713d"
SRC_URI[deb0.sha256sum] = "2bca8ff8333a1033ba98db15f145a826b75029792ff7fc02babef5ced46d5185"
SRC_URI[deb0.sha512sum] = "01614373eefbd724b1bc8ac83e42c2d9bf4ebe8790275876c9dfcc148ef640815f8852fbd05ccc84ac2fad7d2928c694a12bc9bbd87e104e6e9dd1c41ebb545c"

RDEPENDS = " \
    python3 \
    python3-build \
    python3-cachecontrol \
    python3-cleo \
    python3-dulwich \
    python3-fastjsonschema \
    python3-findpython \
    python3-importlib-metadata \
    python3-installer \
    python3-keyring \
    python3-packaging \
    python3-pbs-installer \
    python3-pkginfo \
    python3-platformdirs \
    python3-poetry-core \
    python3-pyproject-hooks \
    python3-requests \
    python3-requests-toolbelt \
    python3-shellingham \
    python3-tomli \
    python3-tomlkit \
    python3-trove-classifiers \
    python3-virtualenv \
"

