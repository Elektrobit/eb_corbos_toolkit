# This was autogenerated! Do not modify
SUMMARY = "ISO 8601 date/time/duration parser and formatter (Python 3 module)"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "isodate"
HOMEPAGE = "https://github.com/gweis/isodate/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/i/isodate/python3-isodate_0.7.0-1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "ac2bf82e14dec5a2123937ea37fb3d07"
SRC_URI[deb0.sha1sum] = "9cdba7c3cad69f5ebfc7f62fcc4e7c3eb3fa4ac4"
SRC_URI[deb0.sha256sum] = "d5057f458babdf68125528cb6db1d1ae2a89703da18e0ca664dd084e5bfcb2bc"
SRC_URI[deb0.sha512sum] = "27d92e09fcf49a24f9b23671658aaf0b17df9c9535a9946f302d920db4c305b9b70e775678860c1fee879d644e9e0a75634ddc6a3dd9d9ea2f992ba10edb4118"

RDEPENDS = " \
    python3 \
"

