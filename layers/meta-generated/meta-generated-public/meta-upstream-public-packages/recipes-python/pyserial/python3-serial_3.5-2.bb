# This was autogenerated! Do not modify
SUMMARY = "pyserial - module encapsulating access for the serial port"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "pyserial"
HOMEPAGE = "https://github.com/pyserial/pyserial"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/pyserial/python3-serial_3.5-2_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "714816c3acaacaba6179d2e20647c0af"
SRC_URI[deb0.sha1sum] = "9e2ce017b8f080350efdaff9375f6d346d30648f"
SRC_URI[deb0.sha256sum] = "55adf00b96ef91b1d8ad935d134c341f7c3dd021a5666cd53e75f37144006a51"
SRC_URI[deb0.sha512sum] = "9a945cfa053d6f3dbf89b6a59f2f88308804b91f9c3c964666d5df3d76702a581798672f7d15051a21a7631bf934cefc823a78111dbb73597691594b04c43601"

RDEPENDS = " \
    python3 \
"

