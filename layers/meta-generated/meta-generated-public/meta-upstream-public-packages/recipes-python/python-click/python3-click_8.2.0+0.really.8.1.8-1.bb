# This was autogenerated! Do not modify
SUMMARY = "Command-Line Interface Creation Kit - Python 3.x"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "python-click"
HOMEPAGE = "https://github.com/pallets/click"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python-click/python3-click_8.2.0+0.really.8.1.8-1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "ca515ad7e4fb16e0b170d744c4e9806c"
SRC_URI[deb0.sha1sum] = "1a5c153d546ae994eef42f98370cc388b7fda5e9"
SRC_URI[deb0.sha256sum] = "a464c9b11930f293c8808cc5ea049830d8645a0d314bfa7e294803cb983ee15e"
SRC_URI[deb0.sha512sum] = "91c1dbe9931efb87e0c3ce5e472aed4caa9b6cc4a246b5056a0816e78de426e728793a747f8596363782288ad03052106037041ac6b32777109d6158d0c29bca"

RDEPENDS = " \
    python3 \
"

