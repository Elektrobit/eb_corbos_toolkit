# This was autogenerated! Do not modify
SUMMARY = "Utility belt for advanced users of python3-requests"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "python-requests-toolbelt"
HOMEPAGE = "https://toolbelt.readthedocs.io/en/latest/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python-requests-toolbelt/python3-requests-toolbelt_1.0.0-4_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "44538463b8f05b161bcc15daa151aa39"
SRC_URI[deb0.sha1sum] = "c556be18861209d63d8cb48a53e85b6c9f234929"
SRC_URI[deb0.sha256sum] = "2858583d77b1596399124ce39dc8835e32b051aa16b2dae47160e94e7c924224"
SRC_URI[deb0.sha512sum] = "15cfeee9ecf644597ca13bf20b04948211730c7fd4ec8fb47daf6b2466930ff36168dea8ab0b9684524339f39ec32f661296b512de1932d2664af8fa75a2a67a"

RDEPENDS = " \
    python3 \
    python3-requests \
"

