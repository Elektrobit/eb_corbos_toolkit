# This was autogenerated! Do not modify
SUMMARY = "Alternative Kconfig implementation (Python 3)"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "kconfiglib"
HOMEPAGE = "https://github.com/ulfalizer/Kconfiglib"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/k/kconfiglib/python3-kconfiglib_14.1.0-4_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "9378e969ba837c64d38b5ab51f8d10e1"
SRC_URI[deb0.sha1sum] = "1703451f1f4e9dc78fc65e1f209147c0873368b4"
SRC_URI[deb0.sha256sum] = "cefdbaaf68c7d23b7afe018b451b46b72d8fe3540b623d0592066ee1df676be7"
SRC_URI[deb0.sha512sum] = "10e02a3c6e5029236185f37d5cf42f19bc3b8d2b4bcefe88d4eacb0d439f2e8ac6333b39fd89fc8344ea2e8efdc8b8158ab7dc3c15fbb2d5b82eab2bbd08a756"

RDEPENDS = " \
    python3 \
"

