# This was autogenerated! Do not modify
SUMMARY = "Pure Python Snowball stemming library"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "snowball"
HOMEPAGE = "https://snowballstem.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/snowball/python3-snowballstemmer_2.2.0-4_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "44a168242295031498a32a8756eeee72"
SRC_URI[deb0.sha1sum] = "d312d02f90beaf8dfab334af7c9d5033c8f583c1"
SRC_URI[deb0.sha256sum] = "0cfd9404618afdf7dc08c479a1687a17753a9c9222475478cb4fd2c848759f52"
SRC_URI[deb0.sha512sum] = "9bddb085ea3a3d70a290743082817f1d97c4641385eb66127b41aa8cae83a51d8fb10239d6523dacd006d62204299417a48f272753f22f2e82650a432022d6cb"

RDEPENDS = " \
    python3 \
"

