# This was autogenerated! Do not modify
SUMMARY = "pure-python3 library for parsing ELF and DWARF"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "python-pyelftools"
HOMEPAGE = "https://github.com/eliben/pyelftools"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python-pyelftools/python3-pyelftools_0.32-1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "5f83b6cd0cb0461e94f8c3d10b8a79a4"
SRC_URI[deb0.sha1sum] = "da1ace0114bf078a13b50634ed9fdbc125cedff6"
SRC_URI[deb0.sha256sum] = "812d79302b70b375e69b44ee19d2625f1da61f69165567bf4617e7a7dc393005"
SRC_URI[deb0.sha512sum] = "58e2be8f717b946130bb98ba7b9adf419d7342adc752bf0d70c066d5fbdf613d0b4625b8df089ed29db46103c6fedae42c3ba88c857cbb349c1a3bca1e1f7e6a"

RDEPENDS = " \
    python3 \
"

