# This was autogenerated! Do not modify
SUMMARY = "library to generate argparse parsers from function signatures"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "python-autocommand"
HOMEPAGE = "https://github.com/Lucretiel/autocommand"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python-autocommand/python3-autocommand_2.2.2-3_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "461a1e5ba2424d2c239ca0c4ea5e3dc8"
SRC_URI[deb0.sha1sum] = "1f0c6a41eb72472a2ad7b117323046ea1175519b"
SRC_URI[deb0.sha256sum] = "1e62ac22ff83466228c051c6c2402a40f521646e15b5aa54cf2391206a848bad"
SRC_URI[deb0.sha512sum] = "a21f299acc5e02f63335ebbe27249ebf0c032794b3ca0fb95e2edd2808bc4500be2d278865d79ec64645dc03a702ecb37d996780e18352de33df802107138805"

RDEPENDS = " \
    python3 \
"

