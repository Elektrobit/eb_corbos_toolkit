# This was autogenerated! Do not modify
SUMMARY = "pure-Python git object database (Python 3)"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "python-gitdb"
HOMEPAGE = "https://github.com/gitpython-developers/gitdb"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python-gitdb/python3-gitdb_4.0.12-1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "4f2c23ba68355a9edb19ffe6f275f40e"
SRC_URI[deb0.sha1sum] = "e06e3cbd042b99e49f975c8e22771cfb7dfa8846"
SRC_URI[deb0.sha256sum] = "e8624f8963e86fafeec049662cae86093ceac5839261fc705ca7bfebff8dc17d"
SRC_URI[deb0.sha512sum] = "0a70c7ee43a9c60cd36155f420d11371254957ed74224e2ead923c25f686b140a1d862c2b1ec9d0a232cfc1774adaccf1b8fbaf27542217770d1d6c864fbb080"

RDEPENDS = " \
    python3 \
    python3-smmap \
"

