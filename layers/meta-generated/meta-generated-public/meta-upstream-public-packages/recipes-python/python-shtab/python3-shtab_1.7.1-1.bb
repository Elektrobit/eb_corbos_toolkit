# This was autogenerated! Do not modify
SUMMARY = "Automagic shell tab completion for Python CLI applications"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "python-shtab"
HOMEPAGE = "https://docs.iterative.ai/shtab/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python-shtab/python3-shtab_1.7.1-1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "cf93739a6247986a08556cf510736790"
SRC_URI[deb0.sha1sum] = "25556672e0b7b084aee5bb83e17d69db98b58da4"
SRC_URI[deb0.sha256sum] = "4d5289dcfad466c94baa808d4b2347b271a469002878d00b968f665425d8793f"
SRC_URI[deb0.sha512sum] = "0c52ae667ee3ff80b962315197ed7d9e0284e3f14360641a4f8e2fd9ed5149a48e7f0fc3aa675d5ab3a4eab5bdd01dcb3ce6256f0790f1a712ad23b2d8cec6e6"

RDEPENDS = " \
    python3 \
"

