# This was autogenerated! Do not modify
SUMMARY = "Python 3 modules to work with Debian-related data formats"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "python-debian"
HOMEPAGE = "https://salsa.debian.org/python-debian-team/python-debian"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python-debian/python3-debian_1.0.1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "ea2116804dec44dfeb711819d7315d7e"
SRC_URI[deb0.sha1sum] = "ccf9e1f913251e201cf4b4e88e58cda050961028"
SRC_URI[deb0.sha256sum] = "41ab65cba82050e18b12afbf34040ffc7c3d6fe32152f0ae5f33b434f1d1e443"
SRC_URI[deb0.sha512sum] = "e731775c0d5fa4b75b7eefed73f89d44eeb67d34085bb4e40d5f6bfebd018c82c42d4ca8e8b820842c76f8bbaf09192234738220b1f4e275287a7800d721a233"

RDEPENDS = " \
    python3 \
    python3-charset-normalizer \
"

