# This was autogenerated! Do not modify
SUMMARY = "Fast property caching (Python)"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "python-propcache"
HOMEPAGE = "https://github.com/aio-libs/propcache"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python-propcache/python3-propcache_0.3.1-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python-propcache/python3-propcache_0.3.1-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "5e0ede48cae4f67ddfa6d0188731838d"
SRC_URI[deb0.sha1sum] = "7127121ac6c05bb7fa96c5ae1111408a3ffaf728"
SRC_URI[deb0.sha256sum] = "56882efac031febde7d7d202e52e685d340b88c433025efefc758564974767aa"
SRC_URI[deb0.sha512sum] = "2cc54d5d965dba938e6cb291e36ebc530765088bdf437499f3f387169e63475e6833d171f0c2cd3f21f9f420953a697e4fac7d8e6e85c2e19b62aae3d2a3dfa1"
SRC_URI[deb1.md5sum] = "6fe75cd8399fe2f63b750f31ea8df2d9"
SRC_URI[deb1.sha1sum] = "b5f8f2d997c09ec4850750e6853490403a638be0"
SRC_URI[deb1.sha256sum] = "70eede8f18e0ec8a6d86564a296206e70fff64749801eba1cbdc74c13415be23"
SRC_URI[deb1.sha512sum] = "5f09f3edb1f52aeebcd176e00e8c6702092fd1e159e8a49aaf00963ab037ea89ab73c387c77acb9cceebff0ceb016991899d8c3c79f8dee6da666802284b799e"

RDEPENDS = " \
    libc6 \
    python3 \
"

