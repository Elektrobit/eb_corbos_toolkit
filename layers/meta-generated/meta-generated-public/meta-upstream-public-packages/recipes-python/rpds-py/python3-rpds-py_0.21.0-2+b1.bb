# This was autogenerated! Do not modify
SUMMARY = "Python bindings to Rust's persistent data structures (rpds)"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "rpds-py"
HOMEPAGE = "https://github.com/crate-py/rpds"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/r/rpds-py/python3-rpds-py_0.21.0-2+b1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/r/rpds-py/python3-rpds-py_0.21.0-2+b1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "3aeedd577f57313d34fc6f55c424bd63"
SRC_URI[deb0.sha1sum] = "bef80a323cf18ba70d203fdbac2857e9bd8cb4e5"
SRC_URI[deb0.sha256sum] = "dd015869b0ba0663a8f252995329c2c630e11bd588f0018b63075a54b6c0a9f0"
SRC_URI[deb0.sha512sum] = "09ed0f1ac061f6e0b1095f51625e808790e1a1a758aea730f0c57fe86af145d880f4ea8778901c2ac28ed627a573bcf7bed9f561390ee7a2a8cc875aa56add55"
SRC_URI[deb1.md5sum] = "c783eb2285f49c3f5702be9a4397bfc3"
SRC_URI[deb1.sha1sum] = "821d1ead68314f00b0b324a008c83107effd2484"
SRC_URI[deb1.sha256sum] = "d8b6a629f87766a17d69ea84f2f96fc3dbf1e6dd01f922777654a418a37bee57"
SRC_URI[deb1.sha512sum] = "63ca7a9ae3a3a0ffd208f16e03e8a8bc677620b594553c470b785a9a6b6b1a96d43fd6cc82b600aaa105e8121cd59e2247331ef54b2ccefb3a693720856a957b"

RDEPENDS = " \
    libc6 \
    libgcc-s1 \
    python3 \
"

