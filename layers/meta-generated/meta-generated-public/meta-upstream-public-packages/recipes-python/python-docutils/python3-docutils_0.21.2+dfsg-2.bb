# This was autogenerated! Do not modify
SUMMARY = "text processing system for reStructuredText (implemented in Python 3)"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "python-docutils"
HOMEPAGE = "https://docutils.sourceforge.io/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python-docutils/python3-docutils_0.21.2+dfsg-2_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "ad1dc76ee054d412e3d3029bab98028f"
SRC_URI[deb0.sha1sum] = "55bbb4c67a9e5f80c2cd16d9f2b8049bcfae3d5f"
SRC_URI[deb0.sha256sum] = "342d7d5717940c2af9ebd6c7b5d34c80809fcc200fcbbba146e2088827b2e397"
SRC_URI[deb0.sha512sum] = "33c37b6326befc6be14405f9f7f97d3786211fad2ba23198cfb0706b58dd7c9581a1b21bba4fe58b1eda226060f2173e761f366757f2cf48e2123cf030bd7872"

RDEPENDS = " \
    docutils-common \
    python3 \
    python3-roman \
"

RPROVIDES = " \
    docutils \
"
