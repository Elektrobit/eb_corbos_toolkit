# This was autogenerated! Do not modify
SUMMARY = "text processing system for reStructuredText - common data"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "python-docutils"
HOMEPAGE = "https://docutils.sourceforge.io/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python-docutils/docutils-common_0.21.2+dfsg-2_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "e1f5ab4d5cbdd12f229abf55aa9e6f0f"
SRC_URI[deb0.sha1sum] = "c1364f6f9423224ef1704d6ad6da6548804bdcb8"
SRC_URI[deb0.sha256sum] = "6f1ec59c479376c8b6f75b7e4d2f5d2a6fb148d870ec2440a74fb1de8b2e561c"
SRC_URI[deb0.sha512sum] = "408a1f802cb2aa975c034e09804bc165159700c7300191d2656e5c1874f220527c434e75d420d9ed66c207dc8036c7767b5260f8eb168b901c92ee434e4fe3fc"

RDEPENDS = " \
    sgml-base \
    xml-core \
"

