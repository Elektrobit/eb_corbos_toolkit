# This was autogenerated! Do not modify
SUMMARY = "tool to create, manipulate and study complex networks (Python3)"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "networkx"
HOMEPAGE = "https://networkx.github.io/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/n/networkx/python3-networkx_3.2.1-5_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "291d38adfef0ddf0c583d503ce2a97ae"
SRC_URI[deb0.sha1sum] = "a08eb4542cefc644602df06bc050d2de18429498"
SRC_URI[deb0.sha256sum] = "161b9076a60132799b5a0555ace555681c6c4891c8c7b9eb6ec4b17b99e8eae8"
SRC_URI[deb0.sha512sum] = "8e4935c401b7ffdaa77dd2c54aa4693145fea78e3875601011b190de0e9db7bf3c9d60dc13ac76a52df742fffc1e3eaf2b777a0402f02638c74d01bdbd852471"

RDEPENDS = " \
    python3 \
    python3-pkg-resources \
"

