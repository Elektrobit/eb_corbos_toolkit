# This was autogenerated! Do not modify
SUMMARY = "create beautiful and testable command-line interfaces"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "python-cleo"
HOMEPAGE = "https://github.com/python-poetry/cleo"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python-cleo/python3-cleo_2.2.1-4_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "d608b594737008c483d7c6cca16f8cd3"
SRC_URI[deb0.sha1sum] = "29539956e3cf81b593e05a65854460994eac509f"
SRC_URI[deb0.sha256sum] = "06110c37d110f2ed70cfe791142a5fb5b584285591e3985c70323c58a7e16731"
SRC_URI[deb0.sha512sum] = "47c8e54414e543a3799d7224bb6d4b1fbf3f6e7d4c8df37b8edf378620191697384bbf47e409c690a94ebce9b59d8b07c3e03bd3f6a0650972889d7ff627f1c3"

RDEPENDS = " \
    python3 \
    python3-rapidfuzz \
"

