# This was autogenerated! Do not modify
SUMMARY = "list-like structure which implements collections.abc.MutableSequence"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "frozenlist"
HOMEPAGE = "https://github.com/aio-libs/frozenlist"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/f/frozenlist/python3-frozenlist_1.6.0-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/f/frozenlist/python3-frozenlist_1.6.0-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "4c3949a7eceb7b59125df8ba5dc92fb0"
SRC_URI[deb0.sha1sum] = "77782b0d813cbdc84047b0f6061941049a8cd80b"
SRC_URI[deb0.sha256sum] = "2c1f022873a051df7f199130cad2215f7dfdb42daa434308011cd646aa15f2ea"
SRC_URI[deb0.sha512sum] = "a464b2bf248cd0a5141953908b8accefa76609c91d61b13a45a0be6eb71ff9168356af4a949e8e86cf6b8dd1af17cc70d421ebcb9ea9907cb259542014a66288"
SRC_URI[deb1.md5sum] = "a3863fcce2a534bf2882eb6897f1f29c"
SRC_URI[deb1.sha1sum] = "06757509bdffec6c8dc9dfb32deef8ad6a8f46a4"
SRC_URI[deb1.sha256sum] = "258490a738fe5d0f339fe568c4f797d913964be04149fc826e6c40268f567530"
SRC_URI[deb1.sha512sum] = "5ad40cbef2660db2c2ce501187fcdcb2e9c217ae42f1437b32c92b0c597b49db8a1961c369669b74f6b716e9aa1d3f9d9f867d4a5037433b879db17905928f64"

RDEPENDS = " \
    libc6 \
    python3 \
"

