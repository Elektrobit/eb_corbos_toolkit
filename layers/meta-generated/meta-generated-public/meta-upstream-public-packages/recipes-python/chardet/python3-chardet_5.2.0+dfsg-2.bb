# This was autogenerated! Do not modify
SUMMARY = "Universal Character Encoding Detector (Python3)"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "chardet"
HOMEPAGE = "https://github.com/chardet/chardet"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/c/chardet/python3-chardet_5.2.0+dfsg-2_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "12d561036fe3a4e9119d3f4d335a5f9e"
SRC_URI[deb0.sha1sum] = "777db7400d16b92affe42fda3f016d2f19e4be4d"
SRC_URI[deb0.sha256sum] = "06d26a4755a176d56d3c68510fe35f394b86640003360b9c6ad047d9a35268bc"
SRC_URI[deb0.sha512sum] = "a5347ea4920ab32c7e38d24adb1d83ba27a0c2c3e21ff5d9d09762a49a4b01a805ed723613d9da996ce43a83dfc5f55d319e7c96e2c8b381a7e0e0a3b2568b57"

RDEPENDS = " \
    python3 \
"

