# This was autogenerated! Do not modify
SUMMARY = "library to access the metadata for a Python package - Python 3.x"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "python-importlib-metadata"
HOMEPAGE = "https://github.com/python/importlib_metadata"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python-importlib-metadata/python3-importlib-metadata_8.7.0-1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "4997a9f3d64ac7324c8c295c9b8cbc62"
SRC_URI[deb0.sha1sum] = "1d42f159c53cf51d9fed4edc4ec29854b1d5d92a"
SRC_URI[deb0.sha256sum] = "f895d1f4901176f5e75614bf95b98ccc2a6cd5017ba5ec727b29f281d29be1cd"
SRC_URI[deb0.sha512sum] = "37db7149534aec6e660fa304c96f4d6f2d9daba89b4d278ee172b5719e19a4f2a58fee57a92b3876b0af46d5b284ef42eec865cb1a7934f6bb0cac8420435c74"

RDEPENDS = " \
    python3 \
    python3-zipp \
"

