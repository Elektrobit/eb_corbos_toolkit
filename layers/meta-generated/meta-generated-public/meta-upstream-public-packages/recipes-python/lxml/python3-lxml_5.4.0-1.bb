# This was autogenerated! Do not modify
SUMMARY = "pythonic binding for the libxml2 and libxslt libraries"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "lxml"
HOMEPAGE = "http://lxml.de/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/l/lxml/python3-lxml_5.4.0-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/l/lxml/python3-lxml_5.4.0-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "b7002eca390ba2b571e79bfca33d502e"
SRC_URI[deb0.sha1sum] = "00bf31556fde583470226380cb407f383d0726b9"
SRC_URI[deb0.sha256sum] = "d3d2ae79d21d2433305a69d28bddf226331b3c13b5e53b71443f18366a425045"
SRC_URI[deb0.sha512sum] = "f6608d94d5bca5c40750bc4cd8c0ece8dabb051ca50700cb8af9506b67db42abb92f57c942c47de067a7a30ce80cc75fb4fe5b6bbd7f075aeb331e41728260d4"
SRC_URI[deb1.md5sum] = "c1e2734ae7c27eb3b8ea5c3563c353ce"
SRC_URI[deb1.sha1sum] = "55ba68eea575f31e01df8354930f3a5e2cd13e31"
SRC_URI[deb1.sha256sum] = "1c4ea541e963622080b00d28bb72e6a109452900c575e136400555230e56ce1c"
SRC_URI[deb1.sha512sum] = "a5ebb351e6e3f1e7f0f9e058570537d4fee1ff07cee17d994b2d11edf080b12ab94ae9cb771fd5d08097095a114c61f8d40094553e3a1d5c00375b26e2775647"

RDEPENDS = " \
    libc6 \
    libxml2 \
    libxslt1.1 \
    python3 \
"

