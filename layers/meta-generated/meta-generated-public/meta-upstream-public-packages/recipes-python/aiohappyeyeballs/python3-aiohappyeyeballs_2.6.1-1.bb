# This was autogenerated! Do not modify
SUMMARY = "Happy Eyeballs connection helper for asyncio"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "aiohappyeyeballs"
HOMEPAGE = "https://github.com/aio-libs/aiohappyeyeballs"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/a/aiohappyeyeballs/python3-aiohappyeyeballs_2.6.1-1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "1824a49c39554d8425d38db72858be3a"
SRC_URI[deb0.sha1sum] = "e2fb33c84a1a16c60754ba01da6ef6f299efaafd"
SRC_URI[deb0.sha256sum] = "b61208f9ef38dd86a9ed5c24c8a37b75a77925fe927651284fbb1b978b15b9f5"
SRC_URI[deb0.sha512sum] = "1b4f9fd607648f11a194058702f262b4176584ac2ad31536ff852f62a9babfbae58c1b338ae0d395586a099e6e0085a21b16a467a1831768627c8ff307b1c3ad"

RDEPENDS = " \
    python3 \
"

