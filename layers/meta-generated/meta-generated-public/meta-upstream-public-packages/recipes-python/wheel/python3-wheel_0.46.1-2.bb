# This was autogenerated! Do not modify
SUMMARY = "built-package format for Python"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "wheel"
HOMEPAGE = "https://github.com/pypa/wheel"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/w/wheel/python3-wheel_0.46.1-2_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "4ce05ec511db1f20d47046ad91d67ccf"
SRC_URI[deb0.sha1sum] = "2fbba653378a06d10f34f7625e38f775923995c4"
SRC_URI[deb0.sha256sum] = "17b788ad15f8231e5058ed386cd6841d42b31937075b56caf4cf63263910e992"
SRC_URI[deb0.sha512sum] = "df819cdd402f5fc82fc8a5bf3929b3ffda2c09505159ca10fe4b0d012ca59884f75d28c5e6dd578fce312622f4c5470b308bf58e3066f7fd1c17a3ec8ebefbc0"

RDEPENDS = " \
    python3 \
    python3-packaging \
"

