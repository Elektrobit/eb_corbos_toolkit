# This was autogenerated! Do not modify
SUMMARY = "Makes working with XML feel like you are working with JSON (Python 3)"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "python-xmltodict"
HOMEPAGE = "https://github.com/martinblech/xmltodict"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python-xmltodict/python3-xmltodict_0.13.0-1.1~deb13u1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "a16288197edb155f3eb63e540836092f"
SRC_URI[deb0.sha1sum] = "1c7768f323b982239a2410c2e4c4e861a32d15aa"
SRC_URI[deb0.sha256sum] = "c5b60c38fe3914a3d03ebb14fc8a2a2ced3af11fc56719b27a0d23d4633fb142"
SRC_URI[deb0.sha512sum] = "6fdc3db7f7264da21a409ec02f14b73a38cc27ee1841daa335a0770f2ebc957bdae5a87338f7f7b3047ea800e17db39a714ec2b06804f06fd40763523ac7ef3f"

RDEPENDS = " \
    python3 \
"

