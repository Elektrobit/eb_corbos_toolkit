# This was autogenerated! Do not modify
SUMMARY = "Backported and Experimental Type Hints for Python"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "python-typing-extensions"
HOMEPAGE = "https://typing-extensions.readthedocs.io/en/latest/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python-typing-extensions/python3-typing-extensions_4.13.2-1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "560794cc31bf5189a7fedb95a2fe2eba"
SRC_URI[deb0.sha1sum] = "91ba82322a896e61d4e6c18d6f4922145cff404c"
SRC_URI[deb0.sha256sum] = "b67662f211c35c17c74a0725bc7c8ffc3b126c650e2a2525593adee06f2bbf69"
SRC_URI[deb0.sha512sum] = "ed6444d2dff7437e803c3f0c1ad4cc85b98c493cfec740c9ba813fc693081a128b0c220da31e0ce96948ceb4000c1afc898d9ac4c53a0fbf30913a7fb88ba83a"

RDEPENDS = " \
    python3 \
"

