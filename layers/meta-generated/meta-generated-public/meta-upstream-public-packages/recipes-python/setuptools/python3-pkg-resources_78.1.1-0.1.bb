# This was autogenerated! Do not modify
SUMMARY = "Package Discovery and Resource Access using pkg_resources"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "setuptools"
HOMEPAGE = "https://pypi.python.org/pypi/setuptools"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/setuptools/python3-pkg-resources_78.1.1-0.1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "0851b7ee6ed95d98ee53ce8d413cf12b"
SRC_URI[deb0.sha1sum] = "00eb266dab14e105ed18f489a9f4e54a9c0c1810"
SRC_URI[deb0.sha256sum] = "cf8749251172abc945216cf878367f614cf91d3d9a1043ba3bacc5a74e8cc1a8"
SRC_URI[deb0.sha512sum] = "f68c0995b47c9f6dd685925f3960303653f3ce9647bee1e5e609043ab548fc8732b1f648aaf0010a50751f527111dfb4c0ed0c9f576ac59665b417aba83277fd"

RDEPENDS = " \
    python3 \
    python3-autocommand \
    python3-inflect \
    python3-jaraco.context \
    python3-jaraco.functools \
    python3-more-itertools \
"

