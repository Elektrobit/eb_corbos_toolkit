# This was autogenerated! Do not modify
SUMMARY = "Python3 Distutils Enhancements"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "setuptools"
HOMEPAGE = "https://pypi.python.org/pypi/setuptools"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/setuptools/python3-setuptools_78.1.1-0.1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "6e11f68e303b39cca6b4b38b37c85622"
SRC_URI[deb0.sha1sum] = "f06173b1018aa4e7ee5d229f5afb91e87604cc19"
SRC_URI[deb0.sha256sum] = "90c4bc8e311873e5b571b407ce6b1fd38195dff77f9de056301a0f950e6df5a5"
SRC_URI[deb0.sha512sum] = "bb242c068e39c43cb3fd425abf39978d86eb7fbbd86f043c78396cef712b3e124e2168e4e0b952df4aeb32e77d0e0cabcdaca90ccebcedba1a3d667a2d84c281"

RDEPENDS = " \
    python3 \
    python3-importlib-metadata \
    python3-jaraco.text \
    python3-more-itertools \
    python3-pkg-resources \
    python3-typeguard \
    python3-typing-extensions \
    python3-zipp \
"

