# This was autogenerated! Do not modify
SUMMARY = "Python Distutils Enhancements (wheel package)"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "setuptools"
HOMEPAGE = "https://pypi.python.org/pypi/setuptools"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/setuptools/python3-setuptools-whl_78.1.1-0.1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "e934bc86bda1f654ec0ea5424888cbf5"
SRC_URI[deb0.sha1sum] = "468cf3d650ab46d0f28d03542b09bff6d5fdf2e8"
SRC_URI[deb0.sha256sum] = "0caf134e73ab90ffeaa5ce2529d73ea7d48078b2a9251ed9d1b7b514a61e9483"
SRC_URI[deb0.sha512sum] = "c568e788dbbd1d2b75ab24cdff458296ddeb6cb4cb960d59b627431e898c8efff169226f4c2eb63008c059e71e46f4a0d5f6df99c87912696e92999b0ae5f9a4"


