# This was autogenerated! Do not modify
SUMMARY = "tools for internationalizing Python applications - Python 3.x"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "python-babel"
HOMEPAGE = "https://babel.pocoo.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python-babel/python3-babel_2.17.0-1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "3c5fb8d206661360418c099ab4c763ce"
SRC_URI[deb0.sha1sum] = "3506ef600276bc658f671718c73c9a0564311591"
SRC_URI[deb0.sha256sum] = "348523917260fe1d9a15d19c9ca6ac0751ec2d5385f9c1a26c9bc27a966ba9e1"
SRC_URI[deb0.sha512sum] = "45dd0f926d9300dd26941ba12828afbd8142f66f444677d57ced4311747c625760c49f05a9e3cdfefd03cd5524ee4b1c16bba13bc2d4bc31e441f0dfec9e3296"

RDEPENDS = " \
    python-babel-localedata \
    python3 \
"

