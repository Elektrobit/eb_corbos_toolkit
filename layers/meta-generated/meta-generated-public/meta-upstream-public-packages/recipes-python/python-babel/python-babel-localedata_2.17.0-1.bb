# This was autogenerated! Do not modify
SUMMARY = "tools for internationalizing Python applications - locale data files"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "python-babel"
HOMEPAGE = "https://babel.pocoo.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python-babel/python-babel-localedata_2.17.0-1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "9aacef16a23c19ab2fafe0b051acfcc0"
SRC_URI[deb0.sha1sum] = "0afbcccd80244e99da48a6b1c558ab787cd9d741"
SRC_URI[deb0.sha256sum] = "10fd7335fc0f568d046da0af7a6faaf3b57ede60bc77e9ded26ed4550e7d30c1"
SRC_URI[deb0.sha512sum] = "dd97a06410d4270027b44c3fcb4f364f4fda9d1c1cce52c68d5f115b94d26344f2a3307d54761756f84f0d893d0bd68034ba8d30cde9ef7c743737bc048d2380"


