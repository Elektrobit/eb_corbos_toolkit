# This was autogenerated! Do not modify
SUMMARY = "Python package installer"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "python-pip"
HOMEPAGE = "https://pip.pypa.io/en/stable/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python-pip/python3-pip_25.1.1+dfsg-1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "01ff59d7dc7e2eb59f6be07476667041"
SRC_URI[deb0.sha1sum] = "096127f318634c847e4eb6d252b6a498b81eb53b"
SRC_URI[deb0.sha256sum] = "065695050e5fe10f162201a5bbe8759837427c76c95b5fe57b0701bcd6070c56"
SRC_URI[deb0.sha512sum] = "187a70f0b24ca12efc477428901c18102975f054fe0bcee6a8a77b5a488b5e88c135b7716e09a87f99b1405f9b00bf7e20547af4127773637ae982500d743f6d"

RDEPENDS = " \
    ca-certificates \
    python3 \
    python3-wheel \
"

RPROVIDES = " \
    pip \
"
