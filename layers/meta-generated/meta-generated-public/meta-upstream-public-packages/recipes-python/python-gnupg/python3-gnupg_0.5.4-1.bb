# This was autogenerated! Do not modify
SUMMARY = "Python wrapper for the GNU Privacy Guard (Python 3.x)"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "python-gnupg"
HOMEPAGE = "https://github.com/vsajip/python-gnupg"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python-gnupg/python3-gnupg_0.5.4-1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "c1c27937a264df53fae19a3d8ddf0776"
SRC_URI[deb0.sha1sum] = "4a735b713fdb901bfe1db92dbb4d3a45406e3205"
SRC_URI[deb0.sha256sum] = "dd387dc84aa3bf59cff5b7794f1656d862b8d2df5da8ec379e83d00f4d21cb88"
SRC_URI[deb0.sha512sum] = "0545c9746de0df93e0ba8e69b2f397e792686f3c2e69eb7c38abaf8d75c9d5a2ec15c0f4ac5f16d1292e4d1b86db909a85a55ad7654b78db8ebb93a95ed539f2"

RDEPENDS = " \
    gnupg \
    python3 \
"

