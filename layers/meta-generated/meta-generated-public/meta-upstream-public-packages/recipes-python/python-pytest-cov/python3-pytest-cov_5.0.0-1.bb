# This was autogenerated! Do not modify
SUMMARY = "py.test plugin to produce coverage reports for Python3"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "python-pytest-cov"
HOMEPAGE = "https://github.com/pytest-dev/pytest-cov"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python-pytest-cov/python3-pytest-cov_5.0.0-1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "1e9d185776a305a9f453ba3e9284df57"
SRC_URI[deb0.sha1sum] = "edd93ffc11df0b3332453767ee5b6ca61d157e37"
SRC_URI[deb0.sha256sum] = "3fb06d5d34a5b7d25892fd1b21b27820ac420847ff9b624b90afae7f57a8ffda"
SRC_URI[deb0.sha512sum] = "fb59246df1345ceea3fd649a998d75cfcc2ae6b598ae926430d98cfc9f47ef4a144c5de60e2469f7128692dce99a23ffc7e1be548bf2c8ecb5bfde0ccb9305ef"

RDEPENDS = " \
    libjs-jquery \
    libjs-jquery-hotkeys \
    libjs-jquery-isonscreen \
    libjs-jquery-tablesorter \
    libjs-jquery-throttle-debounce \
    python3 \
    python3-coverage \
    python3-pytest \
"

