# This was autogenerated! Do not modify
SUMMARY = "formatter to use with the logging module of Python 3"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "python-colorlog"
HOMEPAGE = "https://github.com/borntyping/python-colorlog"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python-colorlog/python3-colorlog_6.9.0-1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "0866108dfdca0309602f65738a688b3d"
SRC_URI[deb0.sha1sum] = "21c505b59ce88482bc6892a087fb92bc28124751"
SRC_URI[deb0.sha256sum] = "19a56ac0aac64d3bd24c2cdfbeafed1b376b46522fe8cb63dabea8a797ac08e4"
SRC_URI[deb0.sha512sum] = "d2cfc778b7f6f6ec409717773ce8245f4bf5cd67fd598af9a97d034e0424151165fd00869a6d341ba7382d2c4ffc6406460f1aacf01a23b863eba2258ee9b408"

RDEPENDS = " \
    python3 \
"

