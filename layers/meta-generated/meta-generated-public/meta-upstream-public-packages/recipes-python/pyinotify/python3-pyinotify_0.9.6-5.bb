# This was autogenerated! Do not modify
SUMMARY = "simple Linux inotify Python bindings"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "pyinotify"
HOMEPAGE = "https://github.com/seb-m/pyinotify"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/pyinotify/python3-pyinotify_0.9.6-5_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "e66114e4fb74ede2ea8d29ba3b88f8d9"
SRC_URI[deb0.sha1sum] = "c51e6b1278cbda044dfccc7c0e57c039abd89a44"
SRC_URI[deb0.sha256sum] = "10517cb846fe7ec7baa9a4abeedb48d45c61d864c9b4971363c3a27c7ad0eece"
SRC_URI[deb0.sha512sum] = "fbb2cb397806f7c773fb010b1d0c3b7eb9cc2b0d6ac32eadf66de3e27cded7dedd791a75d3f58318c09ef079150e806e55741758c984c3b6b8c17a3c808d366c"

RDEPENDS = " \
    python3 \
    python3-pyasyncore \
"

