# This was autogenerated! Do not modify
SUMMARY = "Automated checks on pyproject.toml by JSON Schema definitions"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "python-validate-pyproject"
HOMEPAGE = "https://github.com/abravalheri/validate-pyproject"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python-validate-pyproject/python3-validate-pyproject_0.24.1-1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "33f080f956c12a084189d50b7577fc30"
SRC_URI[deb0.sha1sum] = "4c68d18eed028aa840672efe030b079b48db9632"
SRC_URI[deb0.sha256sum] = "e1b8d2e7ae3e189fe878307ccac046763540a86ca95009d1c1f4f4d921c796ff"
SRC_URI[deb0.sha512sum] = "f77094ef41b4ff2b080b60ea2d8e6fd1046c96c066796dc09837d76eeb5215d104bb627c43b2b72eb974dee84a9d264a97a4a942ced80702aeb38cde87112c0e"

RDEPENDS = " \
    python3 \
    python3-fastjsonschema \
"

