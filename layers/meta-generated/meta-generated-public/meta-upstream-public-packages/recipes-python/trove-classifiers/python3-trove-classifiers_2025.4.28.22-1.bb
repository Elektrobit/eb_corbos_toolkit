# This was autogenerated! Do not modify
SUMMARY = "Validates classifiers in packages for PyPI"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "trove-classifiers"
HOMEPAGE = "https://github.com/pypa/trove-classifiers"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/t/trove-classifiers/python3-trove-classifiers_2025.4.28.22-1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "8bbd3b2ea4f1731cd8ea6aa15f6b0425"
SRC_URI[deb0.sha1sum] = "ee067cfaeb10fce65949d9f367b0781e6f83833f"
SRC_URI[deb0.sha256sum] = "874162ed71f249a2694d192473a419d6ada0284a8428d9c705f1fcac6b3b2875"
SRC_URI[deb0.sha512sum] = "786feb0a12787b727a018bde23cb6a767cf8eb67ff3d2791ea875c9702de143e942b1f6bfc3e6068a1ed6c0ebe8eb66dbd8fbd3f048c82b6e67fe66248eff6f9"

RDEPENDS = " \
    python3 \
"

