# This was autogenerated! Do not modify
SUMMARY = "HTTP library with thread-safe connection pooling for Python3"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "python-urllib3"
HOMEPAGE = "https://urllib3.readthedocs.org"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python-urllib3/python3-urllib3_2.3.0-3+deb13u2_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "3c13f562ddc4a8038b2298c829669b27"
SRC_URI[deb0.sha1sum] = "0d5726d1fc60b70a3220175f69052e692e788b02"
SRC_URI[deb0.sha256sum] = "8132c30c09060562e540025a5d5b1ee9dd3496234c36eab57339e8b94f9e6b38"
SRC_URI[deb0.sha512sum] = "fb05eaabd0657e371503a9c2b8c037bd31cd770110ebf32b970cdfaea725d321e97bd1fb968dd9ec04acbf58ccbc9a753c1a7a18aa48f941d4884839e1ca42df"

RDEPENDS = " \
    python3 \
"

