# This was autogenerated! Do not modify
SUMMARY = "Configurable sidebar-enabled Sphinx theme (Python 3)"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "alabaster"
HOMEPAGE = "https://github.com/sphinx-doc/alabaster"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/a/alabaster/python3-alabaster_0.7.16-0.1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "8495d39a65c5685318bc7a8b1ad1c631"
SRC_URI[deb0.sha1sum] = "af05915d36018ec7aa369fe8528ee73d3f545be2"
SRC_URI[deb0.sha256sum] = "dd30601f0be861dabef81e0bc49fa760cc5665658f0fd4f7a2d42a8c56651bab"
SRC_URI[deb0.sha512sum] = "88aadf1c1a3fa77959d81ce0fa60ed427d357df4e8bf0525807955bbb48bdcc13b49e09c6b13e4eb69fb36a2bf77c78d654742ca4361820f385cf64efd49e694"

RDEPENDS = " \
    python3 \
"

