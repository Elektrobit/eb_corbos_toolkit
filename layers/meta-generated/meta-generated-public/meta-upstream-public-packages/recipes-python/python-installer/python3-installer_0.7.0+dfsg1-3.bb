# This was autogenerated! Do not modify
SUMMARY = "Python library for unpacking and installing wheels"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "python-installer"
HOMEPAGE = "https://github.com/pypa/installer/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python-installer/python3-installer_0.7.0+dfsg1-3_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "4013df131ba00bcca3124e7b8e7dc051"
SRC_URI[deb0.sha1sum] = "c9b52476b5ac0ff9265210c257910206a430911a"
SRC_URI[deb0.sha256sum] = "0fb5d2cc9a2f26e86b20ad3f84628791ed12000c833eeb927074d2ced7f2406e"
SRC_URI[deb0.sha512sum] = "963546d3a7bc2389a7735727843b02658ddac4324d5ce6f3d1200de7486f3f5b095cf106141c135454b00f9ddc848333d70542b07e626b593a386e752049fee7"

RDEPENDS = " \
    python3 \
"

