# This was autogenerated! Do not modify
SUMMARY = "package depending on all supported Python 3 runtime versions"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "python3-defaults"
HOMEPAGE = "https://www.python.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python3-defaults/python3-all_3.13.5-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python3-defaults/python3-all_3.13.5-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "a8e0af876c56d6f70cf6e505082d1416"
SRC_URI[deb0.sha1sum] = "5051f580577812d598f341bee13093e8c7698ab3"
SRC_URI[deb0.sha256sum] = "86990e7f6d323a02f1074694b5987a7b80fb3c16f6b0d3d92cd0edb7f2e3f6e7"
SRC_URI[deb0.sha512sum] = "43e64cd8372fbec66116de93271d331f3d7e45a212baea074f90e84c6dc3852f3b8e4fead9032a69f4b20148300a262bc5eaf5194c561260b8ebbabeb96fc5a8"
SRC_URI[deb1.md5sum] = "a4bddf193053914f25894f033d15b228"
SRC_URI[deb1.sha1sum] = "595f05b62ff84ef45c1de13bb0cb17e8a0d803c8"
SRC_URI[deb1.sha256sum] = "d66295542f123c09f6efdfc4b0fdbeb8193554f56f7f442a332b50f0e2358f13"
SRC_URI[deb1.sha512sum] = "97659604f66ddc8d16a5721b343d99845072955d73e218ba93d3fbb47dc3f9eb645be17ef576f001fc93f21dc982bc1e78b0e73366b32b13a27b0d540bce8610"

RDEPENDS = " \
    python3 \
    python3.13 \
"

