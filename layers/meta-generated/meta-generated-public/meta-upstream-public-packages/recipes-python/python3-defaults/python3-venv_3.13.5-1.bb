# This was autogenerated! Do not modify
SUMMARY = "venv module for python3 (default python3 version)"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "python3-defaults"
HOMEPAGE = "https://www.python.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python3-defaults/python3-venv_3.13.5-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python3-defaults/python3-venv_3.13.5-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "06eb4a50aa81eb96599f90d419e1f59c"
SRC_URI[deb0.sha1sum] = "03ed9b9f02c0554edd95f24412fcb17bf625cb50"
SRC_URI[deb0.sha256sum] = "744ea5038e645ed22299e1bca47f76169b5665dd640df3492bdd1e21eba6cb76"
SRC_URI[deb0.sha512sum] = "a0b2542281af82d5fb4c0b917a1b41ef2846a0aa4d4554a1e56ff4732dbeb67f429e6a78330da36847080bc976d031a98287d58ef632dadccc5737cfc5f29833"
SRC_URI[deb1.md5sum] = "e770df9d79c378a41aebdb344cbeb500"
SRC_URI[deb1.sha1sum] = "d7985d1e03ad54b918c1c5a5dc72f59bb7c58164"
SRC_URI[deb1.sha256sum] = "08d23753825316cbffb69011c9cda39a6cc4adc4d51ea808c8d68d9981573dda"
SRC_URI[deb1.sha512sum] = "71aa6607ffc1d7211d6dd0a83e7de5b4a623f5534861a9bea05e3156623da4bcef377d26bce7f6ff6d328afb9e9ae3b9722e7f26211a676b86a95c4a9085dc0f"

RDEPENDS = " \
    python3 \
    python3.13-venv \
"

