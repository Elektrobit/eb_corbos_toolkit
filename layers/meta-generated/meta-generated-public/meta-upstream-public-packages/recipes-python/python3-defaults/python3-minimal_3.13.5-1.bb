# This was autogenerated! Do not modify
SUMMARY = "minimal subset of the Python language (default python3 version)"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "python3-defaults"
HOMEPAGE = "https://www.python.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python3-defaults/python3-minimal_3.13.5-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python3-defaults/python3-minimal_3.13.5-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "5acbb619c9e67bed95260f0bde46458e"
SRC_URI[deb0.sha1sum] = "42c052a6da47f6af554a65b5dd9f80e1da07ef1e"
SRC_URI[deb0.sha256sum] = "a5d2371bebf3689f676e3f3bae800371bcc4392a8a51269e23d528249b399615"
SRC_URI[deb0.sha512sum] = "bac0319d11487f02b936fd16b799b6b0c6fdb4f6c9bc346ecfa0fb3f0ad67489506428188c1bf0078186ab5610e3868c4c10939464f2b5ded27c2b5538055d2d"
SRC_URI[deb1.md5sum] = "5194772fa15e63a02ab686eb293e17ca"
SRC_URI[deb1.sha1sum] = "9473427ce7c7cc62e7fae135e7bda6769ae04890"
SRC_URI[deb1.sha256sum] = "b1dff61d3e68c83c747b03399356ba707d491bcaf6e495b575d46be3143cdec8"
SRC_URI[deb1.sha512sum] = "6a49178272132b6395344f4753d1fc7da8c791cd9ffb2dd28252508d83ebc364275def4801b64115f4f630c03a6cbd7315427b7e904fc9e0a6ece34e5b4bb762"

RDEPENDS = " \
    dpkg \
    python3.13-minimal \
"

