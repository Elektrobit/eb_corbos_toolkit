# This was autogenerated! Do not modify
SUMMARY = "interactive high-level object-oriented language (default python3 version)"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "python3-defaults"
HOMEPAGE = "https://www.python.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python3-defaults/python3_3.13.5-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python3-defaults/python3_3.13.5-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "fb41f849989ec17a43fa35f6cf3e43f3"
SRC_URI[deb0.sha1sum] = "c4bc1927409f9fb90398eff167fe0344eaacbf17"
SRC_URI[deb0.sha256sum] = "c1388174dc7140e6c19a6dd39f8a0dcb38a835cd66c65644e0dded43d5223cb0"
SRC_URI[deb0.sha512sum] = "727429974b9e50b5eb450260714b6359c1a0e47b5c9534ab7948c58ca323f03e24d8883465e10cfcbbc8ea18e12f19baeb0c1b52ce552512ba47713e35b2e357"
SRC_URI[deb1.md5sum] = "e0dc793adc765e706ee1f5eb029c7197"
SRC_URI[deb1.sha1sum] = "66b9cc9a8247182518f6158acfe30679c72ef07e"
SRC_URI[deb1.sha256sum] = "8d5be256bf3bb4f07afce1aa86f0595c6939e1a6c2ea939bdcb7b36351cbe021"
SRC_URI[deb1.sha512sum] = "56241bad8efb1d163a933f486447685070dab15d0e08a113545ef8748531c4f7539d84bed9f980a78b30177254f23d29c0fe93c1728e0e184615883a6a262f0b"

RDEPENDS = " \
    libpython3-stdlib \
    python3-minimal \
    python3.13 \
"

RPROVIDES = " \
    python3-profiler \
    python3-supported-max \
    python3-supported-min \
"
