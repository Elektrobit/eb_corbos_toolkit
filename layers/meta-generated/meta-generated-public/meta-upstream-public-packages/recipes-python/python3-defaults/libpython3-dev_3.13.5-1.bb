# This was autogenerated! Do not modify
SUMMARY = "header files and a static library for Python (default)"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "python3-defaults"
HOMEPAGE = "https://www.python.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python3-defaults/libpython3-dev_3.13.5-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python3-defaults/libpython3-dev_3.13.5-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "45e6d0ff8f3364a3e0625230c43002c6"
SRC_URI[deb0.sha1sum] = "2af36f7a534bb771add4443df4fdf9a34a6c471f"
SRC_URI[deb0.sha256sum] = "da4acbba1c79f037d2d24635fbae22850640e716b0d95dbed33cb9d1f698a24b"
SRC_URI[deb0.sha512sum] = "89c38bb1a38dba10a5a5b9a31bc10d03703ef72f7ab850cf3c129cbdbd0a64292afd526d17a1f56abf8f4fb9763d5ae5fef019b3f6e1f18351dfb3e28498f6c6"
SRC_URI[deb1.md5sum] = "755905dd1bb47e6efa116449756e2061"
SRC_URI[deb1.sha1sum] = "68c58ca6f57db108e43b17a1f32a0a8b2d8e6b89"
SRC_URI[deb1.sha256sum] = "c5475e33344f1f40375de63bedb02fadb532180de140d37aca9fbd69756642b5"
SRC_URI[deb1.sha512sum] = "8f781d820748d7f1ef15a9d41dce9a7c9298d47644102d4ff42801274f455d08fbe86ac19a22683920d4ba161c8e27968d60f9936f3914f3020c93d93863cde2"

RDEPENDS = " \
    libpython3.13-dev \
"

