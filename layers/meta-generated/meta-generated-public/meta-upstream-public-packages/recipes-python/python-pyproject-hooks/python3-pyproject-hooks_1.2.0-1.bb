# This was autogenerated! Do not modify
SUMMARY = "Wrappers to call pyproject.toml-based build backend hooks"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "python-pyproject-hooks"
HOMEPAGE = "https://github.com/pypa/pyproject-hooks"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python-pyproject-hooks/python3-pyproject-hooks_1.2.0-1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "fd25413dabd0ac1a2a4d58bd517e6c92"
SRC_URI[deb0.sha1sum] = "dfd6cf60b283fdbf57dcb5a0fa0c9c39f704c6c2"
SRC_URI[deb0.sha256sum] = "c31cbf03858dbbc8000f528fa785ba6c04bf9410f38270354df3537eef2ccffc"
SRC_URI[deb0.sha512sum] = "9ac34166c2c22ae7895e961cf8d9e5568046e5d1fb349093d9c2f387df525b23978b8d0f91abe220c8551d45388117541d3be4a4db7558eff210330a5fbbc673"

RDEPENDS = " \
    python3 \
"

