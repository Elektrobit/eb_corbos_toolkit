# This was autogenerated! Do not modify
SUMMARY = "alternative to creating and executing simple grammars - Python 3.x"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "pyparsing"
HOMEPAGE = "https://github.com/pyparsing/pyparsing/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/pyparsing/python3-pyparsing_3.1.2-1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "6947956b6b086c76f790375f91b1d729"
SRC_URI[deb0.sha1sum] = "b09d3133e0d35839761eeddfd1ac0886911ef816"
SRC_URI[deb0.sha256sum] = "f784864f3835bc7e62391350418f28958cc004f1d46690a5c03300ec0a9bcc54"
SRC_URI[deb0.sha512sum] = "832b5f950ea70a896a5a4ccd2c00080ef82ddd4ec5ded1c5961210442ce9ef1f74481570549e9acaf27ad7b819548acf2235ae460876b694b17dd41ca76a0c59"

RDEPENDS = " \
    python3 \
"

