# This was autogenerated! Do not modify
SUMMARY = "determining appropriate platform-specific directories (Python 3)"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "platformdirs"
HOMEPAGE = "https://github.com/platformdirs/platformdirs"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/platformdirs/python3-platformdirs_4.3.7-1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "b27d7641a60d674fe3cc9031f4cb0600"
SRC_URI[deb0.sha1sum] = "09bf7815144bdbe8bd21b459f3ccdb6252f3c0d2"
SRC_URI[deb0.sha256sum] = "53e10f9029f195496f26f224f7166e9a5dceb58cc0242a9b167485bfc16a4b97"
SRC_URI[deb0.sha512sum] = "df7fdacfbad8eea0bcdae3b4ca2e5672e703c41042d1ae5d3c7255bd5533772b9ee3f485351a788e2b6599cf5d3023c922355d313d67350e6514da48bd272101"

RDEPENDS = " \
    python3 \
"

