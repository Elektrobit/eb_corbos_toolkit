# This was autogenerated! Do not modify
SUMMARY = "elegant and simple HTTP library for Python3, built for human beings"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "requests"
HOMEPAGE = "https://requests.readthedocs.io/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/r/requests/python3-requests_2.32.3+dfsg-5+deb13u1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "70a92fb394a309ab49065c339f459752"
SRC_URI[deb0.sha1sum] = "ad7897c5c8b375b79a98edf7280807f5dd1529ff"
SRC_URI[deb0.sha256sum] = "7d271bd47c6647b16aec9facc656c39eca763062ec392aea615dd6597b8304c2"
SRC_URI[deb0.sha512sum] = "6997564f5e7974e0a09bb4d4902ab1e3f1ba7a0907d5d4a8a966f22dab6fa7d29d977f861b3d9adbc0279e74b331950c71debb82f0282eb02b705f0e4f7ac320"

RDEPENDS = " \
    ca-certificates \
    python3 \
    python3-certifi \
    python3-chardet \
    python3-charset-normalizer \
    python3-idna \
    python3-urllib3 \
"

