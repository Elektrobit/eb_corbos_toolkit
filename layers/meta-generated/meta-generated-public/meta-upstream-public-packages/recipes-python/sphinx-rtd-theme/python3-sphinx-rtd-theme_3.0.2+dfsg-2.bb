# This was autogenerated! Do not modify
SUMMARY = "sphinx theme from readthedocs.org (Python 3)"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "sphinx-rtd-theme"
HOMEPAGE = "https://github.com/readthedocs/sphinx_rtd_theme"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/sphinx-rtd-theme/python3-sphinx-rtd-theme_3.0.2+dfsg-2_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "6975e4d80dd05c4359ddc406151a73bc"
SRC_URI[deb0.sha1sum] = "10d6c3a58fc90525a873066253e63bd4236d1f48"
SRC_URI[deb0.sha256sum] = "189bf46643ecd50556e60e5fcca5cb37b31bd563564eb1a14f61742cdb3851fa"
SRC_URI[deb0.sha512sum] = "0ee6cba6fa41d3f14d49a69e47d610a340aaabb76286953dd0af635153ec2e0cff9ce70fa32e7deb2f09b4fbb971f583bc65e60339f4f55ce4a2daa65feba12f"

RDEPENDS = " \
    python3 \
    python3-docutils \
    python3-sphinx \
    python3-sphinxcontrib.jquery \
    sphinx-rtd-theme-common \
"

