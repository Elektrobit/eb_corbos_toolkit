# This was autogenerated! Do not modify
SUMMARY = "Python3 bindings for security auditing"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "audit"
HOMEPAGE = "https://people.redhat.com/sgrubb/audit/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/a/audit/python3-audit_4.0.2-2+b2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/a/audit/python3-audit_4.0.2-2+b2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "d885b51ef7c2dab8dbbc73e1925c284b"
SRC_URI[deb0.sha1sum] = "cf0f4459c77051f9d6b64fd1b7a973ee3c8e1bb1"
SRC_URI[deb0.sha256sum] = "8c648221250ed659bd62fbd6d8636d8adfee68ba3b543cec5bee251ec73857d0"
SRC_URI[deb0.sha512sum] = "2e7c68d4059d69a8203413bf433f96f9990d1540145fc5b61dd2ce08a00a3322224747b378cb9c3739c8f348354e01ad2058220b99fbf13a6320ad9bb5263471"
SRC_URI[deb1.md5sum] = "1dc766af24d9f70873d5a81da1181bd2"
SRC_URI[deb1.sha1sum] = "5a3e49c426d06efde7ef033c9573d8f27daa4330"
SRC_URI[deb1.sha256sum] = "e3795d8e9117a2e48cc602c9f128aa621b406e0e4a0c52cc33547239097f4a55"
SRC_URI[deb1.sha512sum] = "8e8142faedf2d560234842579c00317996243710aae795b89cc57ad69744913fcbfbdcab49f2516a7622c66934f8013973391e39511969b3d02b7865fb8fc06c"

RDEPENDS = " \
    libaudit1 \
    libauparse0t64 \
    libc6 \
    python3 \
"

