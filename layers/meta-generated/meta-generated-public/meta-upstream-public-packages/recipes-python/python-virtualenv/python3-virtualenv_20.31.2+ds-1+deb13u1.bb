# This was autogenerated! Do not modify
SUMMARY = "Python virtual environment creator"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "python-virtualenv"
HOMEPAGE = "https://virtualenv.pypa.io/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python-virtualenv/python3-virtualenv_20.31.2+ds-1+deb13u1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "a28e14f5047b5f76d8b50c7dc8bcc688"
SRC_URI[deb0.sha1sum] = "24f63a182d369f450166aaa6e235fa12ef35a959"
SRC_URI[deb0.sha256sum] = "a3af56f9172dceaf7ad10fb189b9021833585e8b79569a3f04a230a6d6886aa2"
SRC_URI[deb0.sha512sum] = "3ec94a07ffb407752d13e77e7591aa107b4c5161f5f044556724e5bb87ff6177889fe6eb65e3f64a1716c0311db3e1e9944f23bed8b6c6658f7a4fd9929f46b7"

RDEPENDS = " \
    python3 \
    python3-distlib \
    python3-filelock \
    python3-pip-whl \
    python3-platformdirs \
    python3-setuptools-whl \
"

