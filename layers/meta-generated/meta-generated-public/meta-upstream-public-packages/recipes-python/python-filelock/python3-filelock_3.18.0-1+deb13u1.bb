# This was autogenerated! Do not modify
SUMMARY = "platform independent file locking module"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "python-filelock"
HOMEPAGE = "https://github.com/tox-dev/filelock"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python-filelock/python3-filelock_3.18.0-1+deb13u1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "ffc75cf61beaa9b42001b73ced73011b"
SRC_URI[deb0.sha1sum] = "1ed7adf9104617c471f693b593d2449d64c8e6d1"
SRC_URI[deb0.sha256sum] = "809dc431ac61c4b12ee4f399a510fb5aaea4e6e5f90dd44190a14d96ad40604f"
SRC_URI[deb0.sha512sum] = "43137449ca36bc7e13cf7a68a17eab07aad1024d296e2a42fe450c76dadeb04675d1a1093c225e8702ec79648c1b0f6f4458a32a5d21781dcb16b6b68d895458"

RDEPENDS = " \
    python3 \
"

