# This was autogenerated! Do not modify
SUMMARY = "yet another URL library for Python"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "yarl"
HOMEPAGE = "https://github.com/aio-libs/yarl/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/y/yarl/python3-yarl_1.19.0-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/y/yarl/python3-yarl_1.19.0-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "d21bee70a4793858bc7d4c0c490224ef"
SRC_URI[deb0.sha1sum] = "2a82739076c7b9450c83f2a31fce3878f89dba8c"
SRC_URI[deb0.sha256sum] = "ad6ebe1877eceb74615d6c5abf9e1f72a44d8d5de2e97b605a0fd2237d0e4841"
SRC_URI[deb0.sha512sum] = "d394b55e51ddb98d241094a4918fdb09d60f7dc24e5f6266327d00c2e5e90c1795c1e56e5c1d4745ee756de2de4ea90da196c6b33662c17f9730fdc2c99ccf84"
SRC_URI[deb1.md5sum] = "23bcf1d9a3f09b41a118da281e402db3"
SRC_URI[deb1.sha1sum] = "3a69e02c23d855168329008e7f99abf74ca2157f"
SRC_URI[deb1.sha256sum] = "565b177b72f34af86e21b208b2e7ae86fddf40a9e84eafca82d995953892e095"
SRC_URI[deb1.sha512sum] = "d4b26c55544994470fc4d92630a72d4b56bf8c4775243a289990c465c8027b3f2ea356fabe52ecd4b309425caf734acfea677eb7626cf8edc1c679fb9cc0f04e"

RDEPENDS = " \
    libc6 \
    python3 \
    python3-idna \
    python3-multidict \
    python3-propcache \
"

