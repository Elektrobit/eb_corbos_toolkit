# This was autogenerated! Do not modify
SUMMARY = "password hashing library for Python 3"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "python-bcrypt"
HOMEPAGE = "https://github.com/pyca/bcrypt"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python-bcrypt/python3-bcrypt_4.2.0-2.1+b1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python-bcrypt/python3-bcrypt_4.2.0-2.1+b1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "8c1005eca459872059ddf815e5faee72"
SRC_URI[deb0.sha1sum] = "ba640d637a01e50aa295a53009bea3da73019e00"
SRC_URI[deb0.sha256sum] = "7485d96fc2669e9407056474c61aea5bd83ef5f406b46a1d7500ae17fab0a830"
SRC_URI[deb0.sha512sum] = "6f3d8e3e1707bee7b6e87dd792ecf4374c2eed78270535708d24e4be96c22c60e258876d73c4fd516e9d49aa655550b502a01e56aed8b1606b0a03f2ec28f524"
SRC_URI[deb1.md5sum] = "4744513eafeeedb499339880fcb8c0ee"
SRC_URI[deb1.sha1sum] = "db882c371ecf3d904172289a0098f6e32b71e81f"
SRC_URI[deb1.sha256sum] = "43cb91f6fb16c1c2ef4db032e20089bb7f9c241cc2305c048025527f1495559a"
SRC_URI[deb1.sha512sum] = "c9dc9ff50e4a2ca9164a95cf76527b1d8304a93f4bcf0196d4623c941d76e69911ed8f225ca96d66ac4119e0ba547270f2527f6e27753e364a3c836459cd5403"

RDEPENDS = " \
    libc6 \
    libgcc-s1 \
    python3 \
"

