# This was autogenerated! Do not modify
SUMMARY = "Python package build backend used by Hatch"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "hatchling"
HOMEPAGE = "https://hatch.pypa.io/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/h/hatchling/python3-hatchling_1.27.0-1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "53a388ba3192f9a7e24064db0f25c482"
SRC_URI[deb0.sha1sum] = "93ffd65bae6aaee345d8724fdd55cc15f9584704"
SRC_URI[deb0.sha256sum] = "3cae864c83fc459a03da884419bffe5f8cea1175778a0a9c52a1c6bf28000e22"
SRC_URI[deb0.sha512sum] = "9690a7ba96dc4359fba8b3300cae62975dbf312cdb40e7b920030652506fb59b657ff570775df60319f6a3b7eb6c6a55b678021f527deac4e3a3e0ef3b855d64"

RDEPENDS = " \
    python3 \
    python3-packaging \
    python3-pathspec \
    python3-pluggy \
    python3-tomli \
    python3-trove-classifiers \
"

