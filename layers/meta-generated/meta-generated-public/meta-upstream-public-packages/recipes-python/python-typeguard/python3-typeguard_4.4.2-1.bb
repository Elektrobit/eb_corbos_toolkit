# This was autogenerated! Do not modify
SUMMARY = "Run-time type checker for Python"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "python-typeguard"
HOMEPAGE = "https://github.com/agronholm/typeguard"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python-typeguard/python3-typeguard_4.4.2-1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "bb95692610cde7b4d7fa84b7a3a3a5c5"
SRC_URI[deb0.sha1sum] = "3116feab080fe5bb0f21373f7f26329cf6d13dab"
SRC_URI[deb0.sha256sum] = "81e512101d7ab94e73646b9a8e4fb9b948836e3172dc5719ad3acbcde65bca01"
SRC_URI[deb0.sha512sum] = "8b07671af1691a48c1a60ec36ee1d0d225fafe6ad728e5ac9bedabb6e3dc56ae6801df16c84d80f3453bf91e89ff8b1972055415aed2d00149b354a0110722d5"

RDEPENDS = " \
    python3 \
    python3-importlib-metadata \
    python3-typing-extensions \
"

