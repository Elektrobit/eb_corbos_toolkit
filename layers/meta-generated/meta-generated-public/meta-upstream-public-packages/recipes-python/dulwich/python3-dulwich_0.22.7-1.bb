# This was autogenerated! Do not modify
SUMMARY = "Python Git library - Python3 module"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "dulwich"
HOMEPAGE = "https://www.dulwich.io/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/d/dulwich/python3-dulwich_0.22.7-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/d/dulwich/python3-dulwich_0.22.7-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "7f2003c151d6f48d9c00bde771986ff1"
SRC_URI[deb0.sha1sum] = "95bdafbd9fc6a61d86795104e92cee3998415276"
SRC_URI[deb0.sha256sum] = "e71a5e810518b4b3cbfe7331d7cbcbae61c14ad24c34dbeb9d200ea38c69e6ec"
SRC_URI[deb0.sha512sum] = "21d53413d1139b4d86947887e21f32eed4338d53b77184293298c3d27423a3cfd73a21b5e58d09be30b9ea1b85daaadcbb360beef10a90a13d3a9a874e8660a3"
SRC_URI[deb1.md5sum] = "2587b2d4cfc4b0600ee56c01fcf523b6"
SRC_URI[deb1.sha1sum] = "3ae9640367dc5ed006965d08c26145f7ed329f83"
SRC_URI[deb1.sha256sum] = "81f53002df2738c049a70dfe21da4a6c5b7d8b3c50fda784b6236ecd1f3ed4d3"
SRC_URI[deb1.sha512sum] = "bf191d858f25407757b8a3961c38fe5bd5a681cf2c35475b6fd2fd13316773fd5fe1695b1622ead10a6d7f9a7d0e16df6525c9f2b167e6939795b94fc7c6338c"

RDEPENDS = " \
    python3 \
    python3-urllib3 \
"

