# This was autogenerated! Do not modify
SUMMARY = "syntax highlighting package written in Python 3"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "pygments"
HOMEPAGE = "https://pygments.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/pygments/python3-pygments_2.18.0+dfsg-2_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "494f5ab2dbca6a2ffd52c4f33da3c6ac"
SRC_URI[deb0.sha1sum] = "a167d8dcca55382c4ea201157425d4d24f18c1c0"
SRC_URI[deb0.sha256sum] = "9cadaec984d0d923f81e20a2dd68974db643f67ad6adc8a593a7bbdaad8f8554"
SRC_URI[deb0.sha512sum] = "4911639a4a774345676879178a9a579b06228601cba4b3452072a995bc7e1a51213582e82731aa9c82dfca00e44c09c33e66c479116cc2406455a0b2dd8a493e"

RDEPENDS = " \
    python3 \
"

