# This was autogenerated! Do not modify
SUMMARY = "plugin and hook calling mechanisms for Python 3"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "python-pluggy"
HOMEPAGE = "https://pluggy.readthedocs.io/en/latest/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python-pluggy/python3-pluggy_1.5.0-1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "8ca06deda8e8df5e6282fedbd17cb9de"
SRC_URI[deb0.sha1sum] = "d7433d5ec64e9a12e74faf60f2bb138bd2405efa"
SRC_URI[deb0.sha256sum] = "d762a370c7c54046d991b3caa9095facbee5c54792e306b5f9e32455326f82bc"
SRC_URI[deb0.sha512sum] = "249e8333088404ccd53a5a1d97af7f07bb3632119981d612ad6f669af656f2c532bc4a5476357e3cb862be3456526d9f725f258724a68cbb82c02ee00e60d26b"

RDEPENDS = " \
    python3 \
"

