# This was autogenerated! Do not modify
SUMMARY = "utility library for gitignore style pattern matching of file paths (Python 3)"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "python-pathspec"
HOMEPAGE = "https://github.com/cpburnz/python-pathspec"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python-pathspec/python3-pathspec_0.12.1-1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "f8592899b05e537a2bc240b9cde23e4f"
SRC_URI[deb0.sha1sum] = "10d300aaf2c8fd7fdd764deae6db73ef1f885647"
SRC_URI[deb0.sha256sum] = "e90dfd6e9e988df606197427607735f1055f9996a3c237bca1105d7427713817"
SRC_URI[deb0.sha512sum] = "f37b8f902bcbd2ce89f5cf1a55c57f24f1dbed9c1894df610417464646bc93bc26d465555d0ac814251eda50c7890a16de765a560987625647cbf95fd93a1ef1"

RDEPENDS = " \
    python3 \
"

