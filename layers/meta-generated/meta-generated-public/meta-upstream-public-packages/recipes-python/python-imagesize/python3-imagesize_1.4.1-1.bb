# This was autogenerated! Do not modify
SUMMARY = "Python module for getting image size or DPI"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "python-imagesize"
HOMEPAGE = "https://github.com/shibukawa/imagesize_py"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python-imagesize/python3-imagesize_1.4.1-1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "38b0f3799b0e0bfc4424590ea5456400"
SRC_URI[deb0.sha1sum] = "f39e76fda2bf6630c38275d7cdc00fd6271213a9"
SRC_URI[deb0.sha256sum] = "2399d7ef9fc3db7562459c221e39962f3652953577742a926b0c91e13744b3f5"
SRC_URI[deb0.sha512sum] = "95c8a9bf2fb5b29dc10c4f0c4a61fc2de90ad9a4018b1a11d2c77ea1f391d21dd5db03434586a0ee012c46b9fdb06d48fa1215a5730bd9a4dcbeaebdccb158d2"

RDEPENDS = " \
    python3 \
"

