# This was autogenerated! Do not modify
SUMMARY = "Dataclass for PEP 621 metadata with support for [core metadata] generation"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "pyproject-metadata"
HOMEPAGE = "https://github.com/pypa/python-pyproject-metadata"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/pyproject-metadata/python3-pyproject-metadata_0.9.1-1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "be1b007468459b197aadf40d97794f68"
SRC_URI[deb0.sha1sum] = "6f9989e0ec6721bdc99c64c7fbb33d60a44a5708"
SRC_URI[deb0.sha256sum] = "c0f24a52d09f7b3cc3b80413c71c382b2c42a33dba961bad70fe9238d12c99c5"
SRC_URI[deb0.sha512sum] = "ebb20afa165845c2c3eaea0632d4dad690e43951c7b9088308649483998e234f70936f73235d0ff223f28e0fdffe874a2cb15e3e5f3592b0886a7aceb51ba12c"

RDEPENDS = " \
    python3 \
    python3-packaging \
"

