# This was autogenerated! Do not modify
SUMMARY = "Python3 bindings to SELinux shared libraries"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "libselinux"
HOMEPAGE = "https://github.com/SELinuxProject"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libs/libselinux/python3-selinux_3.8.1-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libs/libselinux/python3-selinux_3.8.1-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "0b7818ce12184d5ea41b0fde821ea0a9"
SRC_URI[deb0.sha1sum] = "ae434f45d2e6e366b476f1c65441b63e3e1cdbf7"
SRC_URI[deb0.sha256sum] = "6c14da3dcd438efc1eb55f8823323b110bd5ac5504f8436c0cdae1fa017dcbab"
SRC_URI[deb0.sha512sum] = "2230fad4667062d0c64a9d2479f28f4d18e7981f3286053168a1c2b32526b0b72259470945d5003730c4ff241b811e56d7896001ff124c2bbe7779992783bd1d"
SRC_URI[deb1.md5sum] = "af5ed30e2355a0c0abd1a4929ccafc3b"
SRC_URI[deb1.sha1sum] = "e7d133f575e6771fda5b51d1c46ca73e49a5299a"
SRC_URI[deb1.sha256sum] = "6eae94dfa2877d10e571aff17e28720c89e23c9b3b81ab559a02a51476414ebb"
SRC_URI[deb1.sha512sum] = "db8ed7582a3bfa179f3218351ff1bfe22ad1728f70d22f7ec606c48147cd787227aac27c43d0b875d83e9efc67a8bc07761072c58648c131c3c79144f32a3e23"

RDEPENDS = " \
    libc6 \
    libselinux1 \
    python3 \
"

