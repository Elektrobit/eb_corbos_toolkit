# This was autogenerated! Do not modify
SUMMARY = "cryptographic Python library (Python 3)"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "pycryptodome"
HOMEPAGE = "https://www.pycryptodome.org"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/pycryptodome/python3-pycryptodome_3.20.0+dfsg-3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/pycryptodome/python3-pycryptodome_3.20.0+dfsg-3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "239dc0785759f235029068d0a6fdab43"
SRC_URI[deb0.sha1sum] = "f1bc2d8e9a5f9a22e7e0ec1f7bdacac01a5511c5"
SRC_URI[deb0.sha256sum] = "c275a0597d090fb401777034981ffbea5e2b0b93c34eecaaca1441bff081bbb3"
SRC_URI[deb0.sha512sum] = "7083d64e5da08a65746b2d6c7c0e1ddb208e6774d8115fd61f4df1c8ffc2b362666e6452dfd143631d2b8df0e75538dceb00d6db23125307ac15bdf58b1638e6"
SRC_URI[deb1.md5sum] = "5846664311b320e5453d7c9514f98de7"
SRC_URI[deb1.sha1sum] = "eab08f195b593052173f0382f3a8a1516355c38e"
SRC_URI[deb1.sha256sum] = "ec5a993c71cd5995c7c251ffb8f24a9f4fdd48696f3648d77bce0d40219bf5b8"
SRC_URI[deb1.sha512sum] = "c0a7ff1c0fd81ccbced43d231863186b083a59c3b1c54f7029346161ac73d26805ad33854e8fff50c35e8524873627811e08681545d278745c92c3e0d40560ed"

RDEPENDS = " \
    libc6 \
    python3 \
"

