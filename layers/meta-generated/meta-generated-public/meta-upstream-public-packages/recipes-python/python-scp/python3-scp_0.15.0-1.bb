# This was autogenerated! Do not modify
SUMMARY = "scp module for paramiko (Python 3)"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "python-scp"
HOMEPAGE = "https://github.com/jbardin/scp.py"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python-scp/python3-scp_0.15.0-1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "79a153160305f6b268c921231aa16ddc"
SRC_URI[deb0.sha1sum] = "1952793b34fbfec8c9b059e7e76f9a3947541306"
SRC_URI[deb0.sha256sum] = "78f78932f4aa4bce33d46c27709604f242a5bb6fe1488491d630b832ec231641"
SRC_URI[deb0.sha512sum] = "2879271c243fffff076d8a5a89f51f694bf7e79170981a2522ab9043510bd02ac6d18e5e719b5d9fcd98e6c8081b62fdf493eb9a2d690f402667f0e4a81aaccf"

RDEPENDS = " \
    python3 \
    python3-paramiko \
"

