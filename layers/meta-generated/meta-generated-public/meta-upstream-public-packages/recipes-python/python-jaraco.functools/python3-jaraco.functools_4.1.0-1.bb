# This was autogenerated! Do not modify
SUMMARY = "additional functools in the spirit of stdlib's functools"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "python-jaraco.functools"
HOMEPAGE = "https://github.com/jaraco/jaraco.functools"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python-jaraco.functools/python3-jaraco.functools_4.1.0-1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "ae2c3a80c590b6502457ef4c1306b4c6"
SRC_URI[deb0.sha1sum] = "edd6e3f96b988f5bc0eedb200863e4195fb57a51"
SRC_URI[deb0.sha256sum] = "f5ac3e5f79b6394191d76ea7cde9255d8bae98f639886cb981444128f6545796"
SRC_URI[deb0.sha512sum] = "c87c2bf6ab458d501ab9d6444685f873f6ff8aab03f10676f286d4712b380df4b4e3402aa204c6d93a99761810e289f043500d06b23652005392a38aad04fb66"

RDEPENDS = " \
    python3 \
    python3-more-itertools \
"

