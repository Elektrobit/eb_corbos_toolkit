# This was autogenerated! Do not modify
SUMMARY = "Lex and Yacc implementation for Python3"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "ply"
HOMEPAGE = "https://www.dabeaz.com/ply/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/ply/python3-ply_3.11-9_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "530813ec3de0bb27dbfeb107f53c0377"
SRC_URI[deb0.sha1sum] = "807aef22a7ce684e694ea3da85c2f1186b6aa9f1"
SRC_URI[deb0.sha256sum] = "d85058c4ec2b77641f7cc413d943be1f412b1b44d4cbe0b174810d37615a7a00"
SRC_URI[deb0.sha512sum] = "d804a90ee1a8e46a6db278b4734b5a9ed2a6215cf88cf418480399867368ac8b591aac507e0f59571b7772540bbf745d5db14f590e382fdf3259b14363d32dc1"

RDEPENDS = " \
    python3 \
"

RPROVIDES = " \
    python3-ply-lex-3.10 \
    python3-ply-yacc-3.10 \
"
