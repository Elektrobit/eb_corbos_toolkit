# This was autogenerated! Do not modify
SUMMARY = "manage callbacks in asyncio projects"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "aiosignal"
HOMEPAGE = "https://github.com/aio-libs/aiosignal"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/a/aiosignal/python3-aiosignal_1.3.2-1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "ab12d6cdb8d957071e0116886f561137"
SRC_URI[deb0.sha1sum] = "0c7e8eb520190c6780de267d02d8d1ebc4fe3f3a"
SRC_URI[deb0.sha256sum] = "8a2072d8753991ef49d85ae31b6547e0e04353c8b037f3dc84bc1fb02b228ae0"
SRC_URI[deb0.sha512sum] = "e8b76e5b68b4a97dc6389e964ec6f0dcfca9dc6d0a68d357b35f9aca76510ea21487e718629f41a7959fbd4b81c346ba5d1be409da3dc083d0901883f53d2283"

RDEPENDS = " \
    python3 \
    python3-frozenlist \
"

