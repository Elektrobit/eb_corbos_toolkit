# This was autogenerated! Do not modify
SUMMARY = "Python library for creating "editable wheels""
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "python-editables"
HOMEPAGE = "https://github.com/pfmoore/editables"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python-editables/python3-editables_0.5-2_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "f754d945777004867b47076a90f050bf"
SRC_URI[deb0.sha1sum] = "838b7aee22612e36bb172e67c1777bf4e5cd185c"
SRC_URI[deb0.sha256sum] = "4ecff3c704c2ee4146e5f86aabb23c83d1e5992662a3f2e49d7f73b705265411"
SRC_URI[deb0.sha512sum] = "42bba1ecd9a0a3941fc68addae8846d16be6f50004218a9dd229e125a34e73309ed55d82c9a84703cd45438043b1fdbd05d83a4a6a68087d48c3c721e935c8ce"

RDEPENDS = " \
    python3 \
"

