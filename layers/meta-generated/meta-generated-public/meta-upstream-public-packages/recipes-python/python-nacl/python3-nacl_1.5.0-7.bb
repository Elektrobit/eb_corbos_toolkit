# This was autogenerated! Do not modify
SUMMARY = "Python bindings to libsodium (Python 3)"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "python-nacl"
HOMEPAGE = "https://github.com/pyca/pynacl/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python-nacl/python3-nacl_1.5.0-7_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python-nacl/python3-nacl_1.5.0-7_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "7575dbbb52f7d45921d93fec77279976"
SRC_URI[deb0.sha1sum] = "896cafe931ea05639ab04bfc7f1991c885553209"
SRC_URI[deb0.sha256sum] = "0c5d41d404aa3f8f25f6f59f8170cf48ee9766f86e4848f58c8c029dfcc2bb27"
SRC_URI[deb0.sha512sum] = "c82e2a0bf6c538b8017c132b8f3a7cff3215e552788c73997e17c23d507518f44ff4edae9756aa1a12b8c6f453076a84f6589676e3d5b5b3bfb891eb171746d0"
SRC_URI[deb1.md5sum] = "aaa612b83dbdcd03ad181455f216f0a2"
SRC_URI[deb1.sha1sum] = "e1179e8501fd94f4becaef81df72026ab6bc3e56"
SRC_URI[deb1.sha256sum] = "ebb82699cd4023faf9060d000b8d2f47332464bdf6bf23ebae108536ae776ba9"
SRC_URI[deb1.sha512sum] = "fcc47ee348416a9a9b9fa6d30312eb9835b603209ada44808fa6b02de4fdcb95dc02b01685ccfe79e67444770c3e62762acd966d873402f071f69fb69efcab38"

RDEPENDS = " \
    libc6 \
    libsodium23 \
    python3 \
    python3-cffi-backend-api-max \
    python3-cffi-backend-api-min \
"

