# This was autogenerated! Do not modify
SUMMARY = "pathlib-compatible Zipfile object wrapper - Python 3.x"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "python-zipp"
HOMEPAGE = "https://github.com/jaraco/zipp"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python-zipp/python3-zipp_3.21.0-1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "c5d6b45e36781892d58915e1bef67dff"
SRC_URI[deb0.sha1sum] = "18bf1bbd22810a930f72f6596931a158e0c6237a"
SRC_URI[deb0.sha256sum] = "6cd0f768a5e5c574c7ae4b9d56603f8399b31de732167007e42fc17decc5cc6a"
SRC_URI[deb0.sha512sum] = "49139bfa24b43b0f1aae2e3d15a83e1816ab9d9c9681f3f99da3252eadeb09bf4047e9978b7559070db8a607fc270af38c743fab7b5117bf192f4984db4ce1dc"

RDEPENDS = " \
    python3 \
"

