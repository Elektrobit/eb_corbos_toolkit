# This was autogenerated! Do not modify
SUMMARY = "Tool to Detect Surrounding Shell"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "shellingham"
HOMEPAGE = "https://github.com/sarugaku/shellingham"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/shellingham/python3-shellingham_1.5.4-1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "cda0dc9797330c4c0ef1eefd9a8f61a8"
SRC_URI[deb0.sha1sum] = "b48a6e31019cba5db55be66f705259504db3c7ec"
SRC_URI[deb0.sha256sum] = "d8061f7c0045e4ae562b563004b7841eaa4fb82ee1029f2089b72c6ac737e8cf"
SRC_URI[deb0.sha512sum] = "b0cd0115fc5fc4e1903e01ddb2b6006145f71eb8081073253f5f8c26eec518e7b1213439e272e44c46b545316372519afbf67119815c47e94636248d841e2628"

RDEPENDS = " \
    python3 \
"

