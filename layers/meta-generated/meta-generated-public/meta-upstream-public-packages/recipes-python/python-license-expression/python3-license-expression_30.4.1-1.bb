# This was autogenerated! Do not modify
SUMMARY = "small library to handle license expressions"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "python-license-expression"
HOMEPAGE = "https://github.com/nexB/license-expression"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python-license-expression/python3-license-expression_30.4.1-1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "f040757ad8134589df0a2f8f59c4733c"
SRC_URI[deb0.sha1sum] = "d0e9173677e0311ee9c52d3a6aec23a1ac0f4227"
SRC_URI[deb0.sha256sum] = "86fe223789d6c6012102c7dd2d27328d733dd3be857335cc4efa5527582febdc"
SRC_URI[deb0.sha512sum] = "f26c365f6b6b04414322991294ed4fa176eb338233918c74e53ab2c5053c49339ccd9768e64087d2104d4b3e1f937abf18026a17b3cec4a2832c8aa5d757093a"

RDEPENDS = " \
    python3 \
    python3-boolean \
"

