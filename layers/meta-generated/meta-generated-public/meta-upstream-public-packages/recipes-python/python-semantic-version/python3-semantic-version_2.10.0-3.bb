# This was autogenerated! Do not modify
SUMMARY = "implementing the SemVer scheme - Python 3.x"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "python-semantic-version"
HOMEPAGE = "https://github.com/rbarrois/python-semanticversion"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python-semantic-version/python3-semantic-version_2.10.0-3_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "60681fa900a71441adf3a6f30f26a51d"
SRC_URI[deb0.sha1sum] = "18887f96a2670cf432416a06e5df139ab017edf4"
SRC_URI[deb0.sha256sum] = "29e197f69d0e1c6e89924848fd3410d7b64701ea5982c66c5bb7e9280b40200c"
SRC_URI[deb0.sha512sum] = "37ff3a48a1ed693e44edb7ef88078fc40e52fa1ca3df9da031d1a50e25d538c73a82ec1e0c3bcf03ee5719efb3e9cb39f7c1d4e338ce2f83bfa95ffddc946978"

RDEPENDS = " \
    python3 \
"

