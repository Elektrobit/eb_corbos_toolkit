# This was autogenerated! Do not modify
SUMMARY = "Build backend used by PDM"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "pdm-backend"
HOMEPAGE = "https://github.com/pdm-project/pdm-backend"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/pdm-backend/python3-pdm-backend_2.4.4+ds1-1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "18774895081b88dc4ac49e971f12b73e"
SRC_URI[deb0.sha1sum] = "93b624c577b4bd3eecfbf97fd5264c27b7e3a347"
SRC_URI[deb0.sha256sum] = "afccfb2959f7d8984f6fdf3f3aaeb400c705b6c98d098f6b22261093cde32963"
SRC_URI[deb0.sha512sum] = "077c47c5e8a8a72ee4cbcc6fa4c32ff7edbe7e8815bae0567e85cde6ee9096a2519727a1f7fb1fd2fbb8b1f0e98f729de2989a6f82de89d2959ff4e6c4f2bb82"

RDEPENDS = " \
    python3 \
    python3-boolean \
    python3-cerberus \
    python3-editables \
    python3-importlib-metadata \
    python3-license-expression \
    python3-packaging \
    python3-pyparsing \
    python3-pyproject-metadata \
    python3-tomli-w \
    python3-validate-pyproject \
"

