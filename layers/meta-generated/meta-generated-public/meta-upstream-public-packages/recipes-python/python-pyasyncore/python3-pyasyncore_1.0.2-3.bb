# This was autogenerated! Do not modify
SUMMARY = "asyncore for Python 3.12 onwards"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "python-pyasyncore"
HOMEPAGE = "https://github.com/simonrob/pyasyncore"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python-pyasyncore/python3-pyasyncore_1.0.2-3_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "0a13132489929f8f33053c3041a2a291"
SRC_URI[deb0.sha1sum] = "1e9fd7ef82ea8e31b62136100275cff33f5f69ab"
SRC_URI[deb0.sha256sum] = "d19dd870a31830a1b01d467ce486e20e983e7718ed57ba3793ab0af1f6b8e71e"
SRC_URI[deb0.sha512sum] = "9d49b8e88d16baf812a974e5962d85ed3ef749bae239dab3ab66eb3c9617660890ec6e4b001e2deb678e522a37386fc68c48d4f38eae92ea3c3bc55742cffcd3"

RDEPENDS = " \
    python3 \
"

