# This was autogenerated! Do not modify
SUMMARY = "Minimal subset of the Python language (version 3.13)"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "python3.13"
HOMEPAGE = ""

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python3.13/python3.13-minimal_3.13.5-2+deb13u3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python3.13/python3.13-minimal_3.13.5-2+deb13u3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "ac84222984f11122b33f697dc8354cd6"
SRC_URI[deb0.sha1sum] = "9359a1cdee9b7f7b3ffc3615522388e26f64dcbe"
SRC_URI[deb0.sha256sum] = "3bafb1bf1674a6c8fc52296e1b17b54b666400fc46f6b1d0ef4c24baebc883bb"
SRC_URI[deb0.sha512sum] = "2c872ca7c1063b4f5972be2d8053b488c73330322dae2194908c4ded4eaeab90ebb584abcc2bb22cddacc92077eceea205dee6dc713fdc2ced57f0fdfe5056be"
SRC_URI[deb1.md5sum] = "427e8ccb0f23c11814dbce09ec98864a"
SRC_URI[deb1.sha1sum] = "9e000164d35b806528c47cec8a528de4533ae36a"
SRC_URI[deb1.sha256sum] = "d64a87f3dc9b3b52567cda12096312767b19f8f3995d4051f79a2435d3d994de"
SRC_URI[deb1.sha512sum] = "0a711b70dbd808dae4bc4f3ea12f2d65a9122bfa31e03655af19e62a4c5e620e4228b02864de5b04af4b23243814c7fc132b6c7396c41de7fbe6f2693a122ef9"

RDEPENDS = " \
    libc6 \
    libexpat1 \
    libpython3.13-minimal \
    zlib1g \
"

