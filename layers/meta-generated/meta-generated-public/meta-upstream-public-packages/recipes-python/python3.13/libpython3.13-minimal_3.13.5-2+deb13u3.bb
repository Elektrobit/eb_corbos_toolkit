# This was autogenerated! Do not modify
SUMMARY = "Minimal subset of the Python language (version 3.13)"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "python3.13"
HOMEPAGE = ""

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python3.13/libpython3.13-minimal_3.13.5-2+deb13u3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python3.13/libpython3.13-minimal_3.13.5-2+deb13u3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "e3c21e85b34e50cb153cd5bacd067923"
SRC_URI[deb0.sha1sum] = "6e6e21c2113c1eac1ac300715d71e32e98d09e85"
SRC_URI[deb0.sha256sum] = "9be9a4e59d43ad6e237349befbd0d131e0cf79812323b5ac6427051cee7e7ca9"
SRC_URI[deb0.sha512sum] = "d46f00af881753a4d7428140025a3bef4b5e4919426bc9511df327cf9a10fb3012f3f550392dc43713eff45ab9e8bd689beef67e2cdb4041db62902280ca76f1"
SRC_URI[deb1.md5sum] = "e29b3e367759c92a3164f6d91fe65068"
SRC_URI[deb1.sha1sum] = "18b6ea5e97c30a0c68c3ba64a983ff84b1326291"
SRC_URI[deb1.sha256sum] = "c5210fcdcbf293d7ccdb1a0ebb33fad11c87d027af89e6f5bb8cd62ed001defe"
SRC_URI[deb1.sha512sum] = "bab3fc5ac960448ac9348ee8cc8a15e75d311ffc0ee25045a82e23f7da2593dd83a59e6c6443ca364a2c67dfb284040f2b46e3b9e1fd2ddd884a6db65f6da90f"

RDEPENDS = " \
    libc6 \
    libssl3t64 \
"

