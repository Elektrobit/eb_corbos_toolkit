# This was autogenerated! Do not modify
SUMMARY = "Interactive high-level object-oriented language (standard library, version 3.13)"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "python3.13"
HOMEPAGE = ""

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python3.13/libpython3.13-stdlib_3.13.5-2+deb13u4_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python3.13/libpython3.13-stdlib_3.13.5-2+deb13u4_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "5f3b092e0b29c00925718abdb4a50d49"
SRC_URI[deb0.sha1sum] = "34446b6d753038d30cc9dfb5bf17987ff56071da"
SRC_URI[deb0.sha256sum] = "0def2d972310b59704ad119abee5a97f95409e14ff1359edd8cc7b8892cfd43f"
SRC_URI[deb0.sha512sum] = "8b2d11f30743d055c37bab5a8b92574ee4e012f55ccc6720f6cb628a7825a90c7e554431bd63457c360e9f1a364428f3e6715a41287e34f0312815487d9d8d38"
SRC_URI[deb1.md5sum] = "b238aee09ca68cb952fb56571d6a4968"
SRC_URI[deb1.sha1sum] = "c52e3a8ac7ab4d083f6ec0992010c24ff1108193"
SRC_URI[deb1.sha256sum] = "37cce6086b7c1ca93086f83b68761737607689e634693b6972b5dbfd6c080872"
SRC_URI[deb1.sha512sum] = "feca96572d5a784f23461439c760cbd23b0423bd718be86fc9bd75aeda65504d34be6992e66fd2f259123cef612a17709741ce4e83ab1e81046c261b27ee7494"

RDEPENDS = " \
    libbz2-1.0 \
    libc6 \
    libdb5.3t64 \
    libffi8 \
    liblzma5 \
    libncursesw6 \
    libpython3.13-minimal \
    libreadline8t64 \
    libsqlite3-0 \
    libtinfo6 \
    libuuid1 \
    media-types \
    netbase \
    tzdata \
"

