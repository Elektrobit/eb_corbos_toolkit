# This was autogenerated! Do not modify
SUMMARY = "Interactive high-level object-oriented language (pyvenv binary, version 3.13)"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "python3.13"
HOMEPAGE = ""

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python3.13/python3.13-venv_3.13.5-2+deb13u3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python3.13/python3.13-venv_3.13.5-2+deb13u3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "8af68ecf192f5d7b7c908ffe7634dda8"
SRC_URI[deb0.sha1sum] = "0f13764ba017d1116d38654c13a98dea8addda6b"
SRC_URI[deb0.sha256sum] = "45664ae13818990d154ee8d9024e62ca3f3fa4befee432f4bd5743a7b6475fd4"
SRC_URI[deb0.sha512sum] = "a5caed01dd03e2bb39a876fc7f5bfda7b61c93fda74da7adba14b74be9515d917f960dfe8bddaf0e416946901e1dc4676e097867128332f2540c6b9ee2019e7c"
SRC_URI[deb1.md5sum] = "71981f3fcdba5836cc4d7cb9089669a5"
SRC_URI[deb1.sha1sum] = "3b7dbcd0e259fdb3df2045aaf44180f3a4a7e21f"
SRC_URI[deb1.sha256sum] = "9b51998a1bd9f45453baa89cf159d68536e8cc1402a897bb523aa19cdc5304a9"
SRC_URI[deb1.sha512sum] = "3d4a6d43ba09eaae155a3a22c71105ab3f1b3a8db5606073e40137dea3be6fe5133a494004c4db79b8304ab8b433997e9b24e9bfaf80f367783517d7eb2fac72"

RDEPENDS = " \
    python3-pip-whl \
    python3-setuptools-whl \
    python3.13 \
"

