# This was autogenerated! Do not modify
SUMMARY = "Minimal subset of the Python language (version 3.13)"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "python3.13"
HOMEPAGE = ""

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python3.13/libpython3.13-minimal_3.13.5-2+deb13u4_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python3.13/libpython3.13-minimal_3.13.5-2+deb13u4_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "066f0c4e0430f9b23b935c20819fc744"
SRC_URI[deb0.sha1sum] = "d63097e4bb174c04bfc29e38e6270b43c2db9c0b"
SRC_URI[deb0.sha256sum] = "e3a45504aaf395acb5c57efb5ccfdf85efa6eaffc165653d1f03532bbf5b92c5"
SRC_URI[deb0.sha512sum] = "d0a8c12b2acaa59daffe1b6444041ed1173183fd1ead791eada26aa0f4d298fbfb505071a5038571e24a9057286fd192b85adfab7cd80c498314d273cb3b8161"
SRC_URI[deb1.md5sum] = "f810bbe1b32cc75d35126cb01515b26f"
SRC_URI[deb1.sha1sum] = "8acc14116f3158a53232d07395476dfe06e1aa74"
SRC_URI[deb1.sha256sum] = "774474a023c4835c5362222419b57959d97ebe3ef63d7c54f8a8801226cef163"
SRC_URI[deb1.sha512sum] = "b6ac8af0b98fe34ec561a3f07a9d4643b9f51aeab4b1f34e1e201deba157069acb8d2beab37255b07bad39e4797b33a7c852de650c470f93b25cf1ab7cb2b721"

RDEPENDS = " \
    libc6 \
    libssl3t64 \
"

