# This was autogenerated! Do not modify
SUMMARY = "Interactive high-level object-oriented language (pyvenv binary, version 3.13)"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "python3.13"
HOMEPAGE = ""

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python3.13/python3.13-venv_3.13.5-2+deb13u4_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python3.13/python3.13-venv_3.13.5-2+deb13u4_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "123bf5b8d35114c7abf8f2412895275d"
SRC_URI[deb0.sha1sum] = "6bc774a5b8f7e85771cb22f8fbe482c9ccc0c066"
SRC_URI[deb0.sha256sum] = "886b8a63bd076a43949f7f704dd9f84ea431e25ba97ed9783676043e3f398165"
SRC_URI[deb0.sha512sum] = "78fe97e2ceb0ba23eff97ff5070327483d914fbc4fb80e2345b482a01fe9905bb13d3ae5ece006138432cd9510a28869fd434e41d7e2c41f4c952e4d98e62f07"
SRC_URI[deb1.md5sum] = "7b46205a1f70150c7865cc0ca37d34c2"
SRC_URI[deb1.sha1sum] = "cf85aa3b486cfe554950992f881de04543084cdf"
SRC_URI[deb1.sha256sum] = "2ccce7da838b594b0396f5193a120841fabbd833772bfd8c78fd20a81b38a8a0"
SRC_URI[deb1.sha512sum] = "e8167b36e5b59d73bb5c849f46f7c750339a0ff391e503960c99a7d1ac9c21b0ba362b11e73dbf1ac9be66f61adbf43e4bb0516ad66c47d32d8d891258e35614"

RDEPENDS = " \
    python3-pip-whl \
    python3-setuptools-whl \
    python3.13 \
"

