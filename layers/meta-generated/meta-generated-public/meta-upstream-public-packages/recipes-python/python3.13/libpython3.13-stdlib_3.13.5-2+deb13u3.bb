# This was autogenerated! Do not modify
SUMMARY = "Interactive high-level object-oriented language (standard library, version 3.13)"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "python3.13"
HOMEPAGE = ""

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python3.13/libpython3.13-stdlib_3.13.5-2+deb13u3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python3.13/libpython3.13-stdlib_3.13.5-2+deb13u3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "549e1562cca05cc0726198d41c1eb216"
SRC_URI[deb0.sha1sum] = "a1aaebe2d285ecf60729b8444ee5dff26b3fa15c"
SRC_URI[deb0.sha256sum] = "f4e759dbac49db16c4f1c3601684a9211a2af3211a3f7bdc04fff263af08a5eb"
SRC_URI[deb0.sha512sum] = "38f6f23af552857adc0624133b46702c67a8f9ee77ec73081e99c99de47b072f70071a42192a0b4fedd67b7ea10b2ba9d9109b2683e2052c293ddd19efa82cf2"
SRC_URI[deb1.md5sum] = "0a6548fa3321376b396f0ec0a10a0ae4"
SRC_URI[deb1.sha1sum] = "468289fa076b40d8d00ae53211653b36769e07ef"
SRC_URI[deb1.sha256sum] = "88f3f041436676c627672955f39269abff8168196546fc65130aa31165c03981"
SRC_URI[deb1.sha512sum] = "5e79973ae7204b66cbf7293a4747a2495d3951487c2afb44b849b700fbc6edabfd75f6094d24f12fb1f264164648c838e38a38403cc0128fd9e48bff651c3ee6"

RDEPENDS = " \
    libbz2-1.0 \
    libc6 \
    libdb5.3t64 \
    libffi8 \
    liblzma5 \
    libncursesw6 \
    libpython3.13-minimal \
    libreadline8t64 \
    libsqlite3-0 \
    libtinfo6 \
    libuuid1 \
    media-types \
    netbase \
    tzdata \
"

