# This was autogenerated! Do not modify
SUMMARY = "Interactive high-level object-oriented language (version 3.13)"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "python3.13"
HOMEPAGE = ""

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python3.13/python3.13_3.13.5-2+deb13u4_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python3.13/python3.13_3.13.5-2+deb13u4_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "cc6c16afc742a0381c285763f91f2254"
SRC_URI[deb0.sha1sum] = "8ebce1ad081382ee68e57abdc1834ba5041bc14c"
SRC_URI[deb0.sha256sum] = "035889aaac2ddf70543ea6918f2e8d48512576dfaea9c14e08d2ef68e1b97182"
SRC_URI[deb0.sha512sum] = "120ff923c833b8712c5d7654cd73617b838ca7555557d2cc7e57c2c48bcc726b4a521ef09bf8aff913f721a9c864adec86b0dee862145b8443843e27cbc1b1ef"
SRC_URI[deb1.md5sum] = "5fb15c334ea261497879e3db088dcd2b"
SRC_URI[deb1.sha1sum] = "771e3df6586df4f416c8cb26ac9af16b19ff2f4d"
SRC_URI[deb1.sha256sum] = "db41afdb3d84d2d00ba5c6e4e2e4e70dc1e21d7710c152a7b04d4fce6b2f74e9"
SRC_URI[deb1.sha512sum] = "19389d3e54c60d34adb8f9ae76e00fbe56d78e2b3928dc348f0a359acb819e2da091dbd04890140a7743e6a772dba20d13430d3b8cc100bd428e63d947cd4c2e"

RDEPENDS = " \
    libpython3.13-stdlib \
    media-types \
    python3.13-minimal \
    tzdata \
"

