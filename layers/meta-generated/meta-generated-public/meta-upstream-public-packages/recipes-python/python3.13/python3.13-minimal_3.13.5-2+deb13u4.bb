# This was autogenerated! Do not modify
SUMMARY = "Minimal subset of the Python language (version 3.13)"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "python3.13"
HOMEPAGE = ""

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python3.13/python3.13-minimal_3.13.5-2+deb13u4_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python3.13/python3.13-minimal_3.13.5-2+deb13u4_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "68d1d8ab7386b9c664940d4383fd3691"
SRC_URI[deb0.sha1sum] = "74e55d896b26f35fffd8863b6c23d5c47491f2a5"
SRC_URI[deb0.sha256sum] = "d86fb415db31273c8d98b42088c070b55094fa0bedb5d2daf34101195b78cf23"
SRC_URI[deb0.sha512sum] = "b2eb9347748ce364e29bca0071bb2209e8c6e056c08d0b122edb0e666412bdf9554b2db70f735680725f2a74de1266b6f9fc05f0d78cc4ff728a5f3085ec6ee6"
SRC_URI[deb1.md5sum] = "3ada6341fbebed9db9e57d68a14c22b8"
SRC_URI[deb1.sha1sum] = "38a1db6f0fb8c53072f03c947f42ccd42b81b7b4"
SRC_URI[deb1.sha256sum] = "0fec1a8d1c46c8fd715d022a2bddc6917e499addf82cadd0fb68d92b23a0c24f"
SRC_URI[deb1.sha512sum] = "40fb9faec5668797c71ca2f23aa59a4b36b26971c86af897778d5cf1011aa02edf0ec3a6dc0dcd7207ee0b7dde67e7fe3021ded79d4bc79e1c8947d39b54bff7"

RDEPENDS = " \
    libc6 \
    libexpat1 \
    libpython3.13-minimal \
    zlib1g \
"

