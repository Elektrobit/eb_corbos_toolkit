# This was autogenerated! Do not modify
SUMMARY = "Python interface to libapt-pkg (locales)"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "python-apt"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python-apt/python-apt-common_3.0.0_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "8a24d023a9874907a2695f713df43875"
SRC_URI[deb0.sha1sum] = "d194b69b12867061610764d23f97b4017c624a75"
SRC_URI[deb0.sha256sum] = "9aacb635fa04e01ab56a0af4869a034a94aadcd564d662a91048cd19fe7d6e0c"
SRC_URI[deb0.sha512sum] = "aa2acf668c003bf26d471894c5e9117cd621a5ae6f6ae0b1bc21439cd54bce804cdc88f1771657150e4be730d81a8a9608ede3f8470f578420f020ac3ccd851b"


