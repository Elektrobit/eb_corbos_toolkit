# This was autogenerated! Do not modify
SUMMARY = "Python 3 interface to libapt-pkg"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "python-apt"
HOMEPAGE = ""

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python-apt/python3-apt_3.0.0_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python-apt/python3-apt_3.0.0_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "a93cc5ae383bc154aede19d3ee6b264b"
SRC_URI[deb0.sha1sum] = "cb43812e83ca1dc2cde6ac29e2b00e7cc91e2952"
SRC_URI[deb0.sha256sum] = "e7d7ab8ddb63da8410288b902c4d2237b8689a12ba000851af37ae429e90e618"
SRC_URI[deb0.sha512sum] = "82b25be62d2340accfe13c4158edb8d9daabd30476ea3fdad3ef0b1c809f49bec12b72b4348d0fdd0f124a83d999b4841ceff100569373ae2807618d78a0ae4b"
SRC_URI[deb1.md5sum] = "759d3439f73546a07643088921b6e27d"
SRC_URI[deb1.sha1sum] = "9448591d9fe74ceac337b4016bdd7e9858bd7653"
SRC_URI[deb1.sha256sum] = "7f9c928895e7141ecea9d53ee93962cfb37d48a2015abc99d95a22e77535f8a7"
SRC_URI[deb1.sha512sum] = "3fda7702a03e1916c7782c8dbf773a7799b11366c1dd3a62c5e9d8a9dfe977f38f40c1778f369305e12e1b5f10b9aca62fbcb135890f7edae8c427317f9f6a4d"

RDEPENDS = " \
    distro-info-data \
    libapt-pkg7.0 \
    libc6 \
    libgcc-s1 \
    libstdc++6 \
    python-apt-common \
    python3 \
"

