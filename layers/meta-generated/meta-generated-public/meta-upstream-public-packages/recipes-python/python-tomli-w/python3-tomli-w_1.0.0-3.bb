# This was autogenerated! Do not modify
SUMMARY = "lil' TOML writer for Python"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "python-tomli-w"
HOMEPAGE = "https://github.com/hukkin/tomli-w"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python-tomli-w/python3-tomli-w_1.0.0-3_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "d04b769c096abf82f3d909aa7e6784a7"
SRC_URI[deb0.sha1sum] = "e60669075a2a43da9a704f1b465972cf59da04f9"
SRC_URI[deb0.sha256sum] = "d8fc021090f9277ac6d54db0c94801f797dadd8aefad9b7909375c21633d0a80"
SRC_URI[deb0.sha512sum] = "39d2327da7005ec9662ac0f26e7ad9c03aa37d3fd51f7aab46612b431f1aac67e4c23047bbdbb909c797143fedc466ce5b57001c3af32343236db49d0daa1bb1"

RDEPENDS = " \
    python3 \
"

