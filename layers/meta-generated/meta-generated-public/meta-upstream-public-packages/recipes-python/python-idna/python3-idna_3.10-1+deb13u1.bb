# This was autogenerated! Do not modify
SUMMARY = "Python IDNA2008 (RFC 5891) handling (Python 3)"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "python-idna"
HOMEPAGE = "https://github.com/kjd/idna"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python-idna/python3-idna_3.10-1+deb13u1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "9d780402b4e632810ba22a010d426545"
SRC_URI[deb0.sha1sum] = "9eb6dac48a5d721ee78d1f1348dcdfdb58d76e4a"
SRC_URI[deb0.sha256sum] = "5cf05020b0e5c523ace373a4feac7e074de3e95df30b5a2d584842accba6e60b"
SRC_URI[deb0.sha512sum] = "e9344e312322145198c77e3027bc6d409ae29639c09acbf356bf7eb91dbcd1cef4562d37245bb2babb94189b9b8470da4e2bad0c681a93ec4ee0802b37eb055f"

RDEPENDS = " \
    python3 \
"

