# This was autogenerated! Do not modify
SUMMARY = "Python 3 NTP Helper Classes"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "ntpsec"
HOMEPAGE = "https://www.ntpsec.org"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/n/ntpsec/python3-ntp_1.2.3+dfsg1-8_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/n/ntpsec/python3-ntp_1.2.3+dfsg1-8_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "49203a3199b99fb4034a615130f548ad"
SRC_URI[deb0.sha1sum] = "fe334bd449cb6a38f4ff80ddc7110eade67aec7b"
SRC_URI[deb0.sha256sum] = "04193a98a1a92ec0ccad05f42ae29e097323c72dbb02df7afc3be3c243006b7f"
SRC_URI[deb0.sha512sum] = "11ec49f588a3c60e7dab7093d43c1bf849431617c141c98fd50c75afedf237e38c113f667ab245c5f99a89b50a489717be2f92b7e9f7d89dd85f9484cf1cda6e"
SRC_URI[deb1.md5sum] = "dc1047e01b29e0b68b5ad8c537016b31"
SRC_URI[deb1.sha1sum] = "17f14cc8bd291cadaf2a62e93d7f1f5e885a507d"
SRC_URI[deb1.sha256sum] = "3fb9785d73506a7db457646ec2ee87c0ef81786d9cbea734bd62ee33354ea18c"
SRC_URI[deb1.sha512sum] = "84aaf8e9491752c0d9920d0e5a2cc8713cd7996d77f8f57c2287896bf0e5921a5e36ca951ac961cfc9bf9f0aee09acffce0fa94689a6bb50bcc86f712e6fdbf4"

RDEPENDS = " \
    libbsd0 \
    libc6 \
    libssl3t64 \
    python3 \
"

