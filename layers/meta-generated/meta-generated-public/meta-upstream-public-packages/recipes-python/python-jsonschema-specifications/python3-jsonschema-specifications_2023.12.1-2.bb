# This was autogenerated! Do not modify
SUMMARY = "JSON Schema meta-schemas and vocabularies, exposed as a Registry"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "python-jsonschema-specifications"
HOMEPAGE = "https://github.com/python-jsonschema/jsonschema-specifications"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python-jsonschema-specifications/python3-jsonschema-specifications_2023.12.1-2_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "7f9d3a822c7dc6578ee04a1449239075"
SRC_URI[deb0.sha1sum] = "1f3d62ee3a1ecf7446be8feb493b9071fa60bc87"
SRC_URI[deb0.sha256sum] = "1057cbd1dbb47ca26400c4f96fff24249ef1a3d8300390740051d09b1488dac8"
SRC_URI[deb0.sha512sum] = "d012e258a9be9d295b905e83a82d20d4742f286e4070242d5a48555e46866f199130b4d951e174b98a2d69e71295429f08611b33bd0b60d692fe73487e1b4e39"

RDEPENDS = " \
    python3 \
    python3-importlib-resources \
    python3-referencing \
    python3-rpds-py \
"

