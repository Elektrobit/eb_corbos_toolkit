# This was autogenerated! Do not modify
SUMMARY = "low-level components of python distutils2/packaging"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "distlib"
HOMEPAGE = "https://pypi.python.org/pypi/distlib"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/d/distlib/python3-distlib_0.3.9-1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "134ccc95d7d34d94162c5e36da8aef16"
SRC_URI[deb0.sha1sum] = "ff99a8107f07d96601e45a9bbc5f6e6a021250d1"
SRC_URI[deb0.sha256sum] = "e463db51fa1115c68f9eadae270acb429820cc28f0a71f58121ae2af986c0b0f"
SRC_URI[deb0.sha512sum] = "15cbe4967402c0820fee7980d6c9d8ce1f956f91abeceb796a70248215941d4fec158c21ccfb2cbcff2b8817a1108ee624a877daf2b6a46d3f6636e5dc53c141"

RDEPENDS = " \
    python3 \
"

