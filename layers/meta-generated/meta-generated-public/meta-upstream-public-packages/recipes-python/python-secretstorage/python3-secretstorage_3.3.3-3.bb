# This was autogenerated! Do not modify
SUMMARY = "Python module for storing secrets - Python 3.x version"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "python-secretstorage"
HOMEPAGE = "https://github.com/mitya57/secretstorage"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python-secretstorage/python3-secretstorage_3.3.3-3_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "ab6b6cd83190087284045f39f046ea79"
SRC_URI[deb0.sha1sum] = "de7709a3d9c3300c880be847364225e9f4472a22"
SRC_URI[deb0.sha256sum] = "8abd5add0303cc579e90d10b3f95bee88f90877e7ef99692aa4f9ca5acf5b916"
SRC_URI[deb0.sha512sum] = "1b0cf1903c5be4fa84432c99f0017e94f4f8c90063e95c36e9ed22cf9dedc9c77763c9ae6598822a0bfc31c46f83434448720fc50c7a7f7505e4a13c126034e4"

RDEPENDS = " \
    python3 \
    python3-cryptography \
    python3-jeepney \
"

