# This was autogenerated! Do not modify
SUMMARY = "Python library exposing cryptographic recipes and primitives"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "python-cryptography"
HOMEPAGE = "https://cryptography.io/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python-cryptography/python3-cryptography_43.0.0-3+deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python-cryptography/python3-cryptography_43.0.0-3+deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "6b1d88aa449fd3109ef0ecead7b587ad"
SRC_URI[deb0.sha1sum] = "7612ea48220776403289ad1697f4779631d4422c"
SRC_URI[deb0.sha256sum] = "edfc3aab6cbc4941aa19798059867696eeae90eb41b6dc2c5197c521da548972"
SRC_URI[deb0.sha512sum] = "e2e8ef164718384313e450355919a1a28b2c664e4885fb3b29419b950148c8eef78c025390a110247b648f2a7251099fb9eb68f819636961194c5116d3d81373"
SRC_URI[deb1.md5sum] = "8b05ce84fcd42020a2f495732b7d054a"
SRC_URI[deb1.sha1sum] = "bc40d354fe8a02dccd6dde9b4399348382010529"
SRC_URI[deb1.sha256sum] = "0979b3e86eca2631f2969e3dfffd3902a59b46265775e2415233af4ae2c02175"
SRC_URI[deb1.sha512sum] = "8c2d10fd5d0e85b5f7bb645028eec5f28d00a6be9c1a42a51dfdabbafcb03e785107ae7733129694b627a5291b01664a0b9500fcdb36fcf88a909156b12cee22"

RDEPENDS = " \
    libc6 \
    libgcc-s1 \
    libssl3t64 \
    python3 \
    python3-bcrypt \
    python3-cffi-backend-api-max \
    python3-cffi-backend-api-min \
"

