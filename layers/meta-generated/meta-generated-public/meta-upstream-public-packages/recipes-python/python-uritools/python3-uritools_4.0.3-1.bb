# This was autogenerated! Do not modify
SUMMARY = "RFC 3986 compliant replacement for urlparse"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "python-uritools"
HOMEPAGE = "https://github.com/tkem/uritools"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python-uritools/python3-uritools_4.0.3-1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "96417be6bdfc6c4ea79bcbe3597c1a74"
SRC_URI[deb0.sha1sum] = "12c89238532d369abe67cb710e5c1490a865e761"
SRC_URI[deb0.sha256sum] = "541faad47c1adcf0ff0c90607991a2b4c7391f1fc5c6e86ec7e39303d0ff585c"
SRC_URI[deb0.sha512sum] = "4a71af36da720c69b319830f7d5f56c438a9c27c3373d25e8f2ee6f28a46c94869a2c2eb5712845b1fc9557ca6315142037f8283d7c681d6ab78be3c509e3d0f"

RDEPENDS = " \
    libjs-sphinxdoc \
    python3 \
"

