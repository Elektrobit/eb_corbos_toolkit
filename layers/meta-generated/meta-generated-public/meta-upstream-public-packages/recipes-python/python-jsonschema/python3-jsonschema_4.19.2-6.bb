# This was autogenerated! Do not modify
SUMMARY = "An(other) implementation of JSON Schema"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "python-jsonschema"
HOMEPAGE = "https://github.com/Julian/jsonschema"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python-jsonschema/python3-jsonschema_4.19.2-6_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "673187d2de20ed6fa67b50a553887117"
SRC_URI[deb0.sha1sum] = "4a9725d1e07138898eccea97bea35dbc5ff34fb2"
SRC_URI[deb0.sha256sum] = "e826c2777771ca3852bf3ea4c5df11d8bec99648375c849225eb557411d1b694"
SRC_URI[deb0.sha512sum] = "7a03bfaa6148a4822d5f873a76a17ae2267301701639b5397e8c278d1b2e13844ec0fdbee5816bacfc0a3c0622a07cfef892d246e5502f9d72d0f769017f6892"

RDEPENDS = " \
    python3 \
    python3-attr \
    python3-jsonschema-specifications \
    python3-referencing \
    python3-rpds-py \
"

