# This was autogenerated! Do not modify
SUMMARY = "Python 3 library containing an RDF triple store and RDF parsers/serializers"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "rdflib"
HOMEPAGE = "https://github.com/RDFLib/rdflib"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/r/rdflib/python3-rdflib_7.1.1-3_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "7477d636f8373864a0f1a6f87c81dd00"
SRC_URI[deb0.sha1sum] = "72ade62d0e9b7827f6b759b2f80a2fc5d2537f1c"
SRC_URI[deb0.sha256sum] = "abe118e1850811750f5e3ed28cfecb670f9e8c0e81878dafc9a101c980479fdb"
SRC_URI[deb0.sha512sum] = "0ff570b29f3fe933708c4e9564bf3d933c394489dd766225a2f866855498c6aabb6162820db58a508d26f8e6922b65ee80cf02a5dd38f3bc4ac5b1a3bead6602"

RDEPENDS = " \
    python3 \
    python3-isodate \
    python3-pyparsing \
"

