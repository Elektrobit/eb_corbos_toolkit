# This was autogenerated! Do not modify
SUMMARY = "Simple, powerful testing in Python3"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "pytest"
HOMEPAGE = "https://pytest.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/pytest/python3-pytest_8.3.5-2_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "9d60c17b472c6e9f86fe4b43f1ebc175"
SRC_URI[deb0.sha1sum] = "d7d8426d0d69acc1e0babf47910d70b3f5f7f056"
SRC_URI[deb0.sha256sum] = "f933f7b38d1fd2c140684a44fecc7aa23cd6d08364604384c14c4cc21de8f8f9"
SRC_URI[deb0.sha512sum] = "06e00a181398d24a2c2f03aa25cd2a1dfd707d053e6898e4d3cbb24994765b7440fd4aea260d56db5384ea3a22a563e51eca0948441791223cc4ff0710aa2466"

RDEPENDS = " \
    python3 \
    python3-exceptiongroup \
    python3-iniconfig \
    python3-packaging \
    python3-pluggy \
    python3-tomli \
"

