# This was autogenerated! Do not modify
SUMMARY = "XML bomb protection for Python stdlib modules (for Python 3)"
DESCRIPTION = ""
SECTION = "python"
SOURCE_PACKAGE = "defusedxml"
HOMEPAGE = "https://github.com/tiran/defusedxml"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/d/defusedxml/python3-defusedxml_0.7.1-3_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "c16d63dbd4adaaa4f0f526bda7824660"
SRC_URI[deb0.sha1sum] = "511b11014f06e2e2cedf83499711e3f639f403b5"
SRC_URI[deb0.sha256sum] = "f77090e227c91bf1fe1485b42d74c833d0de0e4a737c8cd65c27bc25926bb35e"
SRC_URI[deb0.sha512sum] = "56ad48df8a7326edfd4dc2a4838329f99d75a57b29f43152386e610234775dbd3226130887ca022891b20fcfd62219a4528ac391f8678f9d279089432b9d62e9"

RDEPENDS = " \
    python3 \
"

