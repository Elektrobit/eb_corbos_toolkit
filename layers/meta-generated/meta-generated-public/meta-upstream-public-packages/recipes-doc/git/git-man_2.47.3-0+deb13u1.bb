# This was autogenerated! Do not modify
SUMMARY = "fast, scalable, distributed revision control system (manual pages)"
DESCRIPTION = ""
SECTION = "doc"
SOURCE_PACKAGE = "git"
HOMEPAGE = "https://git-scm.com/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/git/git-man_2.47.3-0+deb13u1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "f41414429e2df83fd81b105642abe7ba"
SRC_URI[deb0.sha1sum] = "f3d9cde672d8833f93805a3174539e9902fc6834"
SRC_URI[deb0.sha256sum] = "b58306b60e1dff920e1e18bc7e1e499f2ef75184190ab3d98657b165969bf7c9"
SRC_URI[deb0.sha512sum] = "a280a055933c04ca10eb3374e0a88ec60e18b6526689e3170531353f64f217c4da8e6912d2868d907eb3f0ae37e193e9156169ccea26d8417315618cc62d8397"


