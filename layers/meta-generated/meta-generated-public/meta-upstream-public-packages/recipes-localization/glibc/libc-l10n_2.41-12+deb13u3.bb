# This was autogenerated! Do not modify
SUMMARY = "GNU C Library: localization files"
DESCRIPTION = ""
SECTION = "localization"
SOURCE_PACKAGE = "glibc"
HOMEPAGE = "https://www.gnu.org/software/libc/libc.html"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/glibc/libc-l10n_2.41-12+deb13u3_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "490aad87e9d41a6444a7c3b9b89fcbbf"
SRC_URI[deb0.sha1sum] = "77a2b4f4cd9718181c42e3e6e26639ede2532199"
SRC_URI[deb0.sha256sum] = "b7ec1f67aed680a6829d1c3391e259980b223ca3df277dfdc2b788b3c95af0bd"
SRC_URI[deb0.sha512sum] = "753307ef676babc5c673eaddee86653a3189bd8b95a773c44abf028604c8a54350a542cdadb5a51e454971495e6e62e1f458e5bba7f76f7693ba2b9cae7dbc54"


