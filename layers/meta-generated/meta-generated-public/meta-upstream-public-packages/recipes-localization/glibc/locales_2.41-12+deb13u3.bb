# This was autogenerated! Do not modify
SUMMARY = "GNU C Library: National Language (locale) data [support]"
DESCRIPTION = ""
SECTION = "localization"
SOURCE_PACKAGE = "glibc"
HOMEPAGE = "https://www.gnu.org/software/libc/libc.html"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/glibc/locales_2.41-12+deb13u3_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "90f7a296b288ae2b19abc20824cad0bb"
SRC_URI[deb0.sha1sum] = "65ffb3351c54e795a3e066e749566b9841b3c95d"
SRC_URI[deb0.sha256sum] = "3d22cf6f84e762b3efbb0ffb1f24123e92ad83dd2e1268320dd246688e535a5f"
SRC_URI[deb0.sha512sum] = "e2f1ad4de55586d220dfe0ea8efe7cf279f3f3c01f21dacb9f5d418784e343db4dbd2f624b21487a190ad1a962fbcb37158889fc98b8376361131eb0dfb8c42f"

RDEPENDS = " \
    debconf \
    libc-bin \
    libc-l10n \
"

