# This was autogenerated! Do not modify
SUMMARY = "GNU privacy guard - localization files"
DESCRIPTION = ""
SECTION = "localization"
SOURCE_PACKAGE = "gnupg2"
HOMEPAGE = "https://www.gnupg.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gnupg2/gnupg-l10n_2.4.7-21+deb13u1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "d6916f3a15c7ff13faacf22effe2f806"
SRC_URI[deb0.sha1sum] = "b4ae0f59ffe016b3e05f06fbf0cafec6f15bfd72"
SRC_URI[deb0.sha256sum] = "65c0b5b06123f81f08cfa9b0be313cbc9cf6255c550d70eabd8b175ce8928a35"
SRC_URI[deb0.sha512sum] = "6c93b37f3090b64c49ced3fb0834bdc58868966155aa48b62b9a5782e4302cbecea100ebd659c95af73c732628a8de712c4c2de271d28861c32ecb86250e0418"


