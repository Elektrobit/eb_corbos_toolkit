# This was autogenerated! Do not modify
SUMMARY = "utilities for making and checking MS-DOS FAT filesystems"
DESCRIPTION = ""
SECTION = "otherosfs"
SOURCE_PACKAGE = "dosfstools"
HOMEPAGE = "https://github.com/dosfstools/dosfstools"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/d/dosfstools/dosfstools_4.2-1.2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/d/dosfstools/dosfstools_4.2-1.2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "5ce72aa7528549613fdfe9e27e5fda9b"
SRC_URI[deb0.sha1sum] = "c15c83dc2fd38334bd1ccbe8a7dba6ecc14232f3"
SRC_URI[deb0.sha256sum] = "628551496a02e80eee83054b9c696b06ba8177159bf0afe9a5b4ab2fb94b1b41"
SRC_URI[deb0.sha512sum] = "6dc32e2fe3e40c66cfabd3f713db43ec3cf0a4194ab8c96a25aca345accd2adc200021e46493caa5aeb454362a304ac45d069eee05c8631f8dac27dceb2c92c1"
SRC_URI[deb1.md5sum] = "5ebc90477ce984f08082920587beb01c"
SRC_URI[deb1.sha1sum] = "cddd3c4d3df94c57e02dc2e22207f5b361606fe6"
SRC_URI[deb1.sha256sum] = "7ec5c86659561b5e1b412227e0e3fab9dc17e4214274cb1b4cb3b5c5f8c288e9"
SRC_URI[deb1.sha512sum] = "5397798ad162d406a40d6b2451c9de2d0d1739ffd16522f9eba3ac3993bc2ccf8ba83d1c54372a806708476b515ca5b66cd16be9a18b8f3c58f45d73c39a1a26"

RDEPENDS = " \
    libc6 \
"

