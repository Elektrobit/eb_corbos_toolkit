# This was autogenerated! Do not modify
SUMMARY = "QEMU utilities"
DESCRIPTION = ""
SECTION = "otherosfs"
SOURCE_PACKAGE = "qemu"
HOMEPAGE = "http://www.qemu.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/q/qemu/qemu-utils_10.0.2+ds-2+deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/q/qemu/qemu-utils_10.0.2+ds-2+deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "006a8ee1a8eb62e28636753e11893168"
SRC_URI[deb0.sha1sum] = "399fb3888bcb8e3e982f5f1e9f275330e05e80b1"
SRC_URI[deb0.sha256sum] = "a9293c464dd3c27c31bc216ff562bc7c59debf5cacddb48eccbb1b07055db0d3"
SRC_URI[deb0.sha512sum] = "dc08ea8556d8a104f20ffecc75e807238ae73b4d682e1115fb1fa04d5d2c6c2b584224d45f70a2d2b91c37cbfba2357d3f88a6e887f5d6dcfcb4fba242eb6d22"
SRC_URI[deb1.md5sum] = "681709357412ccdabec7af7ed4b3dc26"
SRC_URI[deb1.sha1sum] = "4c7b7341eb886b9734799414f23d6c642e6b3243"
SRC_URI[deb1.sha256sum] = "fe10d93820f84e72414f8c44b5b4e10c96ae60850077d8cb50eadaaf66bad9b8"
SRC_URI[deb1.sha512sum] = "17edb6ba18fd1b50f5bf943aad83e10f45fb26595e00ea0af5fa460ba647755f44a904202e75b2f0b80b3a95a66c3dfdbd3c7046da83382ffd0df0e650e53997"

RDEPENDS = " \
    libaio1t64 \
    libc6 \
    libfuse3-4 \
    libglib2.0-0t64 \
    libgmp10 \
    libgnutls30t64 \
    libhogweed6t64 \
    libnettle8t64 \
    libnuma1 \
    libselinux1 \
    liburing2 \
    libzstd1 \
    zlib1g \
"

