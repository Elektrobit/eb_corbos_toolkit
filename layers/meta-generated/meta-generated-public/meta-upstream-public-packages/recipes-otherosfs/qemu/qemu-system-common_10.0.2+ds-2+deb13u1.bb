# This was autogenerated! Do not modify
SUMMARY = "QEMU full system emulation binaries (common files)"
DESCRIPTION = ""
SECTION = "otherosfs"
SOURCE_PACKAGE = "qemu"
HOMEPAGE = "http://www.qemu.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/q/qemu/qemu-system-common_10.0.2+ds-2+deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/q/qemu/qemu-system-common_10.0.2+ds-2+deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "e9f258f65d2c50a4a20f89abd2bad9ff"
SRC_URI[deb0.sha1sum] = "368062cc2204affa023330c0dd1ed6c3934e5665"
SRC_URI[deb0.sha256sum] = "12c4568ed6d0a008613534d780c850ed937fe9a62a3061a3dc968f870c509000"
SRC_URI[deb0.sha512sum] = "bbde0ad3ce325ed11583337f31a1abdea1889f66c69d3b43369c42300b03b915728c29b4ba723dd23617735ecaf139ae2aa13d18c3eba2c9a9da639b9c591248"
SRC_URI[deb1.md5sum] = "e38081a5933bd61aa7afe9dd63b31a2d"
SRC_URI[deb1.sha1sum] = "2aaeea9dfc9be3c093c3c5866d453e03a2620a53"
SRC_URI[deb1.sha256sum] = "4a9925233eb5b026fa57c2eeca44916716f2079521446c9a827efb4e98aa199b"
SRC_URI[deb1.sha512sum] = "b13293e0382299a3edf8469ffb4a1e55aaef2c58f3266f15ed5160450d075ece71ebe382d299b708d532905b2d43ba7aee84fc5e13a786ad686f2584e0ca9143"

RDEPENDS = " \
    libasound2t64 \
    libbrlapi0.8 \
    libc6 \
    libcacard0 \
    libcap-ng0 \
    libglib2.0-0t64 \
    libgmp10 \
    libgnutls30t64 \
    libhogweed6t64 \
    libncursesw6 \
    libnettle8t64 \
    libnuma1 \
    libpixman-1-0 \
    libtinfo6 \
    liburing2 \
    libusb-1.0-0 \
    libusbredirparser1t64 \
"

