# This was autogenerated! Do not modify
SUMMARY = "QEMU utilities"
DESCRIPTION = ""
SECTION = "otherosfs"
SOURCE_PACKAGE = "qemu"
HOMEPAGE = "http://www.qemu.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/q/qemu/qemu-utils_10.0.11+ds-0+deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/q/qemu/qemu-utils_10.0.11+ds-0+deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "cb09c076712cca73e04b16c8f48610f8"
SRC_URI[deb0.sha1sum] = "aa1bade4e8244337cdea663348f8800f40972e6a"
SRC_URI[deb0.sha256sum] = "d9dea3091178e8bad3566987ea122d8bbeb16be3e2e1f687ad90a56076b54d6c"
SRC_URI[deb0.sha512sum] = "4708a5e42cf92e5952ddd4c1376ce5b734fdd64f58dfadf38509630e519491f74818a96f4d1db6b918ae7d2b5216040945442cb6358d3c6f627eeda20f98901b"
SRC_URI[deb1.md5sum] = "4766d43a2509c1f4d347be5948766ffa"
SRC_URI[deb1.sha1sum] = "61d0dcef354ab4dc699ec48fa56cc537285b0d84"
SRC_URI[deb1.sha256sum] = "d5fe663b6145f16b2877cbf1ec2621923f3bdba56cb6b8013595627326786df2"
SRC_URI[deb1.sha512sum] = "0e284b945cb55b4a4a80557cdacb051c5be99c5b96708e8e70873200e1cd2796207b7d4208a7c5d59f4174c21326f9622af0c49980161ab5692618e68c7aa6a0"

RDEPENDS = " \
    libaio1t64 \
    libc6 \
    libfuse3-4 \
    libglib2.0-0t64 \
    libgmp10 \
    libgnutls30t64 \
    libhogweed6t64 \
    libnettle8t64 \
    libnuma1 \
    libselinux1 \
    liburing2 \
    libzstd1 \
    zlib1g \
"

