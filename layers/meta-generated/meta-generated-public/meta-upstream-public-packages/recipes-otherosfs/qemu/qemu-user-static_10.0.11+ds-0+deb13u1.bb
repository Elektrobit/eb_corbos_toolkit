# This was autogenerated! Do not modify
SUMMARY = "QEMU user mode emulation (compat/transitional package)"
DESCRIPTION = ""
SECTION = "otherosfs"
SOURCE_PACKAGE = "qemu"
HOMEPAGE = "http://www.qemu.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/q/qemu/qemu-user-static_10.0.11+ds-0+deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/q/qemu/qemu-user-static_10.0.11+ds-0+deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "fdabf6f3fe481dfaaa3a445b21ef18ff"
SRC_URI[deb0.sha1sum] = "78b33c9cae08d57519eb79d3b4f8bede43318e46"
SRC_URI[deb0.sha256sum] = "bf0c2fd2d97fe0f2016bc290d5a9eaf7b969d9f97c506dcba3c49abcef247848"
SRC_URI[deb0.sha512sum] = "61e4674a0083b235a133508865db518df3cbb7218d459ae8bbc2d4d61274ead803510d137f5524a671fb75bdf7cd14c35742e706929af75b67ba016dfb26e5da"
SRC_URI[deb1.md5sum] = "25419580d7f622053fc21c96b88b983c"
SRC_URI[deb1.sha1sum] = "46b1e6312082733563c8bfd7412da7b15a3fe351"
SRC_URI[deb1.sha256sum] = "163df0dc912f080514f853e2eb1f6d40d33504caa8e023bc27b0cbcdf8a90492"
SRC_URI[deb1.sha512sum] = "0e9c9d5c9f62adb13b62423652f373f292b92a4b6d6060f6bba6a64f70287e56666dbf702b51bdd03044b1848e5af800878a9cb66fbd9371d54a2e46f1b1b5c7"

RDEPENDS = " \
    qemu-user \
    qemu-user-binfmt \
"

