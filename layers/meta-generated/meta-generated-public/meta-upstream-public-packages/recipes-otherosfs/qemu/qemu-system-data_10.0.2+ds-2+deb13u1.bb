# This was autogenerated! Do not modify
SUMMARY = "QEMU full system emulation (data files)"
DESCRIPTION = ""
SECTION = "otherosfs"
SOURCE_PACKAGE = "qemu"
HOMEPAGE = "http://www.qemu.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/q/qemu/qemu-system-data_10.0.2+ds-2+deb13u1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "0a57a6edc5fd6edb1d54bced3b6755b6"
SRC_URI[deb0.sha1sum] = "49dbd38af497fa2a95467c31449a28f09cd26f79"
SRC_URI[deb0.sha256sum] = "66fc820b6032db0755708cbc77237f21ac5f34b2a25d645f3d5ca4fd9392e9d5"
SRC_URI[deb0.sha512sum] = "23b3fac72b6c8409cd685de7ff074576855921fd856076c77d30402b437b619a5a822269531ef5f4c361402e1c58a4bd4240f53c56df56c27eb6465d0d19713c"


RPROVIDES = " \
    openbios-ppc \
    openbios-sparc \
    qemu-keymaps \
    qemu-skiboot \
    qemu-slof \
    sgabios \
"
