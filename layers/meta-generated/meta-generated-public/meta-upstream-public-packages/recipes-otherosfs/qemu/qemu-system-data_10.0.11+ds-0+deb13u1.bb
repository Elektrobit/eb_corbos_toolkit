# This was autogenerated! Do not modify
SUMMARY = "QEMU full system emulation (data files)"
DESCRIPTION = ""
SECTION = "otherosfs"
SOURCE_PACKAGE = "qemu"
HOMEPAGE = "http://www.qemu.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/q/qemu/qemu-system-data_10.0.11+ds-0+deb13u1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "e2b55496e745f9b284351c2caa961c2d"
SRC_URI[deb0.sha1sum] = "5255195eb156694543364510e44f1aa409ae276e"
SRC_URI[deb0.sha256sum] = "5ab6916f8cbda16c9bfee3bc4ebdad917b47c6cceeed9309d920f85c01a73c4e"
SRC_URI[deb0.sha512sum] = "81db2e03f738339cbcd874cbe5340b965daf36c340660a9502e073477f9604707934e354a1dce5b7423d7bdf0dfcf55cc9a7228bdd5a9a7400c5e9ce9a11cfbb"


RPROVIDES = " \
    openbios-ppc \
    openbios-sparc \
    qemu-keymaps \
    qemu-skiboot \
    qemu-slof \
    sgabios \
"
