# This was autogenerated! Do not modify
SUMMARY = "QEMU user mode emulation (compat/transitional package)"
DESCRIPTION = ""
SECTION = "otherosfs"
SOURCE_PACKAGE = "qemu"
HOMEPAGE = "http://www.qemu.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/q/qemu/qemu-user-static_10.0.2+ds-2+deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/q/qemu/qemu-user-static_10.0.2+ds-2+deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "575e1ab34e0e75fa707d6430443cb663"
SRC_URI[deb0.sha1sum] = "43f3780089e61bfee4008e8159ae145e907d7b5a"
SRC_URI[deb0.sha256sum] = "49efc331942669948c961df1a5b2da815304ddf38ec29bb2928ec171b7ab683c"
SRC_URI[deb0.sha512sum] = "26b2cbc38b5069ac1bacee7036a96c09c5d7225abfab0489764cf7b01c7dab160d1812030e42dfd9612614d0b6ba64127eeb065ea5457f356f9d4ecc006ca2d4"
SRC_URI[deb1.md5sum] = "84f335624ae76defaebb57e3e0d94ff0"
SRC_URI[deb1.sha1sum] = "b296592200e2013bc47d360bf66faffe7edb2a78"
SRC_URI[deb1.sha256sum] = "d27325811d7f8b7e798723630d7b51bb9e15f5907b2c154329267edf9c5c6c34"
SRC_URI[deb1.sha512sum] = "44e200dfe0da6d185fa1a5f1fff43d82cd246c66eb0922eeed2f7987419c3e717dad4ad8f7b4255513c170c06cfa53ef120e3644537d111b2c015c591013e4ee"

RDEPENDS = " \
    qemu-user \
    qemu-user-binfmt \
"

