# This was autogenerated! Do not modify
SUMMARY = "QEMU user mode emulation (static binaries)"
DESCRIPTION = ""
SECTION = "otherosfs"
SOURCE_PACKAGE = "qemu"
HOMEPAGE = "http://www.qemu.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/q/qemu/qemu-user_10.0.11+ds-0+deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/q/qemu/qemu-user_10.0.11+ds-0+deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "15449f9b807dedba0cc3642a4d5bdf5c"
SRC_URI[deb0.sha1sum] = "a0eaa62f815efb2361d43b1e3f8011c17ad9123a"
SRC_URI[deb0.sha256sum] = "6b6fea55551fbcc1eb30e146ad5abdfbb49f8fa8c5998016242126de4d7f80df"
SRC_URI[deb0.sha512sum] = "cdd473ad86b66c891002d15a1fc129e6d4f60082c2149abc0b5790c17b5ce4806b0bce7bdb0f45f9f59bf286137004f5438f6d51ba62f1f4fecbb27d7d6728b3"
SRC_URI[deb1.md5sum] = "3cbaf9daf85af263e2bdd41e3d939f21"
SRC_URI[deb1.sha1sum] = "85aabd6e4b143513d528e05a94caef7305fe0f38"
SRC_URI[deb1.sha256sum] = "bb194fdc8c20a11b30e69cae469152942fb7921a0634dac5bea8e82cf6c807ae"
SRC_URI[deb1.sha512sum] = "b4500f00b8f6fbc68775c062dc075cc4826238cdd683d24ccb71c250c4a0a0a4adcbffb2bfb238cf472529653302b61110d74b887ab019be5272e64b203b7f9f"


