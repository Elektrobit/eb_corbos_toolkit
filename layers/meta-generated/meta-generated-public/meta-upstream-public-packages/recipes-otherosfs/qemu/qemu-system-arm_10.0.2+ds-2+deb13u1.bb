# This was autogenerated! Do not modify
SUMMARY = "QEMU full system emulation binaries (arm)"
DESCRIPTION = ""
SECTION = "otherosfs"
SOURCE_PACKAGE = "qemu"
HOMEPAGE = "http://www.qemu.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/q/qemu/qemu-system-arm_10.0.2+ds-2+deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/q/qemu/qemu-system-arm_10.0.2+ds-2+deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "5bda743d2cf631f3ef5b15c1cfc5d544"
SRC_URI[deb0.sha1sum] = "2bafba27d539135a51997d0b0370aa959e60f861"
SRC_URI[deb0.sha256sum] = "46b6109f663c36ff186eec8cd9d62f834242743d02a484055b6deb97418d52c5"
SRC_URI[deb0.sha512sum] = "24450e14451bda5c0c24276fb7ca0404bde8c9ab71fe9b63436ac539f715b05332aefb55e9848c203db4aaa2d61aafe8217996299e7fca70094ba36c85c52ff7"
SRC_URI[deb1.md5sum] = "02f7f832af7914c6e65eac914ab46fae"
SRC_URI[deb1.sha1sum] = "e71701278797ce3a56c71187b704257493ce4f8d"
SRC_URI[deb1.sha256sum] = "e7b9ef90da92e4f20b7e971878b0ba2c8b647ab6802a3f3ce9e011636b9fba2d"
SRC_URI[deb1.sha512sum] = "c49228836cb6f0c0c89f63ffe58c59991a137c97614ebd9c57018331cc77da2ba032691ef38199860d2ef202ea3988efcd841b8fbe911035d47b8069489df2be"

RDEPENDS = " \
    libaio1t64 \
    libbpf1 \
    libc6 \
    libcapstone5 \
    libfdt1 \
    libfuse3-4 \
    libglib2.0-0t64 \
    libgmp10 \
    libgnutls30t64 \
    libhogweed6t64 \
    libibverbs1 \
    libjpeg62-turbo \
    libnettle8t64 \
    libnuma1 \
    libpixman-1-0 \
    libpmem1 \
    libpng16-16t64 \
    librdmacm1t64 \
    libsasl2-2 \
    libseccomp2 \
    libslirp0 \
    libudev1 \
    liburing2 \
    libvdeplug2t64 \
    libzstd1 \
    qemu-system-common \
    qemu-system-data \
    zlib1g \
"

RPROVIDES = " \
    qemu-system-aarch64 \
    qemu-system-any \
    qemu-system-arm64 \
    qemu-system-armel \
    qemu-system-armhf \
"
RPROVIDES:append:arm64 = " \
    qemu-kvm \
    qemu-system-native \
"
