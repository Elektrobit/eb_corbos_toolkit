# This was autogenerated! Do not modify
SUMMARY = "QEMU full system emulation binaries (common files)"
DESCRIPTION = ""
SECTION = "otherosfs"
SOURCE_PACKAGE = "qemu"
HOMEPAGE = "http://www.qemu.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/q/qemu/qemu-system-common_10.0.11+ds-0+deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/q/qemu/qemu-system-common_10.0.11+ds-0+deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "7c5d65473a180b37f864a2673b8b10c3"
SRC_URI[deb0.sha1sum] = "445e1450e0cdbd680fd0f57c6dde005a386dd7c7"
SRC_URI[deb0.sha256sum] = "35bbfdca8de3967a3412d1beff4309127de0c330e1430ddc1a458f4f1cc37c78"
SRC_URI[deb0.sha512sum] = "fe5214cba3aa5be6b466d9b943f1d0c3fbb23cf40169fc5a254fd446c49d39bdd473a4cf11d31d40cc24552fde4256f38a915c0585d57dd4fed9b4f4ea296699"
SRC_URI[deb1.md5sum] = "c9e85356af3629e4ec29be5ab55eb881"
SRC_URI[deb1.sha1sum] = "92e5ec2ac7149a7022b93c4646ed9ff1ce888717"
SRC_URI[deb1.sha256sum] = "0f39b69dc7ec7149fbdb2046d83f2d6bb9825b91fc2bcf1db1eac8d51ed6b613"
SRC_URI[deb1.sha512sum] = "12b9072a943b4851e7ccc4958b202f218336b3e4af1b286c6385dab2a2f9cccfd31e8d53be3812ba52823f615ce7c3bac2dc6514da2771c31cade4f919742738"

RDEPENDS = " \
    libasound2t64 \
    libbrlapi0.8 \
    libc6 \
    libcacard0 \
    libcap-ng0 \
    libglib2.0-0t64 \
    libgmp10 \
    libgnutls30t64 \
    libhogweed6t64 \
    libncursesw6 \
    libnettle8t64 \
    libnuma1 \
    libpixman-1-0 \
    libtinfo6 \
    liburing2 \
    libusb-1.0-0 \
    libusbredirparser1t64 \
"

