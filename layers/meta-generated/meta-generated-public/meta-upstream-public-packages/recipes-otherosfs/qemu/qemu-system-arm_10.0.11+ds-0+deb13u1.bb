# This was autogenerated! Do not modify
SUMMARY = "QEMU full system emulation binaries (arm)"
DESCRIPTION = ""
SECTION = "otherosfs"
SOURCE_PACKAGE = "qemu"
HOMEPAGE = "http://www.qemu.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/q/qemu/qemu-system-arm_10.0.11+ds-0+deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/q/qemu/qemu-system-arm_10.0.11+ds-0+deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "082b1b736c1037ea99a98828c6a68de7"
SRC_URI[deb0.sha1sum] = "3b79d2b0fdda3433938df27f9af4395f542038bc"
SRC_URI[deb0.sha256sum] = "72ad762eaff440211b2d0f9d05cbc9b139016c8bd951a6fa62eb9c3987d4d2e2"
SRC_URI[deb0.sha512sum] = "3b04efc934921962b77378aaec5e43c70be50628fe907711e2ec920c9543cd3e19effb0190af978b0032078a41b93eec1d64763011f4b8b65c2b769bcdb70e55"
SRC_URI[deb1.md5sum] = "f7ee343add0a46026a16be310b687445"
SRC_URI[deb1.sha1sum] = "d7d03717b4b27577e0c8fe56e84b45d6f976f569"
SRC_URI[deb1.sha256sum] = "54b473ea6ce018e3fbf675dc24516197a9a31b5c5e743cc8025601ff8c93d4e9"
SRC_URI[deb1.sha512sum] = "ff5caa2e96535f6014cc40471a07313806758f5746ab2a8b81f3ac4787ab836ba86c90dec554695b5cb7ed194031d8a97c2bdcd0680f7e4f8faa18c2ed267028"

RDEPENDS = " \
    libaio1t64 \
    libbpf1 \
    libc6 \
    libcapstone5 \
    libfdt1 \
    libfuse3-4 \
    libglib2.0-0t64 \
    libgmp10 \
    libgnutls30t64 \
    libhogweed6t64 \
    libibverbs1 \
    libjpeg62-turbo \
    libnettle8t64 \
    libnuma1 \
    libpixman-1-0 \
    libpmem1 \
    libpng16-16t64 \
    librdmacm1t64 \
    libsasl2-2 \
    libseccomp2 \
    libslirp0 \
    libudev1 \
    liburing2 \
    libvdeplug2t64 \
    libzstd1 \
    qemu-system-common \
    qemu-system-data \
    zlib1g \
"

RPROVIDES = " \
    qemu-system-aarch64 \
    qemu-system-any \
    qemu-system-arm64 \
    qemu-system-armel \
    qemu-system-armhf \
"
RPROVIDES:append:arm64 = " \
    qemu-kvm \
    qemu-system-native \
"
