# This was autogenerated! Do not modify
SUMMARY = "QEMU user mode emulation (static binaries)"
DESCRIPTION = ""
SECTION = "otherosfs"
SOURCE_PACKAGE = "qemu"
HOMEPAGE = "http://www.qemu.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/q/qemu/qemu-user_10.0.2+ds-2+deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/q/qemu/qemu-user_10.0.2+ds-2+deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "d6d20c3d5c08be5f0996f442fc495315"
SRC_URI[deb0.sha1sum] = "d81604f33baabafcf98e1f2962c6a09add32f8c6"
SRC_URI[deb0.sha256sum] = "ac60ebf92f482731e6a89ff5428c805a74f3e66c062670b89c81d2f7512d6c38"
SRC_URI[deb0.sha512sum] = "c7e1a632a20f67a40afbd9de6bf54da2cd546809f5a0fd7d77683611e8f74dd98bd6666d8d9591f9e5813d862832dec32de3fdb475686606508d61e652fa4cf1"
SRC_URI[deb1.md5sum] = "93529c898640a135afe9fa9521ba9810"
SRC_URI[deb1.sha1sum] = "bd479f80b394224792d69a0719bf1ba353c54aec"
SRC_URI[deb1.sha256sum] = "a2bbd74c6777968f6a252e0923051f56c4b30d9632a3e913cdd0ce71ecf26f81"
SRC_URI[deb1.sha512sum] = "fd59d05feb2f2a3263c5b6aeccfb7ac31f8d9c2a01a59e106e9bf4ffd8469d5f9c3b0fe5b58ebb4b2de32ad2e9cb624da59b86b8bb7180cbfdda8e729c57f39a"


