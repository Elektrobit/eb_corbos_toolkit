# This was autogenerated! Do not modify
SUMMARY = "Tools for manipulating MSDOS files"
DESCRIPTION = ""
SECTION = "otherosfs"
SOURCE_PACKAGE = "mtools"
HOMEPAGE = "https://www.gnu.org/software/mtools/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/m/mtools/mtools_4.0.48-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/m/mtools/mtools_4.0.48-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "ae5a48884107698eec0da05a2c8e75de"
SRC_URI[deb0.sha1sum] = "ffa895436af9fd0ca88e64488865d4afaaa60ec2"
SRC_URI[deb0.sha256sum] = "e7069109ce49f5a450caeca681e454f24dc412f9fdb289cde54e115162203760"
SRC_URI[deb0.sha512sum] = "2d26483219b7db407f4478476b665aeef29936dfdaa1cb05639057eac8d0ccab86334d19eff8db37f3ee0befc42718f03bce5dfae2724589705238ce28b7e84e"
SRC_URI[deb1.md5sum] = "bf32d33c3ff9ea2f145cd49f88fc4184"
SRC_URI[deb1.sha1sum] = "2b8684272a5ad5453517e82a7b9e62c78e32a951"
SRC_URI[deb1.sha256sum] = "296cf0a6b06433520effc30542a695307f4abf0d377f94d8a22dc8bd1dd4785f"
SRC_URI[deb1.sha512sum] = "8b7086c7ecfc499b631bdb1c9db3e9c500334976534e89df0dd2f450fb09b6aa7ea98b7bf91ddd46aeb96922717c2d82612437da484f244a9e812fb4a4b2a120"

RDEPENDS = " \
    libc6 \
"

