# This was autogenerated! Do not modify
SUMMARY = "GNU C preprocessor for x86_64-linux-gnu"
DESCRIPTION = ""
SECTION = "interpreters"
SOURCE_PACKAGE = "gcc-14"
HOMEPAGE = "http://gcc.gnu.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "amd64"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gcc-14/cpp-14-x86-64-linux-gnu_14.2.0-19_amd64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "e044e09878431be4356c4465a1b49956"
SRC_URI[deb0.sha1sum] = "9c4366e4fe4d151aef20ec7059fe79f8a6cfbdce"
SRC_URI[deb0.sha256sum] = "ef274b5379f5f97fc71619d39ecc84d039d3e184570d207b909c90afaa5d79e0"
SRC_URI[deb0.sha512sum] = "15122164861944b5af2c8b245a066b55a10061da17576dad740a6e5678ae0fbbcb3b3466e1b0c300e6c736f741ed0458668b86ce3862eef3948541e2a599d85b"

RDEPENDS = " \
    gcc-14-base \
    libc6 \
    libgmp10 \
    libisl23 \
    libmpc3 \
    libmpfr6 \
    libzstd1 \
    zlib1g \
"

