# This was autogenerated! Do not modify
SUMMARY = "GNU C preprocessor"
DESCRIPTION = ""
SECTION = "interpreters"
SOURCE_PACKAGE = "gcc-14"
HOMEPAGE = "http://gcc.gnu.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gcc-14/cpp-14_14.2.0-19_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gcc-14/cpp-14_14.2.0-19_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "4f64d2ad43b3b5468651014254bf4ad1"
SRC_URI[deb0.sha1sum] = "fd8035b2512c7ea141bb362d99cdb8edc83bb65b"
SRC_URI[deb0.sha256sum] = "3bae5fe03c56c6d021900ab4fb79e35c6f75eee72a73fccc6f28a39db559d6a0"
SRC_URI[deb0.sha512sum] = "71f143bbabb838949720c7104914533a2100fd9defd4c6638a37d51a0d78928c44b5e0c6167ed1f4e73bd4549ef3f07f4bacd4bf78d03f57c7446b620f610550"
SRC_URI[deb1.md5sum] = "f3279de7159677f03d14951df2abac7b"
SRC_URI[deb1.sha1sum] = "56ca585f2bcfa590624590a6f0ca66fe253d6e34"
SRC_URI[deb1.sha256sum] = "0b440241f7c3e2e87f2d0f1dd36792c4e2705d38a699ed331818799f21ef9437"
SRC_URI[deb1.sha512sum] = "53351654965e492e61820fa076d83eaaff1277cef87b49cea7f1cf4445fd532f86c31c557c1c014ab0bd859a1d29f2db44ccb9616c3bc25f3db0747e61d6287f"

RDEPENDS = " \
    gcc-14-base \
"
RDEPENDS:append:amd64 = " \
    cpp-14-x86-64-linux-gnu \
"
RDEPENDS:append:arm64 = " \
    cpp-14-aarch64-linux-gnu \
"

