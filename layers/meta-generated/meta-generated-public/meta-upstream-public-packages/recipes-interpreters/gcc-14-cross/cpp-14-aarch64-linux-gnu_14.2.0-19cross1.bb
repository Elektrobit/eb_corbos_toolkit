# This was autogenerated! Do not modify
SUMMARY = "GNU C preprocessor for aarch64-linux-gnu"
DESCRIPTION = ""
SECTION = "interpreters"
SOURCE_PACKAGE = "gcc-14-cross"
HOMEPAGE = "http://gcc.gnu.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "amd64"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gcc-14-cross/cpp-14-aarch64-linux-gnu_14.2.0-19cross1_amd64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "04b0e81d898f0be945bfbffb14fd3ad8"
SRC_URI[deb0.sha1sum] = "51144b16e37a8d49357e303d7270e4f54ab0e9f2"
SRC_URI[deb0.sha256sum] = "6610dda7938376fefcbc3b49c81cd23c82e86411a488e4c9a69c082f2acd714e"
SRC_URI[deb0.sha512sum] = "28d54303544c724a1fc7247bb152516580420c1bda9e29e5a65edb94ff11d590f65ba84159a8fb772014d6c35ef27a51138f2415722dac87ca3d94e627217b4b"

RDEPENDS = " \
    gcc-14-aarch64-linux-gnu-base \
    libc6 \
    libgmp10 \
    libisl23 \
    libmpc3 \
    libmpfr6 \
    libzstd1 \
    zlib1g \
"

