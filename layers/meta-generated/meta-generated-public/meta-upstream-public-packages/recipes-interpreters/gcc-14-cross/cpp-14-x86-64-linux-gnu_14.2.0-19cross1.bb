# This was autogenerated! Do not modify
SUMMARY = "GNU C preprocessor for x86_64-linux-gnu"
DESCRIPTION = ""
SECTION = "interpreters"
SOURCE_PACKAGE = "gcc-14-cross"
HOMEPAGE = "http://gcc.gnu.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gcc-14-cross/cpp-14-x86-64-linux-gnu_14.2.0-19cross1_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "b8ddc76a880e8b9d7108ae1d4629400b"
SRC_URI[deb0.sha1sum] = "6502dc6901907600c18ddced872d5dead66fb826"
SRC_URI[deb0.sha256sum] = "ec8d17b095df075a16c80a15979c196c315af8f88ba0b3231c44b45135b6c444"
SRC_URI[deb0.sha512sum] = "d3d8963f4b61ed1e9f17752c233055f178de3fc553357ee8afb48109dfbbafdde020e39a1217edcd8745474c1a858c3c52921104412c210776b97e28a83a06a3"

RDEPENDS = " \
    gcc-14-x86-64-linux-gnu-base \
    libc6 \
    libgmp10 \
    libisl23 \
    libmpc3 \
    libmpfr6 \
    libzstd1 \
    zlib1g \
"

