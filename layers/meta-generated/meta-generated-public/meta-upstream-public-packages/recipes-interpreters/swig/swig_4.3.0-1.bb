# This was autogenerated! Do not modify
SUMMARY = "Generate scripting interfaces to C/C++ code"
DESCRIPTION = ""
SECTION = "interpreters"
SOURCE_PACKAGE = "swig"
HOMEPAGE = "https://www.swig.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/swig/swig_4.3.0-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/swig/swig_4.3.0-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "709ba7f0be40b1e1c9af10f733fb44ce"
SRC_URI[deb0.sha1sum] = "a3f9a66243bb242325c131c8cf6db24f9ae52bb5"
SRC_URI[deb0.sha256sum] = "fe8749993e720a232582c13a5ddcaeb074c435a1f1c6ed2ffe0db597a972a069"
SRC_URI[deb0.sha512sum] = "78ff9b5e64e9a7113e67bba077ea1230aea4c6129e061bbec59b64dcd4eb8a9d86eeb9fdd7dda8fe661e6f7f1c6c19b0c1d66b4a011eefc6e20e77984088b308"
SRC_URI[deb1.md5sum] = "5f1799eb1b87514ccb5ac3e7e1655d49"
SRC_URI[deb1.sha1sum] = "84ec03307c47717566f12ea14edbbf19b5c85abc"
SRC_URI[deb1.sha256sum] = "160d857d3f3ee5a7162bbfb0eeabbb531d1aba7a026d42b1dab2148d00115b00"
SRC_URI[deb1.sha512sum] = "bfe4ce07b6ed95625826194735758787862e205beb4899af9496c7c3b17afcb6a5543d493142db8e3bd0f2f14e28887648cd82ec7d997b39f8f24843efba4b3c"

RDEPENDS = " \
    libc6 \
    libgcc-s1 \
    libpcre2-8-0 \
    libstdc++6 \
"

