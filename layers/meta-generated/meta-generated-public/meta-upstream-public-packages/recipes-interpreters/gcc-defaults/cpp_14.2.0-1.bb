# This was autogenerated! Do not modify
SUMMARY = "GNU C preprocessor (cpp)"
DESCRIPTION = ""
SECTION = "interpreters"
SOURCE_PACKAGE = "gcc-defaults"
HOMEPAGE = ""

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gcc-defaults/cpp_14.2.0-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gcc-defaults/cpp_14.2.0-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "cbc461a4914b8d953367de0d83f055d4"
SRC_URI[deb0.sha1sum] = "f7b230ddaa3127073239649f4af2d6d8897d717a"
SRC_URI[deb0.sha256sum] = "a6ba40550aadec80437813e0fce5516574945ff40e72306a5b378c03af3a6544"
SRC_URI[deb0.sha512sum] = "eeedc7862ca859554c18bc861251432af0105b7b8a0d9970cc4fa49e946828e854ad0e09d23766063fface6b1ac881dd17d1a48ec2957c8d0758ea44e88e3d94"
SRC_URI[deb1.md5sum] = "3f9f3a3d1114484ac112460fb38f5a5a"
SRC_URI[deb1.sha1sum] = "fcad1e38b3a08bcefaa8451b101d3c3f3ed123fc"
SRC_URI[deb1.sha256sum] = "88b702b0fa5942a4ee52c27f1ccf6316b831357e86693b709d216ba43348172e"
SRC_URI[deb1.sha512sum] = "7c4f808a1e091beea9567d044d73ec6f462744064ad537a11b485f8a2b197a5a68390c158afd5a0b3c9bf09a94ac3d4d2eee16919626ee0ffef4a0b7071e407a"

RDEPENDS = " \
    cpp-14 \
"
RDEPENDS:append:amd64 = " \
    cpp-x86-64-linux-gnu \
"
RDEPENDS:append:arm64 = " \
    cpp-aarch64-linux-gnu \
"

