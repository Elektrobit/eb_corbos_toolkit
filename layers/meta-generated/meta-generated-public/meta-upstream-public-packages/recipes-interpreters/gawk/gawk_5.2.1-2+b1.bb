# This was autogenerated! Do not modify
SUMMARY = "GNU awk, a pattern scanning and processing language"
DESCRIPTION = ""
SECTION = "interpreters"
SOURCE_PACKAGE = "gawk"
HOMEPAGE = "http://www.gnu.org/software/gawk/"

inherit dpkg-prebuilt

DPKG_ARCH = "amd64"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gawk/gawk_5.2.1-2+b1_amd64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "93d7dd31cdebefe2fedb5964de8fe56f"
SRC_URI[deb0.sha1sum] = "c27d729cf6c68e2f42918f210bf717a28489f552"
SRC_URI[deb0.sha256sum] = "0e3b376e74cadfa5049bc8248c563efe89fd45e31466f8891c094c65c0879f5c"
SRC_URI[deb0.sha512sum] = "1b46de8afa1dbb047a85bf077eaeef7beb9dda16bae5b6d88b811a69166d5cb826d0cb7d181c48be5fea0653c5ff8b1b0439af320f6c8aa1f03d2c269174194b"

RDEPENDS = " \
    libc6 \
    libgmp10 \
    libmpfr6 \
    libreadline8t64 \
    libsigsegv2 \
"

RPROVIDES = " \
    awk \
"
