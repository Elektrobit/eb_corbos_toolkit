# This was autogenerated! Do not modify
SUMMARY = "macro processing language"
DESCRIPTION = ""
SECTION = "interpreters"
SOURCE_PACKAGE = "m4"
HOMEPAGE = "https://www.gnu.org/software/m4/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/m/m4/m4_1.4.19-8_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/m/m4/m4_1.4.19-8_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "b8930535a1c1d8e826c51aac95e01537"
SRC_URI[deb0.sha1sum] = "2d15c26c60a7d26e40e6335bc16287c300c055df"
SRC_URI[deb0.sha256sum] = "221b3e224708c1da2a1a88b6824380593579b2254ae7d914afa14cbd5d343334"
SRC_URI[deb0.sha512sum] = "8d7bc0e15f22885d569610c8eedb49788416b2aa6e9463018ab3b212f60f615d8662deb87d49f600c8b536edf4746da04143e6243d537d0dbd2a3658619c4a2b"
SRC_URI[deb1.md5sum] = "68ad2ca75440b75f99a3852053dc1d73"
SRC_URI[deb1.sha1sum] = "2b7ffd02f0ae6f8ba600d1ac4371a9d373f1bc05"
SRC_URI[deb1.sha256sum] = "6f1cd89c9f42844682e2aa8529511f53ad44d4ecb0f1df459a7302be0e1d4f85"
SRC_URI[deb1.sha512sum] = "8b77075b0925e397169a23d3cad295fc9e04922617f202329f3824ad7017c19e235bfb49d413d6f631d4135fed1069a765e96fcb207628dac96b68c7a27416ee"

RDEPENDS = " \
    libc6 \
"

