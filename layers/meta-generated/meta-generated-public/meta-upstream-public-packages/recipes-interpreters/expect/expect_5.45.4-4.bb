# This was autogenerated! Do not modify
SUMMARY = "Automates interactive applications"
DESCRIPTION = ""
SECTION = "interpreters"
SOURCE_PACKAGE = "expect"
HOMEPAGE = "https://core.tcl.tk/expect/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/e/expect/expect_5.45.4-4_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/e/expect/expect_5.45.4-4_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "6e68f8e80be9ac26f53608dcf6e94f0b"
SRC_URI[deb0.sha1sum] = "79a3280ace951dbd90da6406cf4336dee90bf459"
SRC_URI[deb0.sha256sum] = "44c89a2f2b35d7e43ab7aaa60789cb8fe60957ded4c630670366ea853627a65c"
SRC_URI[deb0.sha512sum] = "ac86bd9399bd25cdb586435484f86b919fc61d2f25f6ff1b2883edfbe536001f6d7771b8a6be51d829f3852ea909414bb17346f3ab4effc5307810cb1556662e"
SRC_URI[deb1.md5sum] = "e5549c45db3d0f059fd4db1eabf661db"
SRC_URI[deb1.sha1sum] = "7680794d4f224950e85746f24398a1ca5a7fb76b"
SRC_URI[deb1.sha256sum] = "c2d87a99505bc47d8134251a3834256d391a92be9b92bedb8ae80180bda9870f"
SRC_URI[deb1.sha512sum] = "72f7846195fdd5d1d43eabb7e2b455000da2972d0f082e298b3f1e677fe87dc362120ac23e662e0b19c9b725ecdc9790997b34b7fe7997d4bbe5b153d8ab9134"

RDEPENDS = " \
    libc6 \
    libtcl8.6 \
    tcl-expect \
    tcl8.6 \
"

RPROVIDES = " \
    expect-dev \
"
