# This was autogenerated! Do not modify
SUMMARY = "Automates interactive applications (Tcl package)"
DESCRIPTION = ""
SECTION = "interpreters"
SOURCE_PACKAGE = "expect"
HOMEPAGE = "https://core.tcl.tk/expect/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/e/expect/tcl-expect_5.45.4-4_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/e/expect/tcl-expect_5.45.4-4_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "cb3229eb27a12557d9c69824b7e7e86f"
SRC_URI[deb0.sha1sum] = "c21dd1746a2505e4e896bb0b754445743350329f"
SRC_URI[deb0.sha256sum] = "2b942529987394969cded635d93d8d024793d1e936e9ac638ec359eb972b3125"
SRC_URI[deb0.sha512sum] = "08c646a0017a61caa6d74d4fed1118e13f5b5e5129274b6d7ef02a6ae7d52ae5a2fe48d693755d58bff07aa576fa080af02a43fdee36286cffe6c936e61e5d06"
SRC_URI[deb1.md5sum] = "b35f6d361b726d152016852479593da4"
SRC_URI[deb1.sha1sum] = "eed82520102fcb47c207c4eac9d8e99b03fd8a4f"
SRC_URI[deb1.sha256sum] = "37e02bd1438c485b865f0330485b13055b31bd17c39d4b500a443ce448f298f4"
SRC_URI[deb1.sha512sum] = "bffc4639a49e5fe58bbbbf4040f753778c166aed26e64bed49df5b561e4eea3c2ccc3b41763810aca67a5cc7b44d5e933e7d6bd7743dd9fff46d59ba7227e4a4"

RDEPENDS = " \
    libc6 \
    libtcl8.6 \
"

