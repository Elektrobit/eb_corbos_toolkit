# This was autogenerated! Do not modify
SUMMARY = "Configuration files and manpages for github.com/containers repositories"
DESCRIPTION = ""
SECTION = "golang"
SOURCE_PACKAGE = "golang-github-containers-image"
HOMEPAGE = "https://github.com/containers/image"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/golang-github-containers-image/golang-github-containers-image_5.34.2-1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "caaa88d5252e9ac315285ad09ebc56f9"
SRC_URI[deb0.sha1sum] = "0853f6a73e022f402749a389e15c31baa5baeaac"
SRC_URI[deb0.sha256sum] = "26575641adfd1cdfd4972e2aa2823536d2f4095de873f452f5b12333beff4dec"
SRC_URI[deb0.sha512sum] = "492c4dc2b6db771763ecb6e676f46ba774d9e68c8465f9aa668d466b21c2ed8286f279025e1f671a06144ca2f6f571fcb0d114c446fc0245393583708fac7a0b"


