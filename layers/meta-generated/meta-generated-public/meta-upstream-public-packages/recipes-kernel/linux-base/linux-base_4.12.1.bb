# This was autogenerated! Do not modify
SUMMARY = "Linux image base package"
DESCRIPTION = ""
SECTION = "kernel"
SOURCE_PACKAGE = "linux-base"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/l/linux-base/linux-base_4.12.1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "367460dc7b063db60cafd022123e845d"
SRC_URI[deb0.sha1sum] = "7980264a10c46f5984fce6da8363c5231495ed2e"
SRC_URI[deb0.sha256sum] = "d86e703aff81f404f2104af9411fd2acbae5fdb65f9264e488bb276a77a562be"
SRC_URI[deb0.sha512sum] = "abe917308a10cc5a39095b8b4f75f047cd49aad2352508f292d115091a37f6ccc886df784e0cdb6caded4c795ae308c9b642b803bd19abbc4cdb251a8f6baf7c"

RDEPENDS = " \
    debconf \
"

