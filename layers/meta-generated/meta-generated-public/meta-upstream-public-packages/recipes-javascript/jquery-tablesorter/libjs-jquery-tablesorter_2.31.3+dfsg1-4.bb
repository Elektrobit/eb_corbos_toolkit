# This was autogenerated! Do not modify
SUMMARY = "jQuery flexible client-side table sorting plugin"
DESCRIPTION = ""
SECTION = "javascript"
SOURCE_PACKAGE = "jquery-tablesorter"
HOMEPAGE = "https://github.com/Mottie/tablesorter"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/j/jquery-tablesorter/libjs-jquery-tablesorter_2.31.3+dfsg1-4_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "d6441e82c5ca7349453ff0da64fb4b4b"
SRC_URI[deb0.sha1sum] = "c9df763ddf2d71e13ef2572fff9dd263520b97bf"
SRC_URI[deb0.sha256sum] = "fa89afd58443d81460df6c1cf3b3d2c03b58b5402afa4a5023c5f8848afed284"
SRC_URI[deb0.sha512sum] = "fd1d5f706da598782314062310760d9697b4b34052f60ca86fd17ad8bf2dfa5f602d663b52dc3a94ff8f114973893c70dabeffbc66b93446baca64caeb028eec"

RDEPENDS = " \
    libjs-jquery \
    libjs-jquery-metadata \
"

