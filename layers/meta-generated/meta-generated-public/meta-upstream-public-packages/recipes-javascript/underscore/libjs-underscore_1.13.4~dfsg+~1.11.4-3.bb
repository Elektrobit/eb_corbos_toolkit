# This was autogenerated! Do not modify
SUMMARY = "JavaScript's functional programming helper library"
DESCRIPTION = ""
SECTION = "javascript"
SOURCE_PACKAGE = "underscore"
HOMEPAGE = "https://underscorejs.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/u/underscore/libjs-underscore_1.13.4~dfsg+~1.11.4-3_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "ab489f52a05cb6f576a7f31bbb51ac3b"
SRC_URI[deb0.sha1sum] = "c6d238a61fe0cc68c6ff58c7c9afbbdb4c3ebbe8"
SRC_URI[deb0.sha256sum] = "4a0fbc90e7f62ea50c4ac7453352721fa60bb5eac87e9f39a027908faff29015"
SRC_URI[deb0.sha512sum] = "183fd8051ac6402e5f24ed75b5f195df0ea9106c65e6ef65bafe10019ac1da547fb5b28781ff67a29c5a1803be850b79b31e792a8aed652227283a03f509cb77"


