# This was autogenerated! Do not modify
SUMMARY = "easily add and remove handlers for keyboard events anywhere in your code"
DESCRIPTION = ""
SECTION = "javascript"
SOURCE_PACKAGE = "libjs-jquery-hotkeys"
HOMEPAGE = "https://github.com/tzuryby/jquery.hotkeys"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libj/libjs-jquery-hotkeys/libjs-jquery-hotkeys_0.2.0-1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "3c230b9f2664d91d6d398c79d3ebcdcd"
SRC_URI[deb0.sha1sum] = "82c81b928192c4d92f78b6f77384f3bb0329d632"
SRC_URI[deb0.sha256sum] = "cae9ee63cfed199149721d962bcb18dd7565039ba31af32a875338f2cc48194f"
SRC_URI[deb0.sha512sum] = "92ce4e359d318ec0ab1310d01fff5a25e8acfaba20179df2aa6abf920ab2dbe248d2bfbf3af1abcc837a448705e568ed58ecb883feab2bf25c968e6efaa354dd"

RDEPENDS = " \
    libjs-jquery \
"

