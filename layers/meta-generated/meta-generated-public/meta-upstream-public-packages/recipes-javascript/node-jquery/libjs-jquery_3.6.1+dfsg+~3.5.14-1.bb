# This was autogenerated! Do not modify
SUMMARY = "JavaScript library for dynamic web applications"
DESCRIPTION = ""
SECTION = "javascript"
SOURCE_PACKAGE = "node-jquery"
HOMEPAGE = "https://jquery.com/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/n/node-jquery/libjs-jquery_3.6.1+dfsg+~3.5.14-1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "ee5dba0e9fb36a1dfbc6a8e224961d5e"
SRC_URI[deb0.sha1sum] = "6fb072562e42ea9ef62ac543a26149a80c567451"
SRC_URI[deb0.sha256sum] = "a58c9ff6afe96c769cb6535754c909410760e4efa1e1540236194e489adcfb25"
SRC_URI[deb0.sha512sum] = "eeaef36aad5a53c5274aaa53fa300b71efea8939a66a6e6b4853e4330d2b2de2d3d3283eeb911442d7bbe0cdfbde3bd4eab7499e2918672adf4e7e654636c93e"


