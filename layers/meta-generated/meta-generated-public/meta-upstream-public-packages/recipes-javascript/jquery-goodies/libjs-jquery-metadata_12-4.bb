# This was autogenerated! Do not modify
SUMMARY = "jQuery plugin for parsing metadata from elements"
DESCRIPTION = ""
SECTION = "javascript"
SOURCE_PACKAGE = "jquery-goodies"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/j/jquery-goodies/libjs-jquery-metadata_12-4_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "182522bf70932d0ae556da8461e759e9"
SRC_URI[deb0.sha1sum] = "741bc31f3ef5b5649f9f4723347092619e434469"
SRC_URI[deb0.sha256sum] = "42fb42d785ba6cf1a2fc59dd4e65361e528998ccd0fdb8ca8fa17b923e9305b3"
SRC_URI[deb0.sha512sum] = "f2482cc12dacf8b69bfbd2e86f2dc83d2948561cf50d1ae8ee3bf3c89ed9f2c63093eac856d22b077f5a282e11ef8813cc5d1ced21d6d9e19171ff85a3d723c4"

RDEPENDS = " \
    libjs-jquery \
"

