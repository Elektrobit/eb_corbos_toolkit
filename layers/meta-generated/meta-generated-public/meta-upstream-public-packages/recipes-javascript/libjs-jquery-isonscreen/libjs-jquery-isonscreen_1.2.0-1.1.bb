# This was autogenerated! Do not modify
SUMMARY = "detects if an element is visible within the users current view pane"
DESCRIPTION = ""
SECTION = "javascript"
SOURCE_PACKAGE = "libjs-jquery-isonscreen"
HOMEPAGE = "http://archive.plugins.jquery.com/project/isOnScreen"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libj/libjs-jquery-isonscreen/libjs-jquery-isonscreen_1.2.0-1.1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "dcbb019fb39c8cc1924ae0378bc9f569"
SRC_URI[deb0.sha1sum] = "ee5c3f66a98ba43fa7b7e4825ee96bf635c7ff5c"
SRC_URI[deb0.sha256sum] = "654a6c4489dd33aae918b841bbd57a5468c92d0e99a95cc8936bdaa89ad6e98a"
SRC_URI[deb0.sha512sum] = "4ea60227aededb4672ef53cc0613d16463af748884584549ab838148dd5f562703fc19fdf4da4ed4fd4b0426aa0440a73038489d1d414b98fd1c5aa13b843991"

RDEPENDS = " \
    libjs-jquery \
"

