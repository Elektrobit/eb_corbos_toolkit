# This was autogenerated! Do not modify
SUMMARY = "standard SGML representation system for technical documents"
DESCRIPTION = ""
SECTION = "text"
SOURCE_PACKAGE = "docbook"
HOMEPAGE = "https://www.oasis-open.org/docbook/sgml/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/d/docbook/docbook_4.5-11_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "e77876e90e3810850659c0ed2a5ec852"
SRC_URI[deb0.sha1sum] = "d63047af2f8c14784dc03db2ee758ad7ea18ee94"
SRC_URI[deb0.sha256sum] = "9e9fc878a2bf2b5e1e7a19e2a7e0ea9a2eb4473b17f83ad9313a3cb6399e8d70"
SRC_URI[deb0.sha512sum] = "8169803cd1ccf387e92f1890eff830f125bdca55b5314a8f7438798b13c400dd1b90827bea0089bfbb3dd5b9ebd34b73c488a8adca10ff4c6a1ee28884eebab9"

RDEPENDS = " \
    sgml-base \
    sgml-data \
"

