# This was autogenerated! Do not modify
SUMMARY = "library and command line utility for diffing xml files"
DESCRIPTION = ""
SECTION = "text"
SOURCE_PACKAGE = "xmldiff"
HOMEPAGE = "https://github.com/Shoobx/xmldiff"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/x/xmldiff/xmldiff_2.6.3-0.2_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "d0e31a76c8fe5cae680ee811f61b2ee7"
SRC_URI[deb0.sha1sum] = "d73635227512305fa07ba090c6e682cf23fd2f7c"
SRC_URI[deb0.sha256sum] = "59a814eb4ae17702e45954df350f2f2d0a803f484c561159c72c62cf266f64bb"
SRC_URI[deb0.sha512sum] = "0f943481949f86d81d1f761529e165a39714db6e9a3c4d6063f99f7327921b368022dc49458a3b23c0627a5a925cc98979f7abb0a13b971aec38b6626da4fa1c"

RDEPENDS = " \
    libjs-sphinxdoc \
    python3 \
    python3-lxml \
"

