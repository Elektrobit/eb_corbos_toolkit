# This was autogenerated! Do not modify
SUMMARY = "Compares two files word by word"
DESCRIPTION = ""
SECTION = "text"
SOURCE_PACKAGE = "wdiff"
HOMEPAGE = "https://www.gnu.org/software/wdiff/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/w/wdiff/wdiff_1.2.2-9_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/w/wdiff/wdiff_1.2.2-9_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "49021efc89efee4a75f61133fc55d47e"
SRC_URI[deb0.sha1sum] = "1cb4cce7fd1bfc9b91784af1f857415f3c2d0696"
SRC_URI[deb0.sha256sum] = "a73635d251854ae8d1268b717e88064fb83fae59efb869835c53d8f4054a4dda"
SRC_URI[deb0.sha512sum] = "3491dc98c300e167c0953dec3c98b39fb02b916d6be5e05c27c3f98cfcbc748e2674908561df19c925349f0d1e5dc9a2e7eabf3932b3087c9d84f5525185395e"
SRC_URI[deb1.md5sum] = "d8bd357b12f60166c508bcbb8854265b"
SRC_URI[deb1.sha1sum] = "85140e4a277485d4ac4e535a1fce6384b89dc333"
SRC_URI[deb1.sha256sum] = "6fe8a75361c25faae5d8911b76b95fc32ef9eb4feffbe8a9fd27992fd8a8a954"
SRC_URI[deb1.sha512sum] = "3a39428947311d05aa994b47754630db8491241219d8a2ec0d88b097a9845dcba027c04984edd24d5b919bcf26263b6e03f1640ece5c8e10f35e29906276f0da"

RDEPENDS = " \
    libc6 \
    libtinfo6 \
"

