# This was autogenerated! Do not modify
SUMMARY = "Utilities to work with patches"
DESCRIPTION = ""
SECTION = "text"
SOURCE_PACKAGE = "patchutils"
HOMEPAGE = "http://cyberelk.net/tim/software/patchutils/"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/patchutils/patchutils_0.4.2-1+b1_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "6553e3ae689812363daef5dd73f5296e"
SRC_URI[deb0.sha1sum] = "d09e82090070173553f580f669d1f834fd3b8086"
SRC_URI[deb0.sha256sum] = "bc4b5643e442811fe30ba79fe5ea76689618e0ec541fa4c1a32400299fc0134b"
SRC_URI[deb0.sha512sum] = "59da807fbcc8b5cf361b33b06eb3a5265c68abe17f48556d53a49468632b912a5a6f9338e37033fd30ddb7af337386a805ef6154a466b3dd38a963a02fb2a3f6"

RDEPENDS = " \
    libc6 \
    patch \
    perl \
    sensible-utils \
"

