# This was autogenerated! Do not modify
SUMMARY = "Utilities to work with patches"
DESCRIPTION = ""
SECTION = "text"
SOURCE_PACKAGE = "patchutils"
HOMEPAGE = "http://cyberelk.net/tim/software/patchutils/"

inherit dpkg-prebuilt

DPKG_ARCH = "amd64"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/patchutils/patchutils_0.4.2-1_amd64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "bb2239ea985de06be332ae849df4c793"
SRC_URI[deb0.sha1sum] = "34372dc28e7fb8b8fe5e34e9e2c1a629d6f97293"
SRC_URI[deb0.sha256sum] = "7df59f413baebd7e81d0ec3f8300c5e4acfdef44ab58b2e7a4922f62ab4970c8"
SRC_URI[deb0.sha512sum] = "00837e755ca73287e4492b82ca41548383c26663d2887a9d64389079960fdc3b0558cb62f184b03df0c56929f3a5706eaa23aba54c79b082de9680d7d44faaef"

RDEPENDS = " \
    libc6 \
    patch \
    perl \
    sensible-utils \
"

