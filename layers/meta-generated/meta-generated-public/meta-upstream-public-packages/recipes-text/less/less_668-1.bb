# This was autogenerated! Do not modify
SUMMARY = "pager program similar to more"
DESCRIPTION = ""
SECTION = "text"
SOURCE_PACKAGE = "less"
HOMEPAGE = "http://www.greenwoodsoftware.com/less/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/l/less/less_668-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/l/less/less_668-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "9dfb56e8f4802bc86c12394d6b916af2"
SRC_URI[deb0.sha1sum] = "cb7205e40eeac6264003de5dc4c466baff0ac0cb"
SRC_URI[deb0.sha256sum] = "ba3c216e68298a2d375d4e386baa935e245f0f23ddb74502b12582f8de061d4f"
SRC_URI[deb0.sha512sum] = "41c319fb7708caac14db5cf4710157b5fef879726c94d5b4474ef8b86e7ead7a488d05c3805cad9db02eb74ae94b49a5466d8d1d5f72678529d21b22c2fef3f1"
SRC_URI[deb1.md5sum] = "4ac0a63c5591a7a18c4ecbe19af20559"
SRC_URI[deb1.sha1sum] = "006a595f1ad64217f4a771035229a4a95cc16734"
SRC_URI[deb1.sha256sum] = "dbce2dd7c649fc7a4273f173c8260fc595b05c56cc2ea859298fbb96d6749fed"
SRC_URI[deb1.sha512sum] = "c945f3b33b4f0f3eae89d107a22a9c09a3d5bfc41b49001311138ffc0e9846c2c3a56d34de1935a30453c20ac3567879694bddf3883a06db201c2bdd2ce65abf"

RDEPENDS = " \
    libc6 \
    libtinfo6 \
"

