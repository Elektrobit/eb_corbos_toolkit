# This was autogenerated! Do not modify
SUMMARY = "GNOME XML library - utilities"
DESCRIPTION = ""
SECTION = "text"
SOURCE_PACKAGE = "libxml2"
HOMEPAGE = "http://xmlsoft.org"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libx/libxml2/libxml2-utils_2.12.7+dfsg+really2.9.14-2.1+deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libx/libxml2/libxml2-utils_2.12.7+dfsg+really2.9.14-2.1+deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "f2075f48976cca343b1a2ed4fa1ae645"
SRC_URI[deb0.sha1sum] = "54ee30645f9dce344532776dbf5b7c1fa911ea93"
SRC_URI[deb0.sha256sum] = "c8dfd86a9fb25de95728b3da0696c2664350fe597fa1fea981ef6233e60929f8"
SRC_URI[deb0.sha512sum] = "4a1cdcdad9d97ab4a6401f61a95ac78c23512a8de11ed24f66ce496ca7737a9ec4083f55069cf0fb6dd0da01e6ab4aa0b813c1873793c1feb1f21efc416200b8"
SRC_URI[deb1.md5sum] = "97cbb0bdd0c694acc05e4d48677d8f22"
SRC_URI[deb1.sha1sum] = "5d7024286f97baf62983d71a32121aae92989293"
SRC_URI[deb1.sha256sum] = "685440250e8ef04dd150286a07dff7a987055932b6d0c0329f768c1c4d432bac"
SRC_URI[deb1.sha512sum] = "32abdebb8352a205c675f0b637ada0f233d22eec5c57e24e25534521df7824806fd68c035f9fa32ea8369d7ddcf24fdf26f1d5aead596858fbca1819a1eac862"

RDEPENDS = " \
    libc6 \
    liblzma5 \
    libxml2 \
    zlib1g \
"

