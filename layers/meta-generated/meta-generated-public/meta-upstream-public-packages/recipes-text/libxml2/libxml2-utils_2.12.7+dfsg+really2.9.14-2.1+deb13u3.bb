# This was autogenerated! Do not modify
SUMMARY = "GNOME XML library - utilities"
DESCRIPTION = ""
SECTION = "text"
SOURCE_PACKAGE = "libxml2"
HOMEPAGE = "http://xmlsoft.org"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libx/libxml2/libxml2-utils_2.12.7+dfsg+really2.9.14-2.1+deb13u3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libx/libxml2/libxml2-utils_2.12.7+dfsg+really2.9.14-2.1+deb13u3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "cde6a785e7e57253d9e40e025992b1ae"
SRC_URI[deb0.sha1sum] = "2536948ef8b2136044eae175e8d65dde356580d3"
SRC_URI[deb0.sha256sum] = "cfa40541f9b314491c53b6c63e23ee1a2afa2ac309e6ca379c1081ef2b62e773"
SRC_URI[deb0.sha512sum] = "04108c66e39799f424681ab92abd8cad9d4d3c9e1ba58d704e3a10d5c4fe03ca7638bdc3c60fc24607124d65e1b4fd782054a483d0b92c4dd31cbcfe4229bf93"
SRC_URI[deb1.md5sum] = "14777b9b4a40cec40053a2a3a714b9bf"
SRC_URI[deb1.sha1sum] = "039ed2480f093c28b035d6d13fe4548da0284e21"
SRC_URI[deb1.sha256sum] = "8fe018b0270315582f1fbb40cea2df2972ff77bc8faac516d71b92280622c97f"
SRC_URI[deb1.sha512sum] = "e26e8e864407d5ed5a1f20f964290b0745ad1883edd52dae87f7a6a2c13b8b67c94d1ae0c40240a357a28685fda34950ac3c26e3b58897328be935d5bb69564b"

RDEPENDS = " \
    libc6 \
    liblzma5 \
    libxml2 \
    zlib1g \
"

