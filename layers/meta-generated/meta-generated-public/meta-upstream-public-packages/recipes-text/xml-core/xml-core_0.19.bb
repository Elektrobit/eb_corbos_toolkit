# This was autogenerated! Do not modify
SUMMARY = "XML infrastructure and XML catalog file support"
DESCRIPTION = ""
SECTION = "text"
SOURCE_PACKAGE = "xml-core"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/x/xml-core/xml-core_0.19_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "b1fe670f77b70913841f57320e5de8a3"
SRC_URI[deb0.sha1sum] = "b5df702590c82331567ad92c6ee837a962c8826c"
SRC_URI[deb0.sha256sum] = "079ec5e10b1c49aa23a6c53ae8e55e33aec121d1c87a131d2172bdabc3f4030e"
SRC_URI[deb0.sha512sum] = "e14016832494ac4c667c153efcaf2892d6cc697a1ab7d993468473390c7eded0c89b4038e81875427c141335df6bfb9c804a953a1f8f7324a1bdc55619294358"

RDEPENDS = " \
    sed \
    sgml-base \
"

