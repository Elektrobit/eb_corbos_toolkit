# This was autogenerated! Do not modify
SUMMARY = "common SGML and XML data"
DESCRIPTION = ""
SECTION = "text"
SOURCE_PACKAGE = "sgml-data"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/sgml-data/sgml-data_2.0.11+nmu1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "6380a3791ff73aba374d6b2319141c5e"
SRC_URI[deb0.sha1sum] = "63d58cff491f64b3169cdac8096940f5832f035e"
SRC_URI[deb0.sha256sum] = "2f1c3b3d2387054757b8e64e92fc10f4e1f7f31fdf461ae15cc5f8145e1f3876"
SRC_URI[deb0.sha512sum] = "63974b826650411c2f6973e1395266645b3a79499e444e60467f921afbc01b47417ea99eea84791ae0c9097559001931e09e896c9536d8c3a11c6e4b6380de8c"

RDEPENDS = " \
    perl \
    sgml-base \
    xml-core \
"

