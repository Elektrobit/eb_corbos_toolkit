# This was autogenerated! Do not modify
SUMMARY = "small, friendly text editor inspired by Pico"
DESCRIPTION = ""
SECTION = "editors"
SOURCE_PACKAGE = "nano"
HOMEPAGE = "https://www.nano-editor.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/n/nano/nano_8.4-1+deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/n/nano/nano_8.4-1+deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "4aec65bf01a7b4fb66edfb4aa418304f"
SRC_URI[deb0.sha1sum] = "16be26309e232c994b7ee9187ac25a92989bcf48"
SRC_URI[deb0.sha256sum] = "38d496c9e432ca38ef386f6d832f5c18d6a0a48c78d6711223ca1541f4306a04"
SRC_URI[deb0.sha512sum] = "6e0e649dc17a1c4a19b3729a2e433eb17da8cf07b98b81ab40788cb6deed2e2599ed69fe8d71099c5896c36dce1553faf0a1456a3618cfb3e60ad543a834733d"
SRC_URI[deb1.md5sum] = "cbdb74a1e27aea8af04c76f1f397a919"
SRC_URI[deb1.sha1sum] = "ef541c458115e78cc45d33f044dcb2aa4ed46bcd"
SRC_URI[deb1.sha256sum] = "b82e53bd61cfedc848e4582837b5c7ea9dabf25ad263e3d98a69ef8858bb6e8b"
SRC_URI[deb1.sha512sum] = "1e70bb6eb5b134e14ae87ac2d7d198050d7f926e628a08600cbfacfe997d7adc591619dcc4a951aa1a9d2d43afe6261d2821023879d06270754ba84c327d57e9"

RDEPENDS = " \
    libc6 \
    libncursesw6 \
    libtinfo6 \
"

