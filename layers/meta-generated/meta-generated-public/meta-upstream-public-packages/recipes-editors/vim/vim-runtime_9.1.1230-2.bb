# This was autogenerated! Do not modify
SUMMARY = "Vi IMproved - Runtime files"
DESCRIPTION = ""
SECTION = "editors"
SOURCE_PACKAGE = "vim"
HOMEPAGE = "https://www.vim.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/v/vim/vim-runtime_9.1.1230-2_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "e393c4963814bf0795f53e5f0873c165"
SRC_URI[deb0.sha1sum] = "a5319e7dd90b31a7d6067e1302c640f2deb5ce2f"
SRC_URI[deb0.sha256sum] = "5addd2e7d3aae7d1907aba6c0c16c525e78ccfc0f6ee9ef9651c139a80c97058"
SRC_URI[deb0.sha512sum] = "e7c5ec3377b01f3483e543bdc3c18dec3e7dd41daeb98b4cae7f2d0ee1869582a49135834ebbf4a6471382fa022f7cbb34e3c4854939630e00470aaee3f2973d"


