# This was autogenerated! Do not modify
SUMMARY = "Vi IMproved - enhanced vi editor"
DESCRIPTION = ""
SECTION = "editors"
SOURCE_PACKAGE = "vim"
HOMEPAGE = "https://www.vim.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/v/vim/vim_9.1.1230-2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/v/vim/vim_9.1.1230-2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "677a10c17a1b230a84d62e486177e784"
SRC_URI[deb0.sha1sum] = "11f35f8ce840785248af395279149e4e4fcd148b"
SRC_URI[deb0.sha256sum] = "7050d710bbcd5dee68865d90fd95a9aa865bf16d9a3874c5bb6a4f1d69231cfe"
SRC_URI[deb0.sha512sum] = "b704f86bda8d17db94b69f3c72e933bef707bb6031b3590ee2b1ee2f482f7b8398f42b3b08dab01619cf0ef9798677dcea34d5203bc52b9815b747cec0f71229"
SRC_URI[deb1.md5sum] = "ca0d61534aa0bc1b420319858ef71889"
SRC_URI[deb1.sha1sum] = "e5e6ac3ca6c94ef4b680f8d975c56272a0051163"
SRC_URI[deb1.sha256sum] = "933d4a979a78574f3e57b0ddb87088c720a4526fdd254c39394c4b70f5e59aa7"
SRC_URI[deb1.sha512sum] = "41567171793e2d5b1cc9d138db0054db7e8c9c5098e048821f6b781f24bb71f3d0634efb8d59b52ac8611c13a0784733d04a02078c34243d760ef7973d963a60"

RDEPENDS = " \
    libacl1 \
    libc6 \
    libgpm2 \
    libselinux1 \
    libsodium23 \
    libtinfo6 \
    vim-common \
    vim-runtime \
"

RPROVIDES = " \
    editor \
"
