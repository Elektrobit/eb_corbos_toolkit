# This was autogenerated! Do not modify
SUMMARY = "Vi IMproved - Common files"
DESCRIPTION = ""
SECTION = "editors"
SOURCE_PACKAGE = "vim"
HOMEPAGE = "https://www.vim.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/v/vim/vim-common_9.1.1230-2_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "da6baecbf10d1881bc3ce95427c4b3ef"
SRC_URI[deb0.sha1sum] = "aad648143c20ec0857d37b7bca1f38af3568b9f7"
SRC_URI[deb0.sha256sum] = "bcf7e3e675cbc4eed1f444ea3a6dfbf420eae141615b0d35cee24cf23e18aa18"
SRC_URI[deb0.sha512sum] = "b3752ddbe17905d4f595b122953ad1b78b4aaaf4b73f4b9aad48f5056c7cc534531420ee823accc0884a27e3b5a66d46d01a6ff1bd3d23d7fa337745acbe3fa8"


