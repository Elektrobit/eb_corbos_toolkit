# This was autogenerated! Do not modify
SUMMARY = "tool to make (or reverse) a hex dump"
DESCRIPTION = ""
SECTION = "editors"
SOURCE_PACKAGE = "vim"
HOMEPAGE = "https://www.vim.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/v/vim/xxd_9.1.1230-2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/v/vim/xxd_9.1.1230-2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "a0610b562e7843b410b28b9c7ca560a5"
SRC_URI[deb0.sha1sum] = "86ebbc6ea3875ecfa74eb7af09c272d3913abac7"
SRC_URI[deb0.sha256sum] = "d1ae72a9ae7c3f81a23299422f0f219b55d2a76eb88c78815584983d6b897324"
SRC_URI[deb0.sha512sum] = "710786aa9b70457ddbab4bab568451233240a78daf796b908e67de98f5e14aaca7008afee962c4691bab412b53c7eaeb6ae540b7e4e6e7d02bf7b590a8a9f568"
SRC_URI[deb1.md5sum] = "e80d6b8afccaae92d80335d2c0c19aab"
SRC_URI[deb1.sha1sum] = "a482b2e50f7353a5dfd8b60b8a91ada89eecdce7"
SRC_URI[deb1.sha256sum] = "292ee513b6e10c774abe05666f5eecedf0f68165f9b5770ee334417ef07b4b38"
SRC_URI[deb1.sha512sum] = "5b22241ad221560440096235da7063a48ab83758ad6a8cdd08e0a7092959dca0f26f4d2307c1b83352bfd2318a7e4b95932a9027605c02af8eae145d9cdfbb1f"

RDEPENDS = " \
    libc6 \
"

