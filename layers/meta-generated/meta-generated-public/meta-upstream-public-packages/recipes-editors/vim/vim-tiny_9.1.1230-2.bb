# This was autogenerated! Do not modify
SUMMARY = "Vi IMproved - enhanced vi editor - compact version"
DESCRIPTION = ""
SECTION = "editors"
SOURCE_PACKAGE = "vim"
HOMEPAGE = "https://www.vim.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/v/vim/vim-tiny_9.1.1230-2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/v/vim/vim-tiny_9.1.1230-2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "9f5484dae9a8f7137fb8bd6c1e9eae6b"
SRC_URI[deb0.sha1sum] = "bf2cf48463c1a4a81b4057f0dd0c3950b73b29d8"
SRC_URI[deb0.sha256sum] = "675534b5adc7b92603287feac3cbfd5cbb4f5f0dc301878e40e1d90a73556f64"
SRC_URI[deb0.sha512sum] = "b8bb9eec17d40aa05e08fb9d1c36d2705e1f965962a6e1d38a49c1be76923ba1b030e09e0009347ab7b2b68f0576e07e6a3ba8bec2c250dfad0536dec0c6bfd1"
SRC_URI[deb1.md5sum] = "12893402d8e0a7bba23715485c10ff80"
SRC_URI[deb1.sha1sum] = "c8769b9b7640ed9f2c64914f75523097f2606f05"
SRC_URI[deb1.sha256sum] = "1b2c9db8269961cdb55ab4c1e91994013a33825bc6d5d5d40a5f6136a8687992"
SRC_URI[deb1.sha512sum] = "a97c323e0151571efb617ca85f5237fe8a26c18d1be01ae57a4133c0b98fa6df6f111bd436c1bd5590f7620c47817abd9adad20de685aec5fa96f56da2df704f"

RDEPENDS = " \
    libacl1 \
    libc6 \
    libselinux1 \
    libtinfo6 \
    vim-common \
"

RPROVIDES = " \
    editor \
"
