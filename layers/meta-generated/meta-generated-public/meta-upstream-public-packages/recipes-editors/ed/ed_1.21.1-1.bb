# This was autogenerated! Do not modify
SUMMARY = "classic UNIX line editor"
DESCRIPTION = ""
SECTION = "editors"
SOURCE_PACKAGE = "ed"
HOMEPAGE = "https://www.gnu.org/software/ed/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/e/ed/ed_1.21.1-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/e/ed/ed_1.21.1-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "5c454ac87ccfd6e167f1fa21e9e64379"
SRC_URI[deb0.sha1sum] = "7cfc81f2ce4d2eba28bb5ec2f8739092dc5e7c05"
SRC_URI[deb0.sha256sum] = "b5498068d8ac54ad004bacbde2223a348fee781f9bb94328b01d8bfcbd179b48"
SRC_URI[deb0.sha512sum] = "d6c300828e50cfe4861b0b874b8aff0aadc05e83173fc117dced071fb79ead069e727b890c4a341d5a0ea71f7b513c144c9f2bcac0b67a9741032926f30afc16"
SRC_URI[deb1.md5sum] = "ce38310b08081b0bd0b74b7c72136bcd"
SRC_URI[deb1.sha1sum] = "eb9ab90f03c60ac2bfa8100d748b188ca292b4cd"
SRC_URI[deb1.sha256sum] = "73f6da09bf941baf1f2e54cc49695bbe11305a1c271aa0058ded1d25e889de5a"
SRC_URI[deb1.sha512sum] = "ad4ee54f57fb0072223fe4216295fd0fc64feb80af6d77931ee50ea1fefc64053b94cba2df73e6811564f081c04c5cd0cd69336aea385459e1035048cfbcb208"

RDEPENDS = " \
    libc6 \
"

