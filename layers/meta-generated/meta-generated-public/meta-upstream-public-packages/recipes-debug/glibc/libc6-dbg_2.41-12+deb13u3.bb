# This was autogenerated! Do not modify
SUMMARY = "GNU C Library: detached debugging symbols"
DESCRIPTION = ""
SECTION = "debug"
SOURCE_PACKAGE = "glibc"
HOMEPAGE = "https://www.gnu.org/software/libc/libc.html"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/glibc/libc6-dbg_2.41-12+deb13u3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/glibc/libc6-dbg_2.41-12+deb13u3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "152df671685cad87a4a978e856419af7"
SRC_URI[deb0.sha1sum] = "a9db5c76b23e2a1617997a10f07796b38bc3286d"
SRC_URI[deb0.sha256sum] = "5a6ab1e991c0240ddc7faade86c571601d136968ecb0d1ef7c88d018f11826a7"
SRC_URI[deb0.sha512sum] = "5b2f3462021c35d6d8546b5b445de4e2b6ed6bbf6a90a4a2c2f89974480be4a6cdb338e5a66c9fb1e6da68c095e85ea4e6fa13e5550444bc3f6bfeb2ffb0d9b0"
SRC_URI[deb1.md5sum] = "9542e573ee307a4e2903311b7d0b2bef"
SRC_URI[deb1.sha1sum] = "0ad843e9ae3e00b2838dd3dbe98193d452a687b2"
SRC_URI[deb1.sha256sum] = "827f760483cad481db6f12945bb0e114d0ccd9cbce05eb210b3223d6843c9da5"
SRC_URI[deb1.sha512sum] = "bc3cb447053ff3dbc528a15e08689f24635252189854630dc5988aa872961baa5f142fdb72ffeac5256b4cd522c410aae8a5bfe941079801eef9f9d25a868e70"

RDEPENDS = " \
    libc6 \
"

RPROVIDES = " \
    libc-dbg \
    libc6-dbgsym \
"
