# This was autogenerated! Do not modify
SUMMARY = "HTTPS driver for LWP::UserAgent"
DESCRIPTION = ""
SECTION = "perl"
SOURCE_PACKAGE = "liblwp-protocol-https-perl"
HOMEPAGE = "https://metacpan.org/release/LWP-Protocol-https"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libl/liblwp-protocol-https-perl/liblwp-protocol-https-perl_6.14-1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "3c9208e3e77d440a5ac66b1172eb6116"
SRC_URI[deb0.sha1sum] = "5bdd29eba6adabcdedc6f3b4535ed542e4de7517"
SRC_URI[deb0.sha256sum] = "9201070118916bfbf3111008cac59769fb240376bb04e981132805a915f57223"
SRC_URI[deb0.sha512sum] = "62e7f54cbcf260a6d325f8646dcb1014289a4520b395ae6a7d71073f403ace5fedd32b8f39ef016e75a9ed4fc7d79d3c15a2d5ec42783166af3869c667325d0f"

RDEPENDS = " \
    ca-certificates \
    libio-socket-ssl-perl \
    libnet-http-perl \
    libwww-perl \
    perl \
"

