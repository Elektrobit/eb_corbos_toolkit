# This was autogenerated! Do not modify
SUMMARY = "implementation of content negotiation"
DESCRIPTION = ""
SECTION = "perl"
SOURCE_PACKAGE = "libhttp-negotiate-perl"
HOMEPAGE = "https://metacpan.org/release/HTTP-Negotiate"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libh/libhttp-negotiate-perl/libhttp-negotiate-perl_6.01-2_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "7130eb4cc5f0b2b9766a7fb0ae576d4d"
SRC_URI[deb0.sha1sum] = "5b943f43177ef085adaa2b5e8034a4958176c237"
SRC_URI[deb0.sha256sum] = "b2770aaf4d638283d9b4f713005702fbab42304be169cb4d6761e8537f724261"
SRC_URI[deb0.sha512sum] = "7a2fd5f68b915c96a87419a8d0442ddd1bd0bae4db6ae3e9298bacf752bb01f34864214876b78b695512cd35acb310ba993bb8d8a26cf50e839d4aed12172609"

RDEPENDS = " \
    libhttp-message-perl \
    perl \
"

