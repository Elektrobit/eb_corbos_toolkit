# This was autogenerated! Do not modify
SUMMARY = "debhelper perl modules"
DESCRIPTION = ""
SECTION = "perl"
SOURCE_PACKAGE = "debhelper"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/d/debhelper/libdebhelper-perl_13.24.2_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "5cf6c3de43181576a6fbe5db8788284b"
SRC_URI[deb0.sha1sum] = "e5b70fdcf48a8da743384a7358c21c7a1e3c673f"
SRC_URI[deb0.sha256sum] = "1e1ab830223bcfe92ce61dd7e4d5a7db9cd439275a2c0ed7bf714a99813b8a7f"
SRC_URI[deb0.sha512sum] = "936e3ad5159bd844742d4988e26347e28d7ee6da6cb257a625e4d3dbf4d22acc1f366b2c56e02390a560e289eed3d013206402d6a0d0cd5136bfd7ec191c38c5"

RDEPENDS = " \
    perl \
"

