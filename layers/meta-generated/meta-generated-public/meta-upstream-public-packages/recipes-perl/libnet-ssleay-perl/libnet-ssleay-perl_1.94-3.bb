# This was autogenerated! Do not modify
SUMMARY = "Perl module for Secure Sockets Layer (SSL)"
DESCRIPTION = ""
SECTION = "perl"
SOURCE_PACKAGE = "libnet-ssleay-perl"
HOMEPAGE = "https://metacpan.org/release/Net-SSLeay"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libn/libnet-ssleay-perl/libnet-ssleay-perl_1.94-3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libn/libnet-ssleay-perl/libnet-ssleay-perl_1.94-3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "e9a005a85d3e8fad1dadcf1076c2aa2e"
SRC_URI[deb0.sha1sum] = "77a7e447f7411aac623a853908e8d3481a33e160"
SRC_URI[deb0.sha256sum] = "fc67b418ec1ed7277902702791c91b3023eb488d7c01029f0cc2acfdfdebd13a"
SRC_URI[deb0.sha512sum] = "77b0d7fe9cfbe7d4fbf631c45999ef8ed356ed8d301aefddb141745c549fb5e4358bfac7d8012e4349b9725acde652c18ced117f8bb5b2b82f51da40f03df85e"
SRC_URI[deb1.md5sum] = "3492e99cdde687f6ade236a423140ef7"
SRC_URI[deb1.sha1sum] = "e189eb4ea4a05c4b096ebbad93f01346c6f9d926"
SRC_URI[deb1.sha256sum] = "50622582eec91dac26bf34e19a255b4e1bfaaf9cf44431fb437f3ade9bcbb7bc"
SRC_URI[deb1.sha512sum] = "1ea4c0a1171ecbb55b1fc7ee0789c1254c89a063d195877559e5c2487360aa4016efd60e15180235aaf85742a2d12b966af8c480402f638a922732ea9dfbbb9c"

RDEPENDS = " \
    libc6 \
    libssl3t64 \
    perl \
    perl-openssl-abi-3 \
    perlapi-5.40.1 \
"

