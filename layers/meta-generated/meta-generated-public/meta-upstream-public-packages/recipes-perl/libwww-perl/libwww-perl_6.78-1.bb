# This was autogenerated! Do not modify
SUMMARY = "simple and consistent interface to the world-wide web"
DESCRIPTION = ""
SECTION = "perl"
SOURCE_PACKAGE = "libwww-perl"
HOMEPAGE = "https://metacpan.org/release/libwww-perl"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libw/libwww-perl/libwww-perl_6.78-1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "cdf9bcc54d2656570dada24b6dc65df9"
SRC_URI[deb0.sha1sum] = "28c2a4b67092ed1c5f87fc0f356ee6ddbc9cea73"
SRC_URI[deb0.sha256sum] = "ddcecf6d01b33f14faf6ebd511deb114fcb0c043bb4291e4b45c82cbe7b4ec88"
SRC_URI[deb0.sha512sum] = "0558821bf6b25c427a92da5692990c001c9ae70c3e7eaaa2fbd6e836e51cbd9b2f29d98d3baadfeade21b64f519ec8a7ab2d0d6d792efce3e4988dd421c98518"

RDEPENDS = " \
    ca-certificates \
    libencode-locale-perl \
    libfile-listing-perl \
    libhtml-parser-perl \
    libhtml-tagset-perl \
    libhtml-tree-perl \
    libhttp-cookies-perl \
    libhttp-date-perl \
    libhttp-message-perl \
    libhttp-negotiate-perl \
    liblwp-mediatypes-perl \
    liblwp-protocol-https-perl \
    libnet-http-perl \
    libtry-tiny-perl \
    liburi-perl \
    libwww-robotrules-perl \
    netbase \
    perl \
"

