# This was autogenerated! Do not modify
SUMMARY = "Perl module implementing object oriented interface to SSL sockets"
DESCRIPTION = ""
SECTION = "perl"
SOURCE_PACKAGE = "libio-socket-ssl-perl"
HOMEPAGE = "https://metacpan.org/release/IO-Socket-SSL"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libi/libio-socket-ssl-perl/libio-socket-ssl-perl_2.089-1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "09b7a8bcfbbb6b87b9a1a6232da4c616"
SRC_URI[deb0.sha1sum] = "aa54c4cf1920a3093538528464cb68f6cc3138b4"
SRC_URI[deb0.sha256sum] = "9fe58e2dd2847896e380f9fb26b5344d62cab21d8390598912e485ceedb30f00"
SRC_URI[deb0.sha512sum] = "36dc08b3e443332b772b84eba25a35cddd7a6b0e64d85bca8ed4c2025c74a6d6aa5c1180302f2365e0934f127a3fd6ef8e480cf851494ba0c1fa2a1327a5cd43"

RDEPENDS = " \
    libnet-ssleay-perl \
    netbase \
    perl \
"

