# This was autogenerated! Do not modify
SUMMARY = "utility to determine the locale encoding"
DESCRIPTION = ""
SECTION = "perl"
SOURCE_PACKAGE = "libencode-locale-perl"
HOMEPAGE = "https://metacpan.org/release/Encode-Locale"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libe/libencode-locale-perl/libencode-locale-perl_1.05-3_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "9a7ba3ab3022c675a4fec3583d809ac2"
SRC_URI[deb0.sha1sum] = "35d0919bfaccb06d3ff36e443700f3c41760fb33"
SRC_URI[deb0.sha256sum] = "071bff2a1d193ec1b0d71e1a1ba7e718909866874e600f19d99a6f8c5ae30bcd"
SRC_URI[deb0.sha512sum] = "e26014cd0fc5057f03a30d0ef580158803ec966c0710201c0405d91d22a20be3c03ac1d6e94e2e825017431cc4268132169c3fbf8324c18dadebe49e9605c37d"

RDEPENDS = " \
    perl \
"

