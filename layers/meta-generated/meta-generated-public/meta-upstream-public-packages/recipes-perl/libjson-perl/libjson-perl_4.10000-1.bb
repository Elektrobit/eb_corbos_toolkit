# This was autogenerated! Do not modify
SUMMARY = "module for manipulating JSON-formatted data"
DESCRIPTION = ""
SECTION = "perl"
SOURCE_PACKAGE = "libjson-perl"
HOMEPAGE = "https://metacpan.org/release/JSON"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libj/libjson-perl/libjson-perl_4.10000-1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "b480f0d61d1a7b295bc7a47f8667c8d3"
SRC_URI[deb0.sha1sum] = "c9870bc9038f3bb084588ac7979d9017a274eee3"
SRC_URI[deb0.sha256sum] = "db1c2e7465d8fe9f5e7e19ee3603446ee3310e672c2a92b6b3754281d4ef92e2"
SRC_URI[deb0.sha512sum] = "6f93aafda047b500acf18e3ac24a2d0685ebb45fb353816d098848ef7d4d982d1702fcb84d2419c52bf298e8e79575c429c39c99729600d556d73da3379d430c"

RDEPENDS = " \
    perl \
"

