# This was autogenerated! Do not modify
SUMMARY = "collection of modules to manipulate date/time information"
DESCRIPTION = ""
SECTION = "perl"
SOURCE_PACKAGE = "libtimedate-perl"
HOMEPAGE = "https://metacpan.org/release/TimeDate"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libt/libtimedate-perl/libtimedate-perl_2.3300-2_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "57a9e43a44a6829c9b0ee4acf702c6dd"
SRC_URI[deb0.sha1sum] = "4bdf04dea0fdc741d5dd942a2d02f26cef5378a6"
SRC_URI[deb0.sha256sum] = "8e36723da883c2975d83199e7f4b5331e291881372fde944b0d56660965f38bb"
SRC_URI[deb0.sha512sum] = "612158001a0d61a7a67b02f051211ba59d3aeb9a2721c033d724847aa47859f679dec6c1627e01f421d726ec7f3ad814c6f9d00c3919c1d8e80bdc3074d7ef66"

RDEPENDS = " \
    perl \
"

