# This was autogenerated! Do not modify
SUMMARY = "module of date conversion routines"
DESCRIPTION = ""
SECTION = "perl"
SOURCE_PACKAGE = "libhttp-date-perl"
HOMEPAGE = "https://metacpan.org/release/HTTP-Date"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libh/libhttp-date-perl/libhttp-date-perl_6.06-1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "349a7e0587be741dce2ccebe1b552cfc"
SRC_URI[deb0.sha1sum] = "57bfcb47638bec5ea4490752a8a6e74978bd65e6"
SRC_URI[deb0.sha256sum] = "b46bf28a321e344be21b3161969c613abeddc63b1ff627ee94487a0ee4b53eda"
SRC_URI[deb0.sha512sum] = "74e7d3f7ff17a4f29f5bb7aecde4cbd07296f8d2b020604550733c03e3211f1d7c25b986663550032396f21aea17dca09f8f681d00f3a659a60fd022e89db4d6"

RDEPENDS = " \
    libtime-local-perl \
    libtimedate-perl \
    perl \
"

