# This was autogenerated! Do not modify
SUMMARY = "Library for building Debian binary packages from Debian sources"
DESCRIPTION = ""
SECTION = "perl"
SOURCE_PACKAGE = "sbuild"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/sbuild/libsbuild-perl_0.89.3+deb13u4_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "d7180638e150e959ec641559c48a09eb"
SRC_URI[deb0.sha1sum] = "3e46c6ad0839fc3a28037f3aab2cba3be8161b50"
SRC_URI[deb0.sha256sum] = "483c2ad62c4dd8e9b47a9dde938b084841679ed4f575ba6154f1f35d6805e8f1"
SRC_URI[deb0.sha512sum] = "a4216fe1202ed37669f204e011344835256f3ec1b77568d7f6bea01a9b919a9ffcb32e0d29b8968ca52f8195934bb1515cd38ef24f119ed67eac626b84b5b349"

RDEPENDS = " \
    apt \
    apt-utils \
    dpkg-dev \
    gnupg \
    libdpkg-perl \
    libexception-class-perl \
    libfilesys-df-perl \
    libmime-lite-perl \
    perl \
"

