# This was autogenerated! Do not modify
SUMMARY = "module to parse directory listings"
DESCRIPTION = ""
SECTION = "perl"
SOURCE_PACKAGE = "libfile-listing-perl"
HOMEPAGE = "https://metacpan.org/release/File-Listing"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libf/libfile-listing-perl/libfile-listing-perl_6.16-1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "7a8e1bc807b5b931462d4f8b08406799"
SRC_URI[deb0.sha1sum] = "6139530eeae55d1ac47aa2d0f607e5e662b00e9e"
SRC_URI[deb0.sha256sum] = "171410be7be03a39e6ad531b19d3b95049d43dae9f19076fe250b3b7bcc30574"
SRC_URI[deb0.sha512sum] = "fca8ab7b5cccd77f70c5274445c4d28d85a96d4db00473a0795151af2180a93a0e332a6bf198e4f4ca780c55b84cb4941c17441204e659db2e52919a5fc8ad44"

RDEPENDS = " \
    libhttp-date-perl \
    perl \
"

