# This was autogenerated! Do not modify
SUMMARY = "Perl wrapper for OP check callbacks"
DESCRIPTION = ""
SECTION = "perl"
SOURCE_PACKAGE = "libb-hooks-op-check-perl"
HOMEPAGE = "https://metacpan.org/release/B-Hooks-OP-Check"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libb/libb-hooks-op-check-perl/libb-hooks-op-check-perl_0.22-3+b2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libb/libb-hooks-op-check-perl/libb-hooks-op-check-perl_0.22-3+b2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "c0306b5f5fc73242cb37160ce6e124a9"
SRC_URI[deb0.sha1sum] = "3da6754926afaa1f27fef7fb78150f4ee36da57a"
SRC_URI[deb0.sha256sum] = "90cc8931725ef9a0fcfe16df3e55b6397b4cf57d033f2228ebcf9175ada254de"
SRC_URI[deb0.sha512sum] = "a3e5e88464a45dfbc47141202f5b27af5e4dc3b7562daffe37b68b097d08abc1fab70e0a008a22a3770d61ac6fe2bb8faeaa4f3920d099e62fa0d26d3b84063a"
SRC_URI[deb1.md5sum] = "aa526d75f82fee32174d798a9beba0a6"
SRC_URI[deb1.sha1sum] = "3bfd875f99420d62643ad69829fd70cd418bf819"
SRC_URI[deb1.sha256sum] = "21b22cca921b0a0d8baa7e93b87b0f16655c19021cab2394d9669fdb12386c8d"
SRC_URI[deb1.sha512sum] = "b254aff406cdce1ff343e0ca48b4f0b87d23c6a665e77635b6e25d942a307e441fe46cbcfc46098f30e22a34ef738116eae3811646311c666dc61f4d644c2597"

RDEPENDS = " \
    perl \
    perlapi-5.40.0 \
"
RDEPENDS:append:amd64 = " \
    libc6 \
"

