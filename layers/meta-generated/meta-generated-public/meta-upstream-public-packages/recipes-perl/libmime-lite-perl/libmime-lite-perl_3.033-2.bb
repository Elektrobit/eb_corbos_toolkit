# This was autogenerated! Do not modify
SUMMARY = "module for convenient MIME message creation"
DESCRIPTION = ""
SECTION = "perl"
SOURCE_PACKAGE = "libmime-lite-perl"
HOMEPAGE = "https://metacpan.org/release/MIME-Lite"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libm/libmime-lite-perl/libmime-lite-perl_3.033-2_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "f75238b1f7d74006c83a2332d3d51251"
SRC_URI[deb0.sha1sum] = "24b17f98b1e7622fc946667cd40adef3a0cc4777"
SRC_URI[deb0.sha256sum] = "e31e25580a6efa762fa47c5b8534618d117cbbaf2c8301e22006fdd37898fae1"
SRC_URI[deb0.sha512sum] = "031af621e2039f51190cebacc47c0160aa5bb620aee0e466ae673024e2eabb59b1991f9cca4f299bc3b45f6acce93502fa2900fd05deef41c84e56b599bf0e52"

RDEPENDS = " \
    libemail-date-format-perl \
    libmailtools-perl \
    perl \
"

