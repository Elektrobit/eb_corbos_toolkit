# This was autogenerated! Do not modify
SUMMARY = "modules to manipulate email in perl programs"
DESCRIPTION = ""
SECTION = "perl"
SOURCE_PACKAGE = "libmailtools-perl"
HOMEPAGE = "https://metacpan.org/release/MailTools"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libm/libmailtools-perl/libmailtools-perl_2.22-1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "4ff68cf4dbb6b9cf01126ec6a40cac56"
SRC_URI[deb0.sha1sum] = "d6b7c7fd1aa7ee4839c0da030f3a48ba029728dd"
SRC_URI[deb0.sha256sum] = "5f357d31747638132da12d432b3fc3a52a979221fab40de0d6d5334aa23b070d"
SRC_URI[deb0.sha512sum] = "d563cf9c347b870ca667a883fce2be1bb101207bd73bb6fa389a87f64c080332e756c1e8e419ecc2c02c6e013effc37322f0d7c65277ef3cf982553fa3d87397"

RDEPENDS = " \
    libnet-perl \
    libnet-smtp-ssl-perl \
    libtest-simple-perl \
    libtimedate-perl \
    perl \
"

