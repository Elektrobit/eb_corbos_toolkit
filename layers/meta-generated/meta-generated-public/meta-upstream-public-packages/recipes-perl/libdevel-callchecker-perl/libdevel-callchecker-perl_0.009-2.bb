# This was autogenerated! Do not modify
SUMMARY = "custom op checking attached to subroutines"
DESCRIPTION = ""
SECTION = "perl"
SOURCE_PACKAGE = "libdevel-callchecker-perl"
HOMEPAGE = "https://metacpan.org/release/Devel-CallChecker"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libd/libdevel-callchecker-perl/libdevel-callchecker-perl_0.009-2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libd/libdevel-callchecker-perl/libdevel-callchecker-perl_0.009-2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "c6655ce7a1af3fad04002d170bf15c1a"
SRC_URI[deb0.sha1sum] = "4541a0dcad720ce49073003c359e32c87a5acf19"
SRC_URI[deb0.sha256sum] = "c591d0c927ba6f61b53eed6ae0c976737dd3159a6e2b8ff5618d6c8b7dfea35e"
SRC_URI[deb0.sha512sum] = "46d85960213481789f579bd62455e24b1ffd9b95a8223832d30bbdd12fb9226a86d3ddd54d47baa389d56af9af8473ea69a2ce763bf34ba23aab813bf437162d"
SRC_URI[deb1.md5sum] = "a209926de6035374d815aeb7bb881754"
SRC_URI[deb1.sha1sum] = "32b6bc3b95d5a1cc1e9e82065bddf4300a001827"
SRC_URI[deb1.sha256sum] = "2d8571b24d6e4b21e11d7f887cddce732ed212674329ecbdcd5c2b8e95abfcd6"
SRC_URI[deb1.sha512sum] = "7ad4b37c0f104d18a01a437b516b65034f596ecf7aff2a323ef2495119fdff2d4ad895b1780d859a6cf69df04430a67a5011a467d9a30ab607e8c8ef173bd9b7"

RDEPENDS = " \
    libb-hooks-op-check-perl \
    libdynaloader-functions-perl \
    perl \
    perlapi-5.40.1 \
"

