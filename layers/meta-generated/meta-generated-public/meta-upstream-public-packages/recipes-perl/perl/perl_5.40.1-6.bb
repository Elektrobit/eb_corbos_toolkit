# This was autogenerated! Do not modify
SUMMARY = "Larry Wall's Practical Extraction and Report Language"
DESCRIPTION = ""
SECTION = "perl"
SOURCE_PACKAGE = "perl"
HOMEPAGE = "https://dev.perl.org/perl5/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/perl/perl_5.40.1-6_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/perl/perl_5.40.1-6_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "2fee71a65ffe52dab419e2dd409afe2f"
SRC_URI[deb0.sha1sum] = "9c5005df956b8fa8a3f487c175499e6029669465"
SRC_URI[deb0.sha256sum] = "11ec93d44649e9b37e3bddcf32a5f01d6e9dd3d0d79aac621b49473539c8f5b8"
SRC_URI[deb0.sha512sum] = "ac0d30d272c792de63374730432ed67f3f493859caf7008440da595895f969ea36ac795ec2a0fc5f60a0d927e07a34d2221bc1041b387ca79fa6b0b81dbd5792"
SRC_URI[deb1.md5sum] = "82761b95213b5cdc4da224a28f66991a"
SRC_URI[deb1.sha1sum] = "185fa14ea77e73ce88468919d982d43c86b6105a"
SRC_URI[deb1.sha256sum] = "68e82fa4deba7c9dc6b58c73f79b514f77521435b379e5680b8b8adfcd1d2b33"
SRC_URI[deb1.sha512sum] = "cf3acda445b81813dec8ebbd23a1160f5784ac55d11bcc005f9d1ae5dde3119e1b4a1fb4467adc3fe22803845a1b2ba89f3754d2d4e14844db2f8611e72f362a"

RDEPENDS = " \
    libperl5.40 \
    perl-base \
    perl-modules-5.40 \
"

RPROVIDES = " \
    libansicolor-perl \
    libarchive-tar-perl \
    libattribute-handlers-perl \
    libautodie-perl \
    libcompress-raw-bzip2-perl \
    libcompress-raw-zlib-perl \
    libcompress-zlib-perl \
    libcpan-meta-perl \
    libcpan-meta-requirements-perl \
    libcpan-meta-yaml-perl \
    libdigest-md5-perl \
    libdigest-perl \
    libdigest-sha-perl \
    libencode-perl \
    libexperimental-perl \
    libextutils-cbuilder-perl \
    libextutils-command-perl \
    libextutils-install-perl \
    libextutils-parsexs-perl \
    libfile-spec-perl \
    libhttp-tiny-perl \
    libi18n-langtags-perl \
    libio-compress-base-perl \
    libio-compress-bzip2-perl \
    libio-compress-perl \
    libio-compress-zlib-perl \
    libio-zlib-perl \
    libjson-pp-perl \
    liblocale-maketext-perl \
    liblocale-maketext-simple-perl \
    libmath-bigint-perl \
    libmath-complex-perl \
    libmime-base64-perl \
    libmodule-corelist-perl \
    libmodule-load-conditional-perl \
    libmodule-load-perl \
    libmodule-metadata-perl \
    libnet-perl \
    libnet-ping-perl \
    libparams-check-perl \
    libparent-perl \
    libparse-cpan-meta-perl \
    libperl-ostype-perl \
    libpod-escapes-perl \
    libpod-simple-perl \
    libstorable-perl \
    libsys-syslog-perl \
    libterm-table-perl \
    libtest-harness-perl \
    libtest-simple-perl \
    libtest-tester-perl \
    libtest-use-ok-perl \
    libtext-balanced-perl \
    libthread-queue-perl \
    libthreads-perl \
    libthreads-shared-perl \
    libtime-hires-perl \
    libtime-local-perl \
    libtime-piece-perl \
    libunicode-collate-perl \
    libversion-perl \
    libversion-requirements-perl \
    podlators-perl \
"
