# This was autogenerated! Do not modify
SUMMARY = "module for importing packages into other packages"
DESCRIPTION = ""
SECTION = "perl"
SOURCE_PACKAGE = "libimport-into-perl"
HOMEPAGE = "https://metacpan.org/release/Import-Into"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libi/libimport-into-perl/libimport-into-perl_1.002005-2_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "d9b0c71319f8c90cac8ce72b32a3b17f"
SRC_URI[deb0.sha1sum] = "9b3c4c97d42737e35ab3cf8e901528d1b2ec683a"
SRC_URI[deb0.sha256sum] = "abe499bb1c2d81c678346f7c2765cd9171360137bc9cf9230cf5368060713b3b"
SRC_URI[deb0.sha512sum] = "8696e9926244314bbe363401a9f0005e5c9cc0f95d61cf11af30c7a2b9df152fd71c0087c0af54ef76f556f538a1f3e5f39d098acbf466f006968a32d66282d4"

RDEPENDS = " \
    libmodule-runtime-perl \
    perl \
"

