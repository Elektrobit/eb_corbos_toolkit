# This was autogenerated! Do not modify
SUMMARY = "provide a sorted list of directory content"
DESCRIPTION = ""
SECTION = "perl"
SOURCE_PACKAGE = "libfile-dirlist-perl"
HOMEPAGE = "https://metacpan.org/release/File-DirList"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libf/libfile-dirlist-perl/libfile-dirlist-perl_0.05-3_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "b61c421df0f0e5264436dad718791b71"
SRC_URI[deb0.sha1sum] = "218f48a7b2431a67b3a08272acb9243312a60730"
SRC_URI[deb0.sha256sum] = "970de204782148f97f9f38cb569c4ab71399d88c9c620cd6516786b4f28430c0"
SRC_URI[deb0.sha512sum] = "5a6e8d05ae5bbed6e8efa89392dc50eed7372d51a62533bad2641ed072e7e7576d67a69b120119d2d4c542c27b93ca568b2ddc28656f831a554e635f2838a0fe"

RDEPENDS = " \
    perl \
"

