# This was autogenerated! Do not modify
SUMMARY = "Perl module to gather package and POD information from perl module files"
DESCRIPTION = ""
SECTION = "perl"
SOURCE_PACKAGE = "libmodule-metadata-perl"
HOMEPAGE = "https://metacpan.org/release/Module-Metadata"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libm/libmodule-metadata-perl/libmodule-metadata-perl_1.000038-1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "e12378735b9a694d15c50155c36d9c82"
SRC_URI[deb0.sha1sum] = "6c91bfba6f6655a8d1b4e04f112bab71064430ae"
SRC_URI[deb0.sha256sum] = "1e1740bda3d38bf2e010348b27e25f2a69308462c368951ea89586b88efbec5d"
SRC_URI[deb0.sha512sum] = "faf46c46afffd5d18ca7f123656fa5adbf4848b7ded1c4f8994f5a741943555ef0ddd503cb04e13f08fc8ca0c26823ed120805bf4c2a6e2efbc7b13bb5de293f"

RDEPENDS = " \
    perl \
"

