# This was autogenerated! Do not modify
SUMMARY = "get display widths of characters on the terminal"
DESCRIPTION = ""
SECTION = "perl"
SOURCE_PACKAGE = "libtext-charwidth-perl"
HOMEPAGE = "https://metacpan.org/release/Text-CharWidth"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libt/libtext-charwidth-perl/libtext-charwidth-perl_0.04-11+b4_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libt/libtext-charwidth-perl/libtext-charwidth-perl_0.04-11+b4_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "646e425e08efc5adaf3d34ba44412f75"
SRC_URI[deb0.sha1sum] = "fd53cdac1915e15c3bf6ce9d36daa948e455bf10"
SRC_URI[deb0.sha256sum] = "3a1d44df306e0252e8a16df07eba457bc9f2ef736ee890a1c35ffdfd548eafa0"
SRC_URI[deb0.sha512sum] = "1232e0e5905337d638aa11b33890b498b16acacd499fcd89e271df40079db07c1167d376ef7a3cb009cc9b84d27c5a623a8203306107a539e442dcfa274c2caa"
SRC_URI[deb1.md5sum] = "0ec8e5bc310989e655691bdb298df5e9"
SRC_URI[deb1.sha1sum] = "3598333a210bd4e33e4610787021e8fc6c79f3ae"
SRC_URI[deb1.sha256sum] = "72a9c2131b8dc3a124b778d1e7a606201388bf20203f12b571f4ea58ee362880"
SRC_URI[deb1.sha512sum] = "e76e76917400d568690c17957bb3fa6581cff38fb74d0a9b95759576e20f9bb09327df3aaadc12d18fec42fc37d1fb0d0ccc6f6b96335dbec8e9395b53d82b7d"

RDEPENDS = " \
    libc6 \
    perl-base \
    perlapi-5.40.0 \
"

