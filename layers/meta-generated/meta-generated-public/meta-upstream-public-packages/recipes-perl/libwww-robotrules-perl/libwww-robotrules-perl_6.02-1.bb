# This was autogenerated! Do not modify
SUMMARY = "database of robots.txt-derived permissions"
DESCRIPTION = ""
SECTION = "perl"
SOURCE_PACKAGE = "libwww-robotrules-perl"
HOMEPAGE = "https://metacpan.org/release/WWW-RobotRules"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libw/libwww-robotrules-perl/libwww-robotrules-perl_6.02-1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "1b8324d0e25d6bd149d897f628a8c4d5"
SRC_URI[deb0.sha1sum] = "fe400de7bb2b05482bedd440a12a21fdd71b3a87"
SRC_URI[deb0.sha256sum] = "be69cda8c2a860e64c43396bf2ff1c7145259cb85753ded14e0434f15ed647a0"
SRC_URI[deb0.sha512sum] = "8fa39127eb1a8b8e7aa54f9acca6fb8d339d0c8f4d54d0b72bbd6fec2549dd82e1ace534fd1edf0af83b2e9bcb43b35dcdd632324e5a9f1509c89c34415a8adf"

RDEPENDS = " \
    liburi-perl \
    perl \
"

