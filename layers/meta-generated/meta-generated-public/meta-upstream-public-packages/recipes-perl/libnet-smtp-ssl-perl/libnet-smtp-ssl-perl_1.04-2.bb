# This was autogenerated! Do not modify
SUMMARY = "Perl module providing SSL support to Net::SMTP"
DESCRIPTION = ""
SECTION = "perl"
SOURCE_PACKAGE = "libnet-smtp-ssl-perl"
HOMEPAGE = "https://metacpan.org/release/Net-SMTP-SSL"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libn/libnet-smtp-ssl-perl/libnet-smtp-ssl-perl_1.04-2_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "bc88afdee56c7a0860e023e455b8b8f0"
SRC_URI[deb0.sha1sum] = "9a07bb624cc16d01c7b4a41843c2616e1a0ed628"
SRC_URI[deb0.sha256sum] = "7688f64b65c9679449790e8bcdbbed849269caf3b607c7b39c447be10db177c5"
SRC_URI[deb0.sha512sum] = "0400b4faf47212085ab3907970f0d5a1d009415bd1fff13e99dcbd884de510d9ee88b20ad7e3605b4824f5e073a79c533e56f06b4423312a63caa3f871944811"

RDEPENDS = " \
    libio-socket-ssl-perl \
    perl \
"

