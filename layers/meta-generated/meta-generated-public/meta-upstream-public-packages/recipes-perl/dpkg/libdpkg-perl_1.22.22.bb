# This was autogenerated! Do not modify
SUMMARY = "Dpkg perl modules"
DESCRIPTION = ""
SECTION = "perl"
SOURCE_PACKAGE = "dpkg"
HOMEPAGE = "https://wiki.debian.org/Teams/Dpkg"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/d/dpkg/libdpkg-perl_1.22.22_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "7a6bf35f7a320b598af2d9340612c000"
SRC_URI[deb0.sha1sum] = "f5d219d88a8c51e2e363e90a0d80aa159847d908"
SRC_URI[deb0.sha256sum] = "b41eaeb4879091023f8c1a058510844a244d3d0bd0f437e0e05d58213e36fd9f"
SRC_URI[deb0.sha512sum] = "2ae29caa46e15addb1e29eb16ffd7836aab5dcb8401124ef97dfbb83dd5b8c74bc7679d4197e235ee1b4d71891737593653c67bace5d09af213e9700bf27f0d0"

RDEPENDS = " \
    dpkg \
    perl \
"

