# This was autogenerated! Do not modify
SUMMARY = "Perl module for finding user directories across platforms"
DESCRIPTION = ""
SECTION = "perl"
SOURCE_PACKAGE = "libfile-homedir-perl"
HOMEPAGE = "https://metacpan.org/release/File-HomeDir"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libf/libfile-homedir-perl/libfile-homedir-perl_1.006-2_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "45491f4884ace5250c09bbafbd8fe008"
SRC_URI[deb0.sha1sum] = "7821604c66d667e94e15e95d9966fdda5cc9b549"
SRC_URI[deb0.sha256sum] = "58a1dc7aa85403fba0d848485f4bc2c7589abd9125f63821137987456806519f"
SRC_URI[deb0.sha512sum] = "771675bf50b51e9a00bd7eb0acfd463875f576ec9c52277d6f6a8ebd59f061804a69436d16059f430c473dd6d2bd22e8f3b28cb8500666a8418e47030a26143f"

RDEPENDS = " \
    libfile-which-perl \
    perl \
"

