# This was autogenerated! Do not modify
SUMMARY = "HTTP cookie jars"
DESCRIPTION = ""
SECTION = "perl"
SOURCE_PACKAGE = "libhttp-cookies-perl"
HOMEPAGE = "https://metacpan.org/release/HTTP-Cookies"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libh/libhttp-cookies-perl/libhttp-cookies-perl_6.11-1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "1806681505bb917deacdd7ddacf2c0e6"
SRC_URI[deb0.sha1sum] = "77096cc183e6bec04694fcb7fcf411afd593306f"
SRC_URI[deb0.sha256sum] = "f3a57264a6704bd22397c644b1b91ed6055bdb190bd4d5d995cdf92840d049ed"
SRC_URI[deb0.sha512sum] = "dccf068474d50e51da435fb6909528d33e967c63ec2c9c1d9b79af9eb5ab88e7e832025f501885c48ffaa15e39615e9f3f21d53930e114b0fb6aa1a31a67a8e0"

RDEPENDS = " \
    libhttp-date-perl \
    libhttp-message-perl \
    perl \
"

