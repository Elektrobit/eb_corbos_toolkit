# This was autogenerated! Do not modify
SUMMARY = "perl interface to HTTP style messages"
DESCRIPTION = ""
SECTION = "perl"
SOURCE_PACKAGE = "libhttp-message-perl"
HOMEPAGE = "https://metacpan.org/release/HTTP-Message"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libh/libhttp-message-perl/libhttp-message-perl_7.00-2_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "a20317f219beff93cee20958f373c4ec"
SRC_URI[deb0.sha1sum] = "d0cb5516047722eea00700869d78cf0a6e36890e"
SRC_URI[deb0.sha256sum] = "e55e830b16af9c2b5269000c4dd9b93fd24b304a0675aeb0ab83438c566d2ca7"
SRC_URI[deb0.sha512sum] = "5c573ec18241b35eb42b7869cd7d5dab7112442d251cac9b5d0c7fdb4faea7bc46b9ae1ff7bc12342e5117981ba1cb9b5803103e10db45e3e186536a66f3afe0"

RDEPENDS = " \
    libclone-perl \
    libcompress-raw-bzip2-perl \
    libcompress-raw-zlib-perl \
    libencode-locale-perl \
    libencode-perl \
    libhttp-date-perl \
    libio-html-perl \
    liblwp-mediatypes-perl \
    liburi-perl \
    perl \
"

