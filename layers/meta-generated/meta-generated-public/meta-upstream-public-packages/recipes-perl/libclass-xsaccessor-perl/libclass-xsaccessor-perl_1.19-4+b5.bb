# This was autogenerated! Do not modify
SUMMARY = "Perl module providing fast XS accessors"
DESCRIPTION = ""
SECTION = "perl"
SOURCE_PACKAGE = "libclass-xsaccessor-perl"
HOMEPAGE = "https://metacpan.org/release/Class-XSAccessor"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libc/libclass-xsaccessor-perl/libclass-xsaccessor-perl_1.19-4+b5_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libc/libclass-xsaccessor-perl/libclass-xsaccessor-perl_1.19-4+b5_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "eab67fcbbec5ae4f6c458cb35de14e93"
SRC_URI[deb0.sha1sum] = "48e2783e4a090925a275bf389e2937a63d8ca0f7"
SRC_URI[deb0.sha256sum] = "46e6318281249d47b8abb33d36ec6c5b2bd0ac59af5af23c82835b9e4e0fc794"
SRC_URI[deb0.sha512sum] = "fad6ce20f440d3c11d9c86bef74206fbef46f7a1e44e8e7172eacfdcfc1a5a78076f59960825d6bbad620c16dcd98df6244f678e0f50e225473ee158b6b3c925"
SRC_URI[deb1.md5sum] = "0b0bff0eb2d071204eebc2a827f6b4f3"
SRC_URI[deb1.sha1sum] = "a6573ce645fc5ec64725b04c65769b45ce54668a"
SRC_URI[deb1.sha256sum] = "8ae68717d48cc6bc3a773a30e18e13feff3a7fedf6244f87433a6fd384b7f057"
SRC_URI[deb1.sha512sum] = "4a6fc6a666a9060f8d447b4ef506e8935829660c4aa62ff93fce6650d88392b8697e5a1a54ee9fa19a6e4de939231722f68266f86f7ff582c2c5ce4aa8ca282e"

RDEPENDS = " \
    libc6 \
    perl \
    perlapi-5.40.1 \
"

RPROVIDES = " \
    libclass-xsaccessor-array-perl \
"
