# This was autogenerated! Do not modify
SUMMARY = "Perl module to represent and create HTML syntax trees"
DESCRIPTION = ""
SECTION = "perl"
SOURCE_PACKAGE = "libhtml-tree-perl"
HOMEPAGE = "https://metacpan.org/release/HTML-Tree"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libh/libhtml-tree-perl/libhtml-tree-perl_5.07-3_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "e7001879fdc0013b75739cc6a3c19652"
SRC_URI[deb0.sha1sum] = "d659062daf2c36763c2f17a1572cfabf715771d3"
SRC_URI[deb0.sha256sum] = "00f857bb27388432df3e4d6510334a560c2de19feb4b31897cb5d83251bb54ac"
SRC_URI[deb0.sha512sum] = "64c99291e7f65ac26c4ff2ef8e6f91785251f90579b9ead693cc65cb7d739387f8286aa6db37153d2837742980270f486c885527efb8c18db713ac0c304104a6"

RDEPENDS = " \
    libhtml-parser-perl \
    libhtml-tagset-perl \
    perl \
"

