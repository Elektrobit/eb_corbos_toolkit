# This was autogenerated! Do not modify
SUMMARY = "collection of modules that parse HTML text documents"
DESCRIPTION = ""
SECTION = "perl"
SOURCE_PACKAGE = "libhtml-parser-perl"
HOMEPAGE = "https://metacpan.org/release/HTML-Parser"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libh/libhtml-parser-perl/libhtml-parser-perl_3.83-2~deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libh/libhtml-parser-perl/libhtml-parser-perl_3.83-2~deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "79046308562ce7d0e9796a08d709fa42"
SRC_URI[deb0.sha1sum] = "efa673f093da91b70cd8ac9fd3ce2ed3ce1cf2b0"
SRC_URI[deb0.sha256sum] = "408c98f2e8101608b4d0a3553af9708e4538d51626f97fe16705fd12f56bd79f"
SRC_URI[deb0.sha512sum] = "24fc68aa24111694dc764188bbe437d45fb4295550ae2f67e08f3fc6d88102c31b145355b2165f55ca0fc8feba1671c0f5ef1505b09730073339588c401374e7"
SRC_URI[deb1.md5sum] = "e0c7758d4d08eecf6b9d3985f73e0fc1"
SRC_URI[deb1.sha1sum] = "0592b115c179f4b75797c55610e94e3fa85d0565"
SRC_URI[deb1.sha256sum] = "51f1d70726daa87f762b91bc1f45ca6119a8e99d3f1952575581de3cf3d813d8"
SRC_URI[deb1.sha512sum] = "e31f364fa68ef4cc866780890a42c607f4bb921e1d8efe10b27ab2159a4263454092aca695396a42d9f5d82f10823f1158890dabbe147b4d8f0a4ebd7a19bfab"

RDEPENDS = " \
    libc6 \
    libhtml-tagset-perl \
    liburi-perl \
    perl \
    perlapi-5.40.1 \
"

