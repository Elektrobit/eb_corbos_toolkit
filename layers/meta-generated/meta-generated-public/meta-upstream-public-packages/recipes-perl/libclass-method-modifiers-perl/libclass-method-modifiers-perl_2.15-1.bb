# This was autogenerated! Do not modify
SUMMARY = "Perl module providing method modifiers"
DESCRIPTION = ""
SECTION = "perl"
SOURCE_PACKAGE = "libclass-method-modifiers-perl"
HOMEPAGE = "https://metacpan.org/release/Class-Method-Modifiers"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libc/libclass-method-modifiers-perl/libclass-method-modifiers-perl_2.15-1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "ccea4498a7156c7394601fe8d9f14ad0"
SRC_URI[deb0.sha1sum] = "789ef8d0773de1fbace2b78b532d162ff513c960"
SRC_URI[deb0.sha256sum] = "e23c4f48b4a89115b24e3a97bb2cd40a5e00e1454741113100eac8b6082f553a"
SRC_URI[deb0.sha512sum] = "b9622a9ce70b3fc81b56c36c95828370e167cf9d32796539562d615ef64ed0ae755212f526f9923a4df8e92fdc8c1607cf5bb798973b9b7ea47cedead73f8a10"

RDEPENDS = " \
    perl \
"

