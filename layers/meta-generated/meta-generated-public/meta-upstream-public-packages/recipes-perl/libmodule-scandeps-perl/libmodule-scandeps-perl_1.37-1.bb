# This was autogenerated! Do not modify
SUMMARY = "module to recursively scan Perl code for dependencies"
DESCRIPTION = ""
SECTION = "perl"
SOURCE_PACKAGE = "libmodule-scandeps-perl"
HOMEPAGE = "https://metacpan.org/release/Module-ScanDeps"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libm/libmodule-scandeps-perl/libmodule-scandeps-perl_1.37-1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "fa0423a8c5699de62a8fcfa620751d99"
SRC_URI[deb0.sha1sum] = "9c4c1a08f8a0114ed57cefe2205248759e3c911f"
SRC_URI[deb0.sha256sum] = "e998580a7dbaa1e3dee7367709137e4dd0fde69c15e29354ca58009958a6e3bb"
SRC_URI[deb0.sha512sum] = "aaf479ffc34d6b7a63256a1e0ec6ea9580d35d252b41b1baef99a92e72d0edb210d037d697d306dd3c2f97957f25a3de1ed8b5eba6850fd6afa39882cf7c82bb"

RDEPENDS = " \
    libmodule-metadata-perl \
    libscalar-list-utils-perl \
    libversion-perl \
    perl \
"

