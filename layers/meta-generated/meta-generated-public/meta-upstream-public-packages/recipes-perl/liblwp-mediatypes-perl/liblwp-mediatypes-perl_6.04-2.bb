# This was autogenerated! Do not modify
SUMMARY = "module to guess media type for a file or a URL"
DESCRIPTION = ""
SECTION = "perl"
SOURCE_PACKAGE = "liblwp-mediatypes-perl"
HOMEPAGE = "https://metacpan.org/release/LWP-MediaTypes"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libl/liblwp-mediatypes-perl/liblwp-mediatypes-perl_6.04-2_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "73ddb0e852844ed1171db14338a24821"
SRC_URI[deb0.sha1sum] = "5d47fff6eebd2e60acb353cef3cb59fea9063dce"
SRC_URI[deb0.sha256sum] = "c3ae8bca625ab6e16d6257698de402090135b5eca511df2c8086b0c23eefbaff"
SRC_URI[deb0.sha512sum] = "030dedce6ab60f8b50786cd51646d37b0f2f15aeb7330455627fb794e60231ebb374b7638ab1c21a1379c28daaca60bce90c1b3a0f261b81ddbfee8ca7b76113"

RDEPENDS = " \
    perl \
"

