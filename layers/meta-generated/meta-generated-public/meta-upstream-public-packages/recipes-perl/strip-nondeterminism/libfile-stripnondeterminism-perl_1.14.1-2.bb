# This was autogenerated! Do not modify
SUMMARY = "file non-deterministic information stripper — Perl module"
DESCRIPTION = ""
SECTION = "perl"
SOURCE_PACKAGE = "strip-nondeterminism"
HOMEPAGE = "https://reproducible-builds.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/strip-nondeterminism/libfile-stripnondeterminism-perl_1.14.1-2_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "015f7e73338e6e1847075bdf092e8d45"
SRC_URI[deb0.sha1sum] = "34d051d6a7c11fa262206e3086f827d87a63d0e9"
SRC_URI[deb0.sha256sum] = "d03b28625a443b749e449d146bf99ef5419eb05ecbff256a71069a25de1549cf"
SRC_URI[deb0.sha512sum] = "57c0410a85cfd93d2b9e7e69973a19dbe411167e887027ea2d7e16c039f551c27a6dca76ff08d05279525dc9eb84eda7e6de1d524567fee172d876e98b40bb9a"

RDEPENDS = " \
    file \
    libarchive-zip-perl \
    perl \
"

