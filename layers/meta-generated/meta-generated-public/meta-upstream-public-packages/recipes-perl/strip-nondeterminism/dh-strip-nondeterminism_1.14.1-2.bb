# This was autogenerated! Do not modify
SUMMARY = "file non-deterministic information stripper — Debhelper add-on"
DESCRIPTION = ""
SECTION = "perl"
SOURCE_PACKAGE = "strip-nondeterminism"
HOMEPAGE = "https://reproducible-builds.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/strip-nondeterminism/dh-strip-nondeterminism_1.14.1-2_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "6276a94c963744f9fcb7030362840d10"
SRC_URI[deb0.sha1sum] = "ffcadd6d1344effb12506689f64c7e2758d01b45"
SRC_URI[deb0.sha256sum] = "caadb7094d10f933619f1261fe1e31c86460992b7d2685d2596f15f848d1a174"
SRC_URI[deb0.sha512sum] = "8c8e54606fe83103aa1d4b2f5e732f70dbb04c5db93a67ea08b53bd2ce62808af263adf32ccebe0df490516aa1703b6017209cd2dae00a39b04ebcee8f0c5b87"

RDEPENDS = " \
    libdebhelper-perl \
    libfile-stripnondeterminism-perl \
    perl \
"

