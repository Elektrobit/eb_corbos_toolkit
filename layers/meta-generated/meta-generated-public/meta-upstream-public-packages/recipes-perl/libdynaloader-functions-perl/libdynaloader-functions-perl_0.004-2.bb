# This was autogenerated! Do not modify
SUMMARY = "deconstructed dynamic C library loading"
DESCRIPTION = ""
SECTION = "perl"
SOURCE_PACKAGE = "libdynaloader-functions-perl"
HOMEPAGE = "https://metacpan.org/release/DynaLoader-Functions"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libd/libdynaloader-functions-perl/libdynaloader-functions-perl_0.004-2_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "8b365c005bbec068b12d779789582313"
SRC_URI[deb0.sha1sum] = "f48c3d0623dee0ec391a3889424e8660369a4da8"
SRC_URI[deb0.sha256sum] = "41a780d15e9c1093c2f9d254f7496eeff8819522a6971182373c3a16cb050bee"
SRC_URI[deb0.sha512sum] = "17fe148e3279eb821ca7a39517bc79b26c3ab583d430450351a4b25ead9ecab5f8acaca90d460797dc45b99662e22bcd52908ca29d537710eca910edec29b43a"

RDEPENDS = " \
    perl \
"

