# This was autogenerated! Do not modify
SUMMARY = "module for recursively copying Perl datatypes"
DESCRIPTION = ""
SECTION = "perl"
SOURCE_PACKAGE = "libclone-perl"
HOMEPAGE = "https://metacpan.org/release/Clone"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libc/libclone-perl/libclone-perl_0.47-1+b1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libc/libclone-perl/libclone-perl_0.47-1+b1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "6f85cd0875687729c59ca91315166807"
SRC_URI[deb0.sha1sum] = "c05c22c6d6f5fa1fe15159159e6b1b7ab9a61158"
SRC_URI[deb0.sha256sum] = "c1ca65f05a5fb68b04b4fb0c9f1bd1210c80041c98b0ea7848d80be8bc7a72a5"
SRC_URI[deb0.sha512sum] = "59ba6529a41919e3868d30bc98c15761a8fe7a04c58bfb50eaa9c1654b204eb7b92176c156ee99602093f376f5eef36dac337ea6a53045d42ca302e5cea064cc"
SRC_URI[deb1.md5sum] = "a75f1abca6c78065600508a72c4f75d2"
SRC_URI[deb1.sha1sum] = "a754b7f0142ddea05b86fedd91ebc6eb5e764d51"
SRC_URI[deb1.sha256sum] = "48e3a080da34e615d64d495a8c9d0c745115a479d1f1120f2fb44b706d596e4d"
SRC_URI[deb1.sha512sum] = "09f69e7f8cddc4a4473df4acc9108e89b0e9ef72b49fbf8e91a5d493ec0ba41ae1b52188235dda618a4f8b6036a5f5bb24d9202309d5bf9ee1473ee8d287674d"

RDEPENDS = " \
    libc6 \
    perl \
    perlapi-5.40.0 \
"

