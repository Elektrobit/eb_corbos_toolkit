# This was autogenerated! Do not modify
SUMMARY = "set of basic utilities for writing tests in Perl"
DESCRIPTION = ""
SECTION = "perl"
SOURCE_PACKAGE = "libtest-simple-perl"
HOMEPAGE = "https://metacpan.org/release/Test-Simple/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libt/libtest-simple-perl/libtest-simple-perl_1.302210-1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "5b970d7904c6d4770a04b51eafe561d1"
SRC_URI[deb0.sha1sum] = "868a1fe27703ac7f00f3893d3f2fe7c4ee446e68"
SRC_URI[deb0.sha256sum] = "fdcd8f39c86f18ff1e2a78c06503d05bb2714a4e3c85314bebbaac60df3875cb"
SRC_URI[deb0.sha512sum] = "d57540a4eb16b7483c63eee5d76cbca4c4a483593311a73c8776a14c5522679108eba49c04ad07437b5c19e2e99c46ddb353d410f640aab285bca428703ede58"

RDEPENDS = " \
    libterm-table-perl \
    perl \
"

RPROVIDES = " \
    libtest-tester-perl \
    libtest-use-ok-perl \
    libtest2-perl \
    libtest2-suite-perl \
"
