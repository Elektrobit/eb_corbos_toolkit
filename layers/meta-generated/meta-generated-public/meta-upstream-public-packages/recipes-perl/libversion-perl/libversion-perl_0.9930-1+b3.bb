# This was autogenerated! Do not modify
SUMMARY = "Perl extension for Version Objects"
DESCRIPTION = ""
SECTION = "perl"
SOURCE_PACKAGE = "libversion-perl"
HOMEPAGE = "https://metacpan.org/release/version"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libv/libversion-perl/libversion-perl_0.9930-1+b3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libv/libversion-perl/libversion-perl_0.9930-1+b3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "968f0fa685b9d911ec87e18ad89908d5"
SRC_URI[deb0.sha1sum] = "3c9bca6442d5c41dd07a2ab4bc751832b2dbc681"
SRC_URI[deb0.sha256sum] = "14d20f0fbc0d1f73c86ff425b8266c670278e87fd0a3bd03a8eb00f15cc455cc"
SRC_URI[deb0.sha512sum] = "1fe1465da4f41ef155032ac302db59c771ff06d54511e8a62c5937bcc40c1bed07ad4eddfdfc4b6f4151227986fd9bcf0233f1fe8812286bcf0e4494ea177155"
SRC_URI[deb1.md5sum] = "2db5362d51e3e26d7850f6284a292b4c"
SRC_URI[deb1.sha1sum] = "7732bb1df2649eec4718742858bf3217302f124c"
SRC_URI[deb1.sha256sum] = "17d503362a4bb756d16c3a4285737230cbbd0d9baac67282580c6d4ba12ef028"
SRC_URI[deb1.sha512sum] = "b1903e86de8c9c0c63feda56576dbe7bf63288853ffaf4620acea55a17dcb785a5f7080ef4b679de030edbef1112d3440509baf10ae75b6b66291c33c363d1f6"

RDEPENDS = " \
    libc6 \
    perl \
    perlapi-5.40.0 \
"

