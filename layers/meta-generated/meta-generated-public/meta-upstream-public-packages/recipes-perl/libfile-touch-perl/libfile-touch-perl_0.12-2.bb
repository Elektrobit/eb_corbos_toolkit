# This was autogenerated! Do not modify
SUMMARY = "Perl interface to touch-like functions"
DESCRIPTION = ""
SECTION = "perl"
SOURCE_PACKAGE = "libfile-touch-perl"
HOMEPAGE = "https://metacpan.org/release/File-Touch"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libf/libfile-touch-perl/libfile-touch-perl_0.12-2_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "abcc965ccdf1befe748ebd861ec36a83"
SRC_URI[deb0.sha1sum] = "00693ca97e0a42d1778b7e72a900ec4d05adbf46"
SRC_URI[deb0.sha256sum] = "14fc3b0a5123435fda39effa780fa6e5f951c0558f5ed72cb18020987a5da0f4"
SRC_URI[deb0.sha512sum] = "7cbd351a1526b83d891ac1e7fd32b5f8f865c67c8e1d29c843e7ffb403f2f51d95415948ccf085d4e7f5c4f68dc749609b5223bfb3efe214778d1c0744c9eaff"

RDEPENDS = " \
    perl \
"

