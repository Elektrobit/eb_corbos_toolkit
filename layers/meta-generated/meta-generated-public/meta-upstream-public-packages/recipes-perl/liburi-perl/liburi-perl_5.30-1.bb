# This was autogenerated! Do not modify
SUMMARY = "module to manipulate and access URI strings"
DESCRIPTION = ""
SECTION = "perl"
SOURCE_PACKAGE = "liburi-perl"
HOMEPAGE = "https://metacpan.org/release/URI"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libu/liburi-perl/liburi-perl_5.30-1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "c780c7685351757483991b611450e9a9"
SRC_URI[deb0.sha1sum] = "0b1fdf1baf48d943b98b670aa57dc748fd000e5b"
SRC_URI[deb0.sha256sum] = "33957bd8218ddd3a86cc19fdf3bf7832b0640337a4be6cf23b2714b73d220220"
SRC_URI[deb0.sha512sum] = "c6ae06dd6ab39578a95430255cc1e8829bca3ab48011869e102e8a975e8837f71f2a72161b3080943e788c5299994da9f237dbe34265f370d037a8a7f894275f"

RDEPENDS = " \
    libencode-perl \
    libscalar-list-utils-perl \
    perl \
"

