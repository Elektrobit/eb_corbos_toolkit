# This was autogenerated! Do not modify
SUMMARY = "module providing low-level HTTP connection client"
DESCRIPTION = ""
SECTION = "perl"
SOURCE_PACKAGE = "libnet-http-perl"
HOMEPAGE = "https://metacpan.org/release/Net-HTTP"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libn/libnet-http-perl/libnet-http-perl_6.23-1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "ea5fb8921d7154273c94eba550c21e9b"
SRC_URI[deb0.sha1sum] = "eab3e099e7a9bf615302fe1ac29f2940024bb0b1"
SRC_URI[deb0.sha256sum] = "ef8220824939149b88ff230081e4bd686d1d92f0a233c4f80d1e14115ab1b510"
SRC_URI[deb0.sha512sum] = "e4c78024fa41f66b415d8a060ee23445e70b40c29d943bce320eb9fd2519f6e23fd0fe44a6322f2df85b1d3926f4602f694e0d171b1f8f70a1f1c638bb53e118"

RDEPENDS = " \
    libio-socket-ip-perl \
    liburi-perl \
    perl \
"

