# This was autogenerated! Do not modify
SUMMARY = "module for using IPv4 and IPv6 sockets in a protocol-independent way"
DESCRIPTION = ""
SECTION = "perl"
SOURCE_PACKAGE = "libio-socket-ip-perl"
HOMEPAGE = "https://metacpan.org/release/IO-Socket-IP"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libi/libio-socket-ip-perl/libio-socket-ip-perl_0.43-1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "8f2336aeed02d24b420b652eaa2a9ad9"
SRC_URI[deb0.sha1sum] = "022f731cfdc6fd8b094c55422e83ac3788f2dc48"
SRC_URI[deb0.sha256sum] = "f9c5929f513c20b0500db78cc4a4a75d5d74d95a67bbfc10e1776363ab81b5f3"
SRC_URI[deb0.sha512sum] = "2af79ccae51dbdf249e4b13a496b5002676681632b2951000a409f5fdf9acc99cafb376b55379f2d3c8d3b69cf0b2c3bcc6bb79a88228fb49be14572fb8dc678"

RDEPENDS = " \
    netbase \
"

