# This was autogenerated! Do not modify
SUMMARY = "internationalized substitute of Text::Wrap"
DESCRIPTION = ""
SECTION = "perl"
SOURCE_PACKAGE = "libtext-wrapi18n-perl"
HOMEPAGE = "https://metacpan.org/release/Text-WrapI18N"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libt/libtext-wrapi18n-perl/libtext-wrapi18n-perl_0.06-10_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "b57a11d040f8e9055f8f2e83ed3dd70b"
SRC_URI[deb0.sha1sum] = "f442e53233cb43d7c9d108051d76a73cfd48e473"
SRC_URI[deb0.sha256sum] = "17f98c7c09af8ac3bdbfd5a5dad32f3f51c71b02cdfc411366f49092a395de85"
SRC_URI[deb0.sha512sum] = "0a554401cff25893504699c927f9bcd19929fdfd3837f4d7569c3cd18bd2bd21949435f9ef5466b5a7b7d77f004b22f00e1fc559084a60822faa293d93212792"

RDEPENDS = " \
    libtext-charwidth-perl \
"

