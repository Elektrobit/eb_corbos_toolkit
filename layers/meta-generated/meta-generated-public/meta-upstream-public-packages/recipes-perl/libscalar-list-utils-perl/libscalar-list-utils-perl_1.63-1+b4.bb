# This was autogenerated! Do not modify
SUMMARY = "modules providing common scalar and list utility subroutines"
DESCRIPTION = ""
SECTION = "perl"
SOURCE_PACKAGE = "libscalar-list-utils-perl"
HOMEPAGE = "https://metacpan.org/release/Scalar-List-Utils"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libs/libscalar-list-utils-perl/libscalar-list-utils-perl_1.63-1+b4_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libs/libscalar-list-utils-perl/libscalar-list-utils-perl_1.63-1+b4_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "242c5c3fca869be282128aad19038d85"
SRC_URI[deb0.sha1sum] = "ab2aadb7fb5f0984fcd95422b778f49539a98f55"
SRC_URI[deb0.sha256sum] = "93b7ed975d41e50ba78b2c23799baa11242fc5c50d465c6fab2585184aff3e6f"
SRC_URI[deb0.sha512sum] = "82fa9e87e3e8226520a02c1dd3ea31dc0ea3f3c02a132e8a551cab52ccc823ed905a764e77db106ff9f8060c6a779265244b7d683339390187b621bb4a3dd634"
SRC_URI[deb1.md5sum] = "a9f96b4e859538313f626364cc7c5ddc"
SRC_URI[deb1.sha1sum] = "7ee5b3f3f263a8a0b21eb0a63a1cd966bbc23fed"
SRC_URI[deb1.sha256sum] = "76177ee7a2a67b9d1c0c1c3f0df4b4996b6beb60d627c767b55a781819f48635"
SRC_URI[deb1.sha512sum] = "79c0ad82ff104faa087c2a96abee8ffa5d5da47bc03b94ee372938225b5f7c552d6fe5ae8868a25f659a98bae0bb1dd669c3dc2924b83a5cb1599fdf3bd21de8"

RDEPENDS = " \
    libc6 \
    perl \
    perlapi-5.40.0 \
"

