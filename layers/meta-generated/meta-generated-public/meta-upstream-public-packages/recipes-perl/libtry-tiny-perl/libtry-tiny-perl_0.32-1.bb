# This was autogenerated! Do not modify
SUMMARY = "module providing minimalistic try/catch"
DESCRIPTION = ""
SECTION = "perl"
SOURCE_PACKAGE = "libtry-tiny-perl"
HOMEPAGE = "https://metacpan.org/release/Try-Tiny"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libt/libtry-tiny-perl/libtry-tiny-perl_0.32-1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "1e4b3deb3d831f98ce8ed7b68e13f420"
SRC_URI[deb0.sha1sum] = "5df086deac5b9360edd382fbeda98aedd8207f49"
SRC_URI[deb0.sha256sum] = "f160af736fa67df5a5f6ec222d28e6c188b5b87965bd649956a6bea8795c1d3a"
SRC_URI[deb0.sha512sum] = "514716d4d05bfd3d20e693512611f673dd78cb4d2c5f16d35d22607b4705064789e4f9e960c0f20524624657785bbb13a97447cdd94a728cbb51ac09548f874b"

RDEPENDS = " \
    perl \
"

