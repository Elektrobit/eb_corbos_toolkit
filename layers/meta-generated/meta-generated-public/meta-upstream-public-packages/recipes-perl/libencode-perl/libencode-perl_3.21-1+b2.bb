# This was autogenerated! Do not modify
SUMMARY = "module providing interfaces between Perl's strings and the system"
DESCRIPTION = ""
SECTION = "perl"
SOURCE_PACKAGE = "libencode-perl"
HOMEPAGE = "https://metacpan.org/release/Encode"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libe/libencode-perl/libencode-perl_3.21-1+b2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libe/libencode-perl/libencode-perl_3.21-1+b2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "82a0739e99935f74eb5adbbfd38a393c"
SRC_URI[deb0.sha1sum] = "668e05cfe446948e90ee4659de773c576f3789e5"
SRC_URI[deb0.sha256sum] = "ea20d3d506fc201fec6476e429bb9de8980a734a184ef2c9304950cec8b3c09b"
SRC_URI[deb0.sha512sum] = "76a6ecd381290bff8951214b7387ca477d1f14f8313abf448529c4fd706bcbb077e07b18b10d8b86fec0da268b618a47953e4486a07a62ab7cb439b74d144068"
SRC_URI[deb1.md5sum] = "464a433a82cd1e2912948cc2f8dfbd8a"
SRC_URI[deb1.sha1sum] = "192feafce8f8217f4e38f5d46fb85059b009b4d0"
SRC_URI[deb1.sha256sum] = "e49158dfe936aa72b4ac199132e44d4f1277028bcf08cf6294e6c9f38f2b294c"
SRC_URI[deb1.sha512sum] = "6b0eab13aac4118d143629b621c25b8fda04041e47c114c5859c7fe57fd15b4342218299c421f695981555112063696078918663baf3c85c0ee4f5f679d6085b"

RDEPENDS = " \
    libc6 \
    perl \
    perlapi-5.40.0 \
"

