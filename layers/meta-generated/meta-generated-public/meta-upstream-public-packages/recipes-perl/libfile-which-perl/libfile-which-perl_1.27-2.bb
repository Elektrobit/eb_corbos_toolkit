# This was autogenerated! Do not modify
SUMMARY = "Perl module for searching paths for executable programs"
DESCRIPTION = ""
SECTION = "perl"
SOURCE_PACKAGE = "libfile-which-perl"
HOMEPAGE = "https://metacpan.org/release/File-Which"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libf/libfile-which-perl/libfile-which-perl_1.27-2_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "3afb57122bc9e5846bda550d6c53bcda"
SRC_URI[deb0.sha1sum] = "9c53736664a5dd955b7f95fc40ea757667ee5827"
SRC_URI[deb0.sha256sum] = "ab06d044acd41214f38f310bfec05548bee6ae7fcc97a3ac683b9932bd1d48c1"
SRC_URI[deb0.sha512sum] = "7e135bb1435df4c9ca592691eb35dbab5875bf93d88988c1b5ef0bac05260500713ae7b460f9aa63bdc8405ac57947374e0355550a9ba8d0eb08cc3b0e0ef78a"

RDEPENDS = " \
    perl \
"

