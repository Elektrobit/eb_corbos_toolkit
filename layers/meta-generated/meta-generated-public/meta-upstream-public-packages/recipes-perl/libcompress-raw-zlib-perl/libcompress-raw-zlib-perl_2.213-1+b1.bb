# This was autogenerated! Do not modify
SUMMARY = "low-level interface to zlib compression library"
DESCRIPTION = ""
SECTION = "perl"
SOURCE_PACKAGE = "libcompress-raw-zlib-perl"
HOMEPAGE = "https://metacpan.org/release/Compress-Raw-Zlib"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libc/libcompress-raw-zlib-perl/libcompress-raw-zlib-perl_2.213-1+b1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libc/libcompress-raw-zlib-perl/libcompress-raw-zlib-perl_2.213-1+b1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "59aedb6bafb0c16c5ef906caedea1ce8"
SRC_URI[deb0.sha1sum] = "5707d46e2284ce481f3485465294e8d5eabef342"
SRC_URI[deb0.sha256sum] = "761bb8266f128b8e4b413ae4a76dcb01a226a09a8709c1dc676d1783af0e6499"
SRC_URI[deb0.sha512sum] = "efb1a2a6c65fc06a92c0972d16fcacf54ce5e13c1cb11734f3f74c003a5cafd4ccb9187744c02fc2f8d0626ce9c9bcf63d646ab559110a7728bc4b85c72c6ff3"
SRC_URI[deb1.md5sum] = "9d345c7c150b3931d9e8ca791fbf28a7"
SRC_URI[deb1.sha1sum] = "32481033ed77a49f7e31f53b0f320f3b43b65816"
SRC_URI[deb1.sha256sum] = "d723a20baa3ba32f052e73a50b5440f4e885d4d25bae52abc8e9e20336bb8b22"
SRC_URI[deb1.sha512sum] = "28d89c49d51d77daccc4b122e0931caccd1c1994c8416a7f202037e27d6901425312994aae92ab666420b408a63964a85449ce50fdb6176753fac1b81202d2a6"

RDEPENDS = " \
    libc6 \
    perl \
    perlapi-5.40.0 \
    zlib1g \
"

