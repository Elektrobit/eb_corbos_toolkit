# This was autogenerated! Do not modify
SUMMARY = "Minimalist Object Orientation library (with Moose compatibility)"
DESCRIPTION = ""
SECTION = "perl"
SOURCE_PACKAGE = "libmoo-perl"
HOMEPAGE = "https://metacpan.org/release/Moo"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libm/libmoo-perl/libmoo-perl_2.005005-1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "66682042682fc8100eed0f22a3f8d505"
SRC_URI[deb0.sha1sum] = "d11f94f539e1b856e3ed052f8c605a5f567f8d98"
SRC_URI[deb0.sha256sum] = "31c360197548cfc607b673fd2e1f89bb0d724e7540a8dfe91bf8875cfa902cd2"
SRC_URI[deb0.sha512sum] = "953e3747c22ad72810b92654c85ce15b9e558e7deb08d646359c35e9b6acc477b6d9e56155cf4300a81cd21065cee1951e5c15f35cebd3de5943d261e3dc370b"

RDEPENDS = " \
    libclass-method-modifiers-perl \
    libclass-xsaccessor-perl \
    libimport-into-perl \
    librole-tiny-perl \
    libscalar-list-utils-perl \
    libsub-quote-perl \
    perl \
"

