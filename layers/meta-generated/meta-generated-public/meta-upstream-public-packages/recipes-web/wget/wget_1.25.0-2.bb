# This was autogenerated! Do not modify
SUMMARY = "retrieves files from the web"
DESCRIPTION = ""
SECTION = "web"
SOURCE_PACKAGE = "wget"
HOMEPAGE = "https://www.gnu.org/software/wget/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/w/wget/wget_1.25.0-2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/w/wget/wget_1.25.0-2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "cc6c90bff89868a9dec2ec13cf86943c"
SRC_URI[deb0.sha1sum] = "3d0fb7c6536d3ba7860f0ab80b261107795ed9e4"
SRC_URI[deb0.sha256sum] = "5649cad63c781b2dcf5a7b87d70b3bf789291cd0d6bcabc4d521211f94980683"
SRC_URI[deb0.sha512sum] = "922c26ceb450db258bd9572182cfff18911452a64f8b66ae5ded1f3b7147b077d06edf1a752e06f763bd29b83c9bb14c6e51d571c25f3eeb02969d5cc8ea3cb4"
SRC_URI[deb1.md5sum] = "5b5aa9fac26be6a69e647a59a8136fe2"
SRC_URI[deb1.sha1sum] = "36bbaf83fa83b3a16d0675a11659982b7df98d45"
SRC_URI[deb1.sha256sum] = "b5232cda342e4b6d6f5ebf309d4b1639e722837dd9fa0574997029302288c43b"
SRC_URI[deb1.sha512sum] = "36d96da98fefd664b4e772101b8303b2e50cdbd529ef6f7faa5c41d07191402229f89e1217af5e951089296de578e686f1186959406cb596f8a1a3ef683ca439"

RDEPENDS = " \
    libc6 \
    libgnutls30t64 \
    libidn2-0 \
    libnettle8t64 \
    libpcre2-8-0 \
    libpsl5t64 \
    libuuid1 \
    zlib1g \
"

