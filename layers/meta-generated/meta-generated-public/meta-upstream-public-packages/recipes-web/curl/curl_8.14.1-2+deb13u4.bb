# This was autogenerated! Do not modify
SUMMARY = "command line tool for transferring data with URL syntax"
DESCRIPTION = ""
SECTION = "web"
SOURCE_PACKAGE = "curl"
HOMEPAGE = "https://curl.se/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/c/curl/curl_8.14.1-2+deb13u4_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/c/curl/curl_8.14.1-2+deb13u4_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "fd49b0bc9f606f0743122c199fad9e2b"
SRC_URI[deb0.sha1sum] = "7ba41bdcd2ca506a7d43c424db9cde0662a868ca"
SRC_URI[deb0.sha256sum] = "7bd23df36e65ca32a5bbd81f67ca311b9e0c122212c70d0733f4e45d745789d2"
SRC_URI[deb0.sha512sum] = "55cf20408f2ec1972cda999f5ae630c16843f318944098768f314ff0710a794a652cfabf0c40239a931a8dbd46fe33d293702f6bcd001da37186921ff986cf2a"
SRC_URI[deb1.md5sum] = "b9f16371dde60c8957ea84c83c1db2f4"
SRC_URI[deb1.sha1sum] = "afc95b17f1a80f8fc31f28b5a8419de86395af6e"
SRC_URI[deb1.sha256sum] = "9881fbb76558c576488c90e0a1cb1cc2d2154b1e39a70dd44e2b736200146afe"
SRC_URI[deb1.sha512sum] = "1b6eae5366b9764a44019c32014194158a42a10676738f74b45281c327417d20702b2205855b516ee213f26aa2c18faf5e210e5542e6d1af2705649148ae61bd"

RDEPENDS = " \
    libc6 \
    libcurl4t64 \
    zlib1g \
"

