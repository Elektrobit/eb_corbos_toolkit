# This was autogenerated! Do not modify
SUMMARY = "generic font configuration library - configuration"
DESCRIPTION = ""
SECTION = "fonts"
SOURCE_PACKAGE = "fontconfig"
HOMEPAGE = "https://www.freedesktop.org/wiki/Software/fontconfig/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/f/fontconfig/fontconfig-config_2.15.0-2.3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/f/fontconfig/fontconfig-config_2.15.0-2.3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "95f8ab94549d523b1a2739afefe99757"
SRC_URI[deb0.sha1sum] = "42632289af95f004453b2deaf183de21282d7ca3"
SRC_URI[deb0.sha256sum] = "0475c00d02660c07a15085051818625331bb502e053242106aaaa1f2ddb41225"
SRC_URI[deb0.sha512sum] = "d66ce0c10bc2ba3e37d00432a894ff2bad7d704fbf6eaeac8b531626d14977ca6cfcd2ccef1e93b7119dcdb770620f5390bc2cea3686a2a74c3052b60e60a0c0"
SRC_URI[deb1.md5sum] = "f56afc064b13ff3cf020ee0480f5d23d"
SRC_URI[deb1.sha1sum] = "eba09ae6af3f9ed7ab2ca567c468dd03360f9a1d"
SRC_URI[deb1.sha256sum] = "10f643f467b51cf25fc18d1945bc61246dd8d8d1fe6bc712a2b1712c74ebc4d6"
SRC_URI[deb1.sha512sum] = "352897823676938ab0a89c82a94ac46c44d255229177d1d07996f7f0e6bde7c1990b083bbec226d6a87efe57603a9b130e27810ac0295782229e27f1a0ba7394"

RDEPENDS = " \
    debconf \
    fonts-dejavu-core \
"

