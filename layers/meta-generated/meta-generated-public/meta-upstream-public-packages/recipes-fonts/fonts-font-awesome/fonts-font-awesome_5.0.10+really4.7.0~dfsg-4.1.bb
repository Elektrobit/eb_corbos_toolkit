# This was autogenerated! Do not modify
SUMMARY = "iconic font designed for use with Twitter Bootstrap"
DESCRIPTION = ""
SECTION = "fonts"
SOURCE_PACKAGE = "fonts-font-awesome"
HOMEPAGE = "http://fontawesome.io/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/f/fonts-font-awesome/fonts-font-awesome_5.0.10+really4.7.0~dfsg-4.1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "df46d41772b221b5290249a8660c7fd4"
SRC_URI[deb0.sha1sum] = "1b9bddc539da7c0d8226773a3077b924320b05c0"
SRC_URI[deb0.sha256sum] = "5f09e1adce26d59628a239c538882d53e58978b958233864fc617be9a510018e"
SRC_URI[deb0.sha512sum] = "1e1cc04c395af508668bd814fe2cb0b86024de180ed603ce3e7a47c2cbc6408e92c614a5714842b1f23e29bee6939700a790ef99b5866a5c6ccd2aabb0b08bfc"


RPROVIDES = " \
    node-font-awesome \
    sass-stylesheets-fonts-awesome \
"
