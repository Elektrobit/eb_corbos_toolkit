# This was autogenerated! Do not modify
SUMMARY = "Vera font family derivate with additional characters"
DESCRIPTION = ""
SECTION = "fonts"
SOURCE_PACKAGE = "fonts-dejavu"
HOMEPAGE = "https://dejavu-fonts.github.io/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/f/fonts-dejavu/fonts-dejavu-core_2.37-8_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "a1ef9f90a50918bc2430b08ec79dad1e"
SRC_URI[deb0.sha1sum] = "475722decc50725f650e326d52dfdd0c66853a6b"
SRC_URI[deb0.sha256sum] = "86635b3d25b3655fc11cb3ecc3af59f0bf19643b02b94f2de48bd10253cdba12"
SRC_URI[deb0.sha512sum] = "2f4e0a3a64b4c8599906e741e7187ab2006bc165e58b8147a6d0aeae718cd78812d1f02cf29c96a0162c191b3dbe72220f2ebe9dd8a15196a2a2d336b3f7a4df"

RDEPENDS = " \
    fonts-dejavu-mono \
"

