# This was autogenerated! Do not modify
SUMMARY = "Vera font family derivate with additional characters"
DESCRIPTION = ""
SECTION = "fonts"
SOURCE_PACKAGE = "fonts-dejavu"
HOMEPAGE = "https://dejavu-fonts.github.io/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/f/fonts-dejavu/fonts-dejavu-mono_2.37-8_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "946eab8f7cb1e6313bb25975156f1714"
SRC_URI[deb0.sha1sum] = "aa243c859895c91f0fb48f4974a9d7b6b67065da"
SRC_URI[deb0.sha256sum] = "3003e98a5debfdeadc7040a7f715fe9fe6fb67f68deacf6049b54e30f07fc014"
SRC_URI[deb0.sha512sum] = "b51162e1cb0b631e57349536e78107da897b9ab593a65f665a62094ab76919a9f83be5a93e25f2dcb676c9201d204769a60fb9187112bcbd566eb444a31e2053"


