# This was autogenerated! Do not modify
SUMMARY = "Netfilter netlink library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libnfnetlink"
HOMEPAGE = "https://git.netfilter.org/libnfnetlink"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libn/libnfnetlink/libnfnetlink0_1.0.2-3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libn/libnfnetlink/libnfnetlink0_1.0.2-3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "de3124cb01d44b98604a5cccf7ccfacf"
SRC_URI[deb0.sha1sum] = "c6d880a96d0008214396178bc16f9b68e716706d"
SRC_URI[deb0.sha256sum] = "5e4c3c40a04ffdb4139e4bef1136585e151a8eb8c71efa6c7250b636b3c0d1b1"
SRC_URI[deb0.sha512sum] = "8949de9784758bc20bb8f16c628009d193703ff09b9a5a4598ae081dd1c32ed87eb957a46ea257ddea1a4158eb738df60ecc1a4d22d963f1e2453cbd85f30cb8"
SRC_URI[deb1.md5sum] = "c83ffc479feccec17c9b83dd41740b3a"
SRC_URI[deb1.sha1sum] = "902751648d8d6134b6a8a8a618ac7a0274bbef62"
SRC_URI[deb1.sha256sum] = "327e3137c7a454a1fcd0eb1369745a94c3170dc075ff9d0d438d9470526ee298"
SRC_URI[deb1.sha512sum] = "21adc8edb4cdb1f67899238bac1c2de1b9b3aa83f2d1e0e26789fbe7da79bd532993a26885826b733961641566752ce2cb360cdc941b734ecbd970bd38e7e829"

RDEPENDS = " \
    libc6 \
"

