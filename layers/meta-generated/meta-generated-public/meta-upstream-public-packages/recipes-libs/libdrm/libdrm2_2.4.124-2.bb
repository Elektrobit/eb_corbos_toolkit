# This was autogenerated! Do not modify
SUMMARY = "Userspace interface to kernel DRM services -- runtime"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libdrm"
HOMEPAGE = "https://gitlab.freedesktop.org/mesa/drm/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libd/libdrm/libdrm2_2.4.124-2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libd/libdrm/libdrm2_2.4.124-2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "f5b2af6ff63fe9260f7765a20920c3db"
SRC_URI[deb0.sha1sum] = "b4e7c68564b379e90a1e1de1f6c3d3c79de48a63"
SRC_URI[deb0.sha256sum] = "fe2276901c7cd7b8079de63072d37fe1cbeb4eb001a3bc1f1d662ad89aa0890e"
SRC_URI[deb0.sha512sum] = "02f32fcf9887bbaa7645942e116ff060892c3cc04a24c82c3e47e825e922660a1aef28e50c2179f904d02cc2a61df5973eb871b536267d8f46b0d6184cfb6a27"
SRC_URI[deb1.md5sum] = "865c5aa834e64c87909c4cc6432c6c83"
SRC_URI[deb1.sha1sum] = "2c296be5aea149cff0b8c1c13e3bf2e450e7b12f"
SRC_URI[deb1.sha256sum] = "b535506630bb6a9a616bc07caf3b29915f980d8c3437852fb96ea64fb1a8a3f8"
SRC_URI[deb1.sha512sum] = "d0c06d039719ca69058c6c058c78b012e0a9bd81a6267840696cf55fa4a4e567315a1eb1b6f4b403f0e66cb25e549c1d2605c71314917616944ef23defd2fe1d"

RDEPENDS = " \
    libc6 \
    libdrm-common \
"

