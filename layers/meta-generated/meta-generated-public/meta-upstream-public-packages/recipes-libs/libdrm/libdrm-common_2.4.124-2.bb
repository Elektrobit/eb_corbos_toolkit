# This was autogenerated! Do not modify
SUMMARY = "Userspace interface to kernel DRM services -- common files"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libdrm"
HOMEPAGE = "https://gitlab.freedesktop.org/mesa/drm/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libd/libdrm/libdrm-common_2.4.124-2_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "d88988b4eefb036b42c8e3fa8afa74b6"
SRC_URI[deb0.sha1sum] = "5a21cf65f58fc1ae3043de814e1d58427185d892"
SRC_URI[deb0.sha256sum] = "9a8a6c65c165e9964f106fb4ac710959b5d33e0790227e3ab6b27c4742d1254a"
SRC_URI[deb0.sha512sum] = "f015f81085e2621cbdb349a31c63e71d28ec34627993f1dd1b3fd5dae76d8a42627e009e99384d8e25d360e5e5cbc2fef24db2f34cb64ea95d8f26ea051a2a6b"


