# This was autogenerated! Do not modify
SUMMARY = "Userspace interface to amdgpu-specific kernel DRM services -- runtime"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libdrm"
HOMEPAGE = "https://gitlab.freedesktop.org/mesa/drm/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libd/libdrm/libdrm-amdgpu1_2.4.124-2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libd/libdrm/libdrm-amdgpu1_2.4.124-2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "340c0476be782374cc6686b503540145"
SRC_URI[deb0.sha1sum] = "24918a7210e73494377075f867f64677eb4d761d"
SRC_URI[deb0.sha256sum] = "c1d97a5e32e2bc68e833b8abeae026b6306198e87ee4396a7ffecd4779caefbf"
SRC_URI[deb0.sha512sum] = "878a19c50e9ba29cb32b36a4222e3231ad3225b7df79e11ca9d120160bf4e5e4d0da180d4702af7dd58c25325d0be669e4a3ffaa9c0bff48eac8205e8519953d"
SRC_URI[deb1.md5sum] = "de4b8024c570a788e088b9435ffe42f2"
SRC_URI[deb1.sha1sum] = "5b3cbead78f22f4fd4ddd296c77677f5a20b0039"
SRC_URI[deb1.sha256sum] = "e36c72774cc215818b48ee2174c7ad1d9a2bf89a09cdee7a7a128d288d8eef43"
SRC_URI[deb1.sha512sum] = "e6a557d02fc4206f6a54b20f80b058312e348e0bafe8c722fd6832b362506342e5af28e9e065ab6dbdf7d5a1dde1fc1f0c5fc056631058c4ce5fbc8eeb8b20f9"

RDEPENDS = " \
    libc6 \
    libdrm2 \
"

