# This was autogenerated! Do not modify
SUMMARY = "Network communication, cryptography and signaturing library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libsodium"
HOMEPAGE = "https://www.libsodium.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libs/libsodium/libsodium23_1.0.18-1+deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libs/libsodium/libsodium23_1.0.18-1+deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "ffe701bd7c1b211e688db5d340f91304"
SRC_URI[deb0.sha1sum] = "55d9aee0bcd4a96e802ce3bd33f87f981b1b34d4"
SRC_URI[deb0.sha256sum] = "9ff9d97bb7ce3aee7f6e6ec3a785cdbe237454a7b9fd84728121bc4ef2bebebe"
SRC_URI[deb0.sha512sum] = "4184e523d97b6a4d4838da5fadebbfc15068dc9a9e6cde653285c5c4fc67f9fe754cf1b61f910d3d3350d90324d385bc1fa4df277b209b7f0fbe9917bbefdc15"
SRC_URI[deb1.md5sum] = "207a64f494b466893fb011fbd788abc6"
SRC_URI[deb1.sha1sum] = "283449abed3611000399635e3d5dc333b29c4c08"
SRC_URI[deb1.sha256sum] = "d94fc46204b65a965e356ebc19f9f88aeb20a9c777cb9a6569e75f75d0ae5523"
SRC_URI[deb1.sha512sum] = "f350645941ce97b77269c087e4748da7b4d29f78df9795b28aeff1255d9eb91bc452ab235faf33cd1750935007c44f6dfb8efa51280c842c2fe6f3515b61211e"

RDEPENDS = " \
    libc6 \
"

