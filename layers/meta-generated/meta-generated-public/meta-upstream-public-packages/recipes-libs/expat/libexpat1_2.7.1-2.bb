# This was autogenerated! Do not modify
SUMMARY = "XML parsing C library - runtime library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "expat"
HOMEPAGE = "https://libexpat.github.io/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/e/expat/libexpat1_2.7.1-2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/e/expat/libexpat1_2.7.1-2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "f679d79b2aaecfcb335274627a04960c"
SRC_URI[deb0.sha1sum] = "2df60d569f5ba6703427c701e3707c04cd958a03"
SRC_URI[deb0.sha256sum] = "f875f56675be5b074da877f9a93b09d47dc2eb4e679951d36e2943b8d4843344"
SRC_URI[deb0.sha512sum] = "5a6b30b56f7db6ea676a71f0c4c789bfc0786f384762ee10d3f89e4a628f0d78561f02dcaaaefd5247d6db0490221f64a65f4c7777104aa69b7327c42073550c"
SRC_URI[deb1.md5sum] = "61919628ab2df023ea17f837470b7a0b"
SRC_URI[deb1.sha1sum] = "48585a6c3fab8508da2a2702d18a16f3c605b9ab"
SRC_URI[deb1.sha256sum] = "7f6868227f4893a11123e43b9ed291950b550c7dc209905b2fb871c74678d1bf"
SRC_URI[deb1.sha512sum] = "5783aca472bae39365268e1f781e90a4d5db143a9054baf667596f783e0bdfaf41ac0dc154b5725710d9791d1fe9d5c5fd8c687faa67e025b2df37939100549f"

RDEPENDS = " \
    libc6 \
"

