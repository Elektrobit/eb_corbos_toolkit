# This was autogenerated! Do not modify
SUMMARY = "Speech recognition tool - front-end library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "pocketsphinx"
HOMEPAGE = "http://cmusphinx.sourceforge.net/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/pocketsphinx/libpocketsphinx3_0.8+5prealpha+1-15+b4_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/pocketsphinx/libpocketsphinx3_0.8+5prealpha+1-15+b4_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "f023b10254b79dd53919f90452a25d3e"
SRC_URI[deb0.sha1sum] = "5ae1289c4642d11c5eaddd2314a99bf177db61d8"
SRC_URI[deb0.sha256sum] = "b2c444a2f9b7456fa804f672c0d7849a33d857f5a1de7710b02355721cfd2750"
SRC_URI[deb0.sha512sum] = "eaa956e1d0fe3d5feb2788b719594311c56e9f85087e78b78b67c07d5b47adc514442d62fb9ae9cb627c2d0f488fd76e8ca1e5d92bb2bc6f26916c495bdda113"
SRC_URI[deb1.md5sum] = "93e11e700794c49e07d4fab89dc9e7c7"
SRC_URI[deb1.sha1sum] = "b14fb1fbcebdc0c2988377fb140777fedde7d706"
SRC_URI[deb1.sha256sum] = "d0a2b514f8859912fc09d7cd39a80f3c1359d5172535cece37df2f4f124fc911"
SRC_URI[deb1.sha512sum] = "30289a605fec6abcefa9d6c71ce72e5e2eb7d361cc091715084c53e3a88aeea1aadb4ff95b7946a2f11e880ec64e48dd94c0d46036aa23bbd31dc431a88d411c"

RDEPENDS = " \
    libc6 \
    libsphinxbase3t64 \
"

