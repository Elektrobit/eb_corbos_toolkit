# This was autogenerated! Do not modify
SUMMARY = "Middleware to access a smart card using PC/SC (library)"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "pcsc-lite"
HOMEPAGE = "https://pcsclite.apdu.fr/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/pcsc-lite/libpcsclite1_2.3.3-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/pcsc-lite/libpcsclite1_2.3.3-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "07cafecd36cffb43686530c1a9a520e9"
SRC_URI[deb0.sha1sum] = "9a6f5ce0ffe9e2c4326074146c4e9998d023d070"
SRC_URI[deb0.sha256sum] = "a8bc4725549060d1e696d358e32a3699d947d5381871553a290389830bebccbd"
SRC_URI[deb0.sha512sum] = "de0cd0e62d44a510749d79047e0396fb37513852187c0a527d1cd6614e3cf9cdfc52a8a8367152e98dfed63b47dcb8e29d2fda000469c5fe527e92cac5866d93"
SRC_URI[deb1.md5sum] = "9c51f27a48293426a55737415f9de176"
SRC_URI[deb1.sha1sum] = "edb87a6fef139bd3dd05211b89a93700d9ff4a93"
SRC_URI[deb1.sha256sum] = "e406cfd8f918cbe868c14a9d0dfbc0967f98861e679bcb0f30df6a49d80936f1"
SRC_URI[deb1.sha512sum] = "b647a3ced505845ab7f27083282b8deb1488451698e4358e327e3e4a566c2a4d18e84bf2c11b9c8b704d67a3364a31fa9394740856819bda76c295da21228f87"

RDEPENDS = " \
    libc6 \
"

