# This was autogenerated! Do not modify
SUMMARY = "Bauer stereophonic-to-binaural DSP library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libbs2b"
HOMEPAGE = "https://bs2b.sourceforge.net/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libb/libbs2b/libbs2b0_3.1.0+dfsg-8+b1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libb/libbs2b/libbs2b0_3.1.0+dfsg-8+b1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "af8edc2289f87be92a38b77d9935383c"
SRC_URI[deb0.sha1sum] = "3a3fc01ea9a246d3ebe37a1fd9125cbfba72c560"
SRC_URI[deb0.sha256sum] = "683621e230de5d9cb919f6c6c3a18db4eb7b80706761b983a4a8f2a56747351d"
SRC_URI[deb0.sha512sum] = "b76723e3842eb3e9a0b4b66d0c68779b4aa660693a4e1547622aca85a2246fe5433bf31e7a4c496145e7de805a2a9f335a7d3f83eba1c39c7a8a62f264849944"
SRC_URI[deb1.md5sum] = "91f549fc2ac9e56913385dc78e92dd2a"
SRC_URI[deb1.sha1sum] = "298556222cefe3351a9c818d569dca3bb85b4e7e"
SRC_URI[deb1.sha256sum] = "6041677fd23ee86179348846e058b40c4c8dbdd7ace50d772a4e5b56a80b08db"
SRC_URI[deb1.sha512sum] = "5f0eb392cbdfc2e04bebcd97182a2641e9ebbf6aacee1057efe5b8b14e8bd977de733b75f7676f3669c94c5ca1d110e91c8560b8d9d1905dcf8ec110013cdb44"

RDEPENDS = " \
    libc6 \
    libstdc++6 \
"

