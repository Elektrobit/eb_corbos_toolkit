# This was autogenerated! Do not modify
SUMMARY = "disk partition manipulator - shared library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "parted"
HOMEPAGE = "https://www.gnu.org/software/parted"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/parted/libparted2t64_3.6-5_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/parted/libparted2t64_3.6-5_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "49c37739e4ca28488e6d4d31be7280ac"
SRC_URI[deb0.sha1sum] = "8d62ebd30331c07c080e878f807f35f2b4dc63fa"
SRC_URI[deb0.sha256sum] = "65bc42f046f51f01152da1c6b48f7b65d2e84bc0b04c0da29c33bded87217a36"
SRC_URI[deb0.sha512sum] = "4f487adee404d4fbc9ae3f8a93caac72192da26e5dd04fcf73f93f945f8a626f69654f25426cea67fd74fa9e79e7b0ebd31cc3e2cf47dc143e1d4d04b519d55c"
SRC_URI[deb1.md5sum] = "19e1d806296cd8331a280f3b01cd1038"
SRC_URI[deb1.sha1sum] = "4fe11c56f746e2de04e2fb50a422ba39c853cb5b"
SRC_URI[deb1.sha256sum] = "cc441a27a61a0d7320cc991f147049b12444c6e290277f1a0a5a3fc5942ded63"
SRC_URI[deb1.sha512sum] = "03cbb9ed7992046912ff7beb6aa5cc1b982b0c37ec42463adcd17d8fece99faa552627b4f5e23e5c2d5a328cce2e4d3bcc76d70ec6efed1733b4110358c53397"

RDEPENDS = " \
    libblkid1 \
    libc6 \
    libdevmapper1.02.1 \
    libuuid1 \
"
RDEPENDS:append:amd64 = " \
    dmidecode \
"

RPROVIDES = " \
    libparted \
    libparted2 \
"
