# This was autogenerated! Do not modify
SUMMARY = "package management runtime library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "apt"
HOMEPAGE = ""

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/a/apt/libapt-pkg7.0_3.0.3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/a/apt/libapt-pkg7.0_3.0.3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "89c5af2d5a011714603f09e57a278bd6"
SRC_URI[deb0.sha1sum] = "5f04b97f12e0883a2d8b873bb8944dfa05139f1c"
SRC_URI[deb0.sha256sum] = "fdcc9f780c7de466c7f0038e6e242c73cb63c8f9fe2781a3185a2c810984ab0a"
SRC_URI[deb0.sha512sum] = "b6da5a438c483ded6685d1d23f24ccd3ab5abc6a9971a4c8963a1a8f4f79ae4535420b25548fed25bb3a5100ed9b930e966e3ceed5b22a2d325a60a23b04363a"
SRC_URI[deb1.md5sum] = "4a0492db883585ee6729796b4c4a6e64"
SRC_URI[deb1.sha1sum] = "44d66819a8f8e07abbba11cae8a8802bc3ff2a1f"
SRC_URI[deb1.sha256sum] = "c5aea30677a9c7a56edc92fcba3361f5e8cb31d5cdfedf72fc9d8e4fba150bda"
SRC_URI[deb1.sha512sum] = "655cf1f9c416029dd6c1ebf36812cce88a42cb9c3f3b45e7e079c261151ebcc8b58aa6f975f9fa2ec286dc27c4dcf8e4b8f9c7aa909adbe6f6d926ce1f81bc8f"

RDEPENDS = " \
    libbz2-1.0 \
    libc6 \
    libgcc-s1 \
    liblz4-1 \
    liblzma5 \
    libssl3t64 \
    libstdc++6 \
    libsystemd0 \
    libudev1 \
    libxxhash0 \
    libzstd1 \
    zlib1g \
"

RPROVIDES = " \
    libapt-pkg \
"
