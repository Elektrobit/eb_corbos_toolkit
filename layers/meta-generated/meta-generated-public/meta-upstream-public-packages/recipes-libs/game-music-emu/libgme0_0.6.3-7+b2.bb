# This was autogenerated! Do not modify
SUMMARY = "Playback library for video game music files - shared library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "game-music-emu"
HOMEPAGE = "https://github.com/libgme/game-music-emu"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/game-music-emu/libgme0_0.6.3-7+b2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/game-music-emu/libgme0_0.6.3-7+b2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "f553a6ad300a108a6b5c3f1dae02f3be"
SRC_URI[deb0.sha1sum] = "be02b53cd405120a76f3dd14c22a940a290fe8ec"
SRC_URI[deb0.sha256sum] = "fbcef23f20099dd7b88a3d9edb79482359b2ab845632acb929313df7d2c5b6b7"
SRC_URI[deb0.sha512sum] = "94545ea8eedfdc8037366f08fb07cd64c794778972088c4737e552a7c56dd09a0d62c15494f1f86a55028af0549d4307b1b2e2400ddce27c7c605f6291cfe950"
SRC_URI[deb1.md5sum] = "bd29b6797d7fefe2e8dd967d61d70289"
SRC_URI[deb1.sha1sum] = "275cb8dc23fd91c36ef060517dc692a6292478bc"
SRC_URI[deb1.sha256sum] = "800d180f08f676cfad4db078c10e0b304dc54d62c05a7f32d79896879a0a3eaf"
SRC_URI[deb1.sha512sum] = "9b5d4de90a2523960a41758df8e848204d69cc65ab134c19c73c05baebc488c8dd87350eed480b5fc47b2a33b9430a91e7f5a3f80198cc261749ba10b0c99682"

RDEPENDS = " \
    libc6 \
    libgcc-s1 \
    libstdc++6 \
    zlib1g \
"

