# This was autogenerated! Do not modify
SUMMARY = "Limited Error Raster Compression library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "lerc"
HOMEPAGE = "https://github.com/Esri/lerc"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/l/lerc/liblerc4_4.0.0+ds-5_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/l/lerc/liblerc4_4.0.0+ds-5_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "8c5933a75125eed15b466c16bf201bfa"
SRC_URI[deb0.sha1sum] = "ea9db04001b6b65ec9d11b4696f6548855902801"
SRC_URI[deb0.sha256sum] = "2e0c13c0ddbde12968c2c713c2e0474a5b78e90d5216031256a725e8c76aa31c"
SRC_URI[deb0.sha512sum] = "246bf35107de64260269069263a87935c8e210b3c5b10cb454862f18a49594f4b2674bd61cc41acbdb95c7dca2f33a092b432ab874ce483bc52d926f2cce822b"
SRC_URI[deb1.md5sum] = "376e38e3d65123d30d3212d4463bced9"
SRC_URI[deb1.sha1sum] = "13f6bbea5eb49960b69f605fc29e7a479015d6f8"
SRC_URI[deb1.sha256sum] = "db015dc1888371e490594f8aaaaa55356313478d744fa69e242e034e4c2a0019"
SRC_URI[deb1.sha512sum] = "be0c2030834eaa194d46796ef4ebf5e11e2e44073a695434810c21542d8ec555765e26e10fc8500f57f9af37fddbb20b3d1bfb0486704f929c94fd37503792a3"

RDEPENDS = " \
    libc6 \
    libgcc-s1 \
    libstdc++6 \
"

