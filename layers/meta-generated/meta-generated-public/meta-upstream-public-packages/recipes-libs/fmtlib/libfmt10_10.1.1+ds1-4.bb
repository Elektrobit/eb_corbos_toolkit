# This was autogenerated! Do not modify
SUMMARY = "fast type-safe C++ formatting library -- library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "fmtlib"
HOMEPAGE = "https://fmt.dev/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/f/fmtlib/libfmt10_10.1.1+ds1-4_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/f/fmtlib/libfmt10_10.1.1+ds1-4_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "720eb7be6fa41d60d79a5b26970f131d"
SRC_URI[deb0.sha1sum] = "ea0a2ba6ecf8dcce23444835afef0bdff2c1e765"
SRC_URI[deb0.sha256sum] = "da77a5254e5c7cdac6ecf6f8f21a9cc93d64392765f0f0a4dd06805238950fbe"
SRC_URI[deb0.sha512sum] = "0fa631802cb35a5e50bca4e75fdf1340b61f7d3b5284edaf7042c4dbfa35ee744581fbddffd37ec62839a341c31aa25e62a06ef18619c86ab957cc8a5f3053e8"
SRC_URI[deb1.md5sum] = "b928474ea5a9b178516564cdcc62b662"
SRC_URI[deb1.sha1sum] = "cb3857e5e72420728c2639a496e95e13abc42d20"
SRC_URI[deb1.sha256sum] = "e10e3f745fb3cb517f67c76fe4ed8476e6efb4ab28a8e8640e4e6d634bdb8ae0"
SRC_URI[deb1.sha512sum] = "0ee95b9e266110e783fa614c8d9291f5c2c530af381e3ef94712a995ccffbb00f86722e1a8dd1fdcdf6efeb4575ec1c8c9160922ae3bda87a9e731a09dd636ac"

RDEPENDS = " \
    libc6 \
    libgcc-s1 \
    libstdc++6 \
"

