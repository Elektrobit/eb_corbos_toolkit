# This was autogenerated! Do not modify
SUMMARY = "Fast YAML 1.1 parser and emitter library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libyaml"
HOMEPAGE = "https://github.com/yaml/libyaml"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/liby/libyaml/libyaml-0-2_0.2.5-2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/liby/libyaml/libyaml-0-2_0.2.5-2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "b8d54b7fe92f5376c0239d8e7f53e15a"
SRC_URI[deb0.sha1sum] = "cbe72701c2d6caa42cfde3c69572782e4f9494b9"
SRC_URI[deb0.sha256sum] = "8a5475402801de445a17887bb72d03613565a6a84b216b4b606d1462c613eeb2"
SRC_URI[deb0.sha512sum] = "ec2f69a3723621fffd82229106e62c78c284e6df09710dfa71cc89038f8e254456512ff6f189a5d17a9b1ed7a9c14e8d01b990f3b32a046fc17657c1c3b7c5f2"
SRC_URI[deb1.md5sum] = "84b665abc1bbc1450b803780589aa5d9"
SRC_URI[deb1.sha1sum] = "e9938f6d799596cd5b79fc0a93377008a9832b3f"
SRC_URI[deb1.sha256sum] = "c81500b4c93e29ac28cdded7ec5bf9950c75f8c76c386669ccb6fb854c4daf72"
SRC_URI[deb1.sha512sum] = "c15b17b83b9d891f06397b619d484361525909a344c30211285cf02aa690b487e4efc90a718f884fb9690521589f97aec0270b603a6228d43475afbbefb806b5"

RDEPENDS = " \
    libc6 \
"

