# This was autogenerated! Do not modify
SUMMARY = "implementation of QUIC protocol (library)"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "ngtcp2"
HOMEPAGE = "https://github.com/ngtcp2/ngtcp2"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/n/ngtcp2/libngtcp2-crypto-gnutls8_1.11.0-1+deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/n/ngtcp2/libngtcp2-crypto-gnutls8_1.11.0-1+deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "085da7b6511e5afdbbd1b33f59054431"
SRC_URI[deb0.sha1sum] = "642615b7c2c977036458b9e257947cc298d9b175"
SRC_URI[deb0.sha256sum] = "2a7f109c0c4db6a800e4661c5e5e34e1f1f83c8162482276183d1ada9da7c96c"
SRC_URI[deb0.sha512sum] = "d2816f9f80fd582afc3ece074b5252a79e4ddc832040aebea414644445e8f38665b9d730ea59ac5a58d558b4c44778d6f807c64d05fc26a76fb887e459ebfbba"
SRC_URI[deb1.md5sum] = "eebc61326d91d51f2095f77059f897e0"
SRC_URI[deb1.sha1sum] = "539d1b5f14b55b28ae8030af641d12bbda6cf1c5"
SRC_URI[deb1.sha256sum] = "4a220245385ec7222f4a20e444532808b90139b70ea9c7eeab179c927a27b37f"
SRC_URI[deb1.sha512sum] = "4c1bdc335341984c8dab973e827ce11e8599b28fa62c154053d0766d209eb96bcff5005ab3dc2ad47c8ddfeb61978dbe13b7126f21a6cd64475521f3b00f899c"

RDEPENDS = " \
    libc6 \
    libgnutls30t64 \
    libngtcp2-16 \
"

