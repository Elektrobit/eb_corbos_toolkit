# This was autogenerated! Do not modify
SUMMARY = "implementation of QUIC protocol (library)"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "ngtcp2"
HOMEPAGE = "https://github.com/ngtcp2/ngtcp2"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/n/ngtcp2/libngtcp2-16_1.11.0-1+deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/n/ngtcp2/libngtcp2-16_1.11.0-1+deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "73c7dc70b69796219facc3d77a092303"
SRC_URI[deb0.sha1sum] = "b75b9fa17e2bac433138f8253172c92e2597cd04"
SRC_URI[deb0.sha256sum] = "627eec81ebbd48c4e6091f5cd9dc5070b792b7075000eed60ab08c7daa961caf"
SRC_URI[deb0.sha512sum] = "acf3b41b80a252dfe14c38c822b36b5c3427b82914d4c99c1c54d32268bf0a5dcce6e6d843ae9fc7e6aede3bd89374dfb1a96c4ffa6a0250e34702bc368f2bc9"
SRC_URI[deb1.md5sum] = "60f866276eac1567e5bf14c0052a9655"
SRC_URI[deb1.sha1sum] = "79d29d59be9e30362dd49dc5d476bb052947ff52"
SRC_URI[deb1.sha256sum] = "1ced2874229e4a503060c244730baf75e61b1d5444472b10e5022f1594f4ab88"
SRC_URI[deb1.sha512sum] = "3b1facac6e04f42f904d5af5796c768a0f68e7f78bd56abde2e1667df5056532f786d5a4f49a30c18895ab33ef1985bb810eed7bcbcae7ccdfbb9355e14d2570"

RDEPENDS = " \
    libc6 \
"

