# This was autogenerated! Do not modify
SUMMARY = "Universally Unique ID library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "util-linux"
HOMEPAGE = "https://github.com/util-linux/util-linux"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/u/util-linux/libuuid1_2.41-5_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/u/util-linux/libuuid1_2.41-5_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "73c71627ecada7d8e92822bfff16a7c5"
SRC_URI[deb0.sha1sum] = "69561687e45ee4833a59400e51976ff05cf71c0d"
SRC_URI[deb0.sha256sum] = "10247744737c1bb574f9667b3f06a3b43a5055c67bdfcc1945803451cc036db3"
SRC_URI[deb0.sha512sum] = "9384120452c3242e474c743bce55bca35379404c351632db3e585558320719a7cb948c164b99b15e4b5827d74a5ada8af0ab5803acd28972d6871213a607e34f"
SRC_URI[deb1.md5sum] = "b7f253331894ce1e6919c54f54f43452"
SRC_URI[deb1.sha1sum] = "0cc7ca3341253904256e5dc4296786ce151e51eb"
SRC_URI[deb1.sha256sum] = "85b7d04605f9d423d5699b3c07f027e8380649fd164a51e0712cded0cc56eced"
SRC_URI[deb1.sha512sum] = "85c0d268bc14db767d0d00bb4978ab994eedd93cb5824740a1c0da8d48f7565a4f639039de8b5c8176349cd333897f1b43a378ada18cc494f789d2c926cc9f51"

RDEPENDS = " \
    libc6 \
"

RPROVIDES = " \
    libuuid1t64 \
"
