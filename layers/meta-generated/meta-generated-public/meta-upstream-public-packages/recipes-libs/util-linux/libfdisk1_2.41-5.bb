# This was autogenerated! Do not modify
SUMMARY = "fdisk partitioning library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "util-linux"
HOMEPAGE = "https://github.com/util-linux/util-linux"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/u/util-linux/libfdisk1_2.41-5_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/u/util-linux/libfdisk1_2.41-5_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "d48faa12facb26ab3bcbb11b137b88a7"
SRC_URI[deb0.sha1sum] = "331f434ebc38096e46e9e7fb1cf243e6469137b5"
SRC_URI[deb0.sha256sum] = "e0af64cd4197cb87b6801d28d3edd24474e8db6b20a89f4e6216f56a5c1830f5"
SRC_URI[deb0.sha512sum] = "427ef76d0f37daa7233235d07b4f9a53ed15e13f242a0d5222be918d0137e1dc72d85e71d89d9a25cf20e652b08a3c1c3a54b2fcfc78a99da6f3aeed19567893"
SRC_URI[deb1.md5sum] = "04c49dcd45d6e8655b8919109ad4b792"
SRC_URI[deb1.sha1sum] = "7fc6fac63e4715024e0bb85af9aea3605dc5d6b8"
SRC_URI[deb1.sha256sum] = "7c6ee5055072037933040b78dc38d0b5932faed393a421637f6d528d0940f4a6"
SRC_URI[deb1.sha512sum] = "1dabb3c65c812a2d0d297c75f65415b042caf6c9eda76b54a5ff5ba10055ad68f5098f91c6d641c9076ff4c47a65d7ededbee4c28e10d672068d6b46c1325702"

RDEPENDS = " \
    libblkid1 \
    libc6 \
    libuuid1 \
"

