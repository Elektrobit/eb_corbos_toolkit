# This was autogenerated! Do not modify
SUMMARY = "smart column output alignment library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "util-linux"
HOMEPAGE = "https://github.com/util-linux/util-linux"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/u/util-linux/libsmartcols1_2.41-5_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/u/util-linux/libsmartcols1_2.41-5_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "9e4fd35089ee273d8a7d5ea61d829ae8"
SRC_URI[deb0.sha1sum] = "7d770da5d5618391bd3e0d7faa03d1ece944a393"
SRC_URI[deb0.sha256sum] = "22ac8bd618c11827e69d710da8b663e07777d3b09969bda0adb968c886e51a97"
SRC_URI[deb0.sha512sum] = "83175fe4de6aa49cfd3db77909ec2f390dc038ba022229f4f11c7398172081ce0975d58c64722c5fd5bc20856a420d01a6f4d4a560e75ee8ed73dfc691e0c194"
SRC_URI[deb1.md5sum] = "1d499c4a8e535f70a12df2c8c8f0fff9"
SRC_URI[deb1.sha1sum] = "5dcd0bf891959358babecefd28126626b3e9d83c"
SRC_URI[deb1.sha256sum] = "ac0ae538118235b83de86121454488336a26767b612a34c2d387595cae3936e6"
SRC_URI[deb1.sha512sum] = "c550424ed66f2a0d501f2440e828cf9d30f2282f09b8e06cfc4ca818aae877fdbd4900e79c4a2044be1cf4013b98ac2a884fc6b2b93bb1a8fda7df8d05d46bfb"

RDEPENDS = " \
    libc6 \
"

