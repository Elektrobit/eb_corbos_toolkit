# This was autogenerated! Do not modify
SUMMARY = "block device ID library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "util-linux"
HOMEPAGE = "https://github.com/util-linux/util-linux"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/u/util-linux/libblkid1_2.41-5_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/u/util-linux/libblkid1_2.41-5_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "6a0e6883dbc760764b821f3535eace8b"
SRC_URI[deb0.sha1sum] = "8413cb58799327072dd69a418e41fc05009cfd03"
SRC_URI[deb0.sha256sum] = "bed93f11942524e5338074c46cce376197740635bf0745ccb7d259e0f6ce7117"
SRC_URI[deb0.sha512sum] = "167d769278cb7722e972e6668bdfa9cd2e21ee45f6b34ac008c5027554caeaa3845cd56a0b249b24ebf03db49b154ddd779e8034f2c2dd1395938e5d4948eb97"
SRC_URI[deb1.md5sum] = "ed547c662079b0fa36ab72a9be20b2d0"
SRC_URI[deb1.sha1sum] = "4bb119d7bbfef4763bc98c3f3e117d43d2a82dc7"
SRC_URI[deb1.sha256sum] = "ee91c24cc227ed977c39d746d09532d357e66f147bd670be6cb69e2c3435cf76"
SRC_URI[deb1.sha512sum] = "219f6ee4eb514210f46e01cbf08a12691309f193762ea07caf7681df959edd7f8abd7af23a7bcac069f552a0dcab67a463bcae8533062c13fac2b4bdef890ffd"

RDEPENDS = " \
    libc6 \
"

