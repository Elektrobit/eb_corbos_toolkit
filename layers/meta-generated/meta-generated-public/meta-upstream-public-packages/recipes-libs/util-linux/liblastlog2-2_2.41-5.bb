# This was autogenerated! Do not modify
SUMMARY = "lastlog2 database shared library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "util-linux"
HOMEPAGE = "https://github.com/util-linux/util-linux"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/u/util-linux/liblastlog2-2_2.41-5_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/u/util-linux/liblastlog2-2_2.41-5_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "01f2f66a7592d75ae14be519c42ecf89"
SRC_URI[deb0.sha1sum] = "66f318bba3291962b0c2233835a3561dfbc01d95"
SRC_URI[deb0.sha256sum] = "ff6a315b41873de9730b2c1d02b3463e1518f2ea0eb790d72adce8427ce88dd7"
SRC_URI[deb0.sha512sum] = "8324e046a9b3e9d45bc6013d6cc4bc34c0ff99ee7d25d9976f8be02e929d70a5ed7d35303c6a40ff2a44836a257b2f551ad80009bfe74b68811cb87358d719af"
SRC_URI[deb1.md5sum] = "eb1428c138b601230ef5a280c4497985"
SRC_URI[deb1.sha1sum] = "c4429d7358f33d6aa946a453dfb6cf6dfb4185fb"
SRC_URI[deb1.sha256sum] = "2aabc6ee5bcd7867c4da38e8348f4a1ec6ca5ff4f37944dc7b056bd9f45156c7"
SRC_URI[deb1.sha512sum] = "6623e8c335910c7a696cce5399183f06ec4c87cf56ab467edcb01f0f87c9788465ef056502945447836c9e947e78cb6e1c67014bc534fde552b02dc4b790ce04"

RDEPENDS = " \
    libc6 \
    libsqlite3-0 \
"

