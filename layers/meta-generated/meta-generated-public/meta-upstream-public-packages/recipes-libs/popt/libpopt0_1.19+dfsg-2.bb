# This was autogenerated! Do not modify
SUMMARY = "lib for parsing cmdline parameters"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "popt"
HOMEPAGE = "https://github.com/rpm-software-management/popt"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/popt/libpopt0_1.19+dfsg-2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/popt/libpopt0_1.19+dfsg-2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "d6f75bac044cd1ddc1b3496962b3b26d"
SRC_URI[deb0.sha1sum] = "af7136f8681de0761c9694916da46c8def77c4e2"
SRC_URI[deb0.sha256sum] = "07f649b706852af937654295697dcfc7858f3295718ec18681dce1704663e4f2"
SRC_URI[deb0.sha512sum] = "32198e87a204d797e740bee1a852a477054c35cb8455d09b6ad97b54b8793bd393d8031d7018d9781456f2651a52929612d2067fcea7090e3f706730fcc44e50"
SRC_URI[deb1.md5sum] = "9dc603b0e5c4f27efe580b301db7acdf"
SRC_URI[deb1.sha1sum] = "04d5f69509a67672119c38f562295bfd742887f3"
SRC_URI[deb1.sha256sum] = "b58ba178effc24280c4c6be3cf2c93a34607e18ad76b2f74b2de818136699076"
SRC_URI[deb1.sha512sum] = "6e1df1477423a8457e6c3c4697e7df77f3e406e55850789b9fdefdb929c2264bcead1a813a939f677ae8cffd07d4fcdbabcedd80a47aeb44e52aeafc8d05bd34"

RDEPENDS = " \
    libc6 \
"

