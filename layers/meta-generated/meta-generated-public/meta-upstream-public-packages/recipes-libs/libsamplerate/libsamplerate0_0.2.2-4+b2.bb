# This was autogenerated! Do not modify
SUMMARY = "Audio sample rate conversion library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libsamplerate"
HOMEPAGE = "https://libsndfile.github.io/libsamplerate/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libs/libsamplerate/libsamplerate0_0.2.2-4+b2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libs/libsamplerate/libsamplerate0_0.2.2-4+b2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "a469c5c19f43bfc2e150f2039fa5563f"
SRC_URI[deb0.sha1sum] = "4f7be9dc412f03bb8cfdfca9a435455e5968511d"
SRC_URI[deb0.sha256sum] = "2665417fa996c1e249dbaa65c32305ac666e5ae865fad0f109b629935ec0bd18"
SRC_URI[deb0.sha512sum] = "83fd53ef907be337461a18b120d50e330cca0b0976cc0efd684bf696b8f8eac36eb57ce0a42e5f9df6561e4f880089ee31718b8574090545869e3101410594cf"
SRC_URI[deb1.md5sum] = "d78568571fc5f6ea82da6abb4ffb0875"
SRC_URI[deb1.sha1sum] = "f038b5c381515414e765771f6eeab4d54d158daa"
SRC_URI[deb1.sha256sum] = "5d9fad694b249d48d8457e1242ab60e04db6a30d7d56f80c6ae463ff122147ec"
SRC_URI[deb1.sha512sum] = "2030a3e43e341fd89ae63374de2a05bac200df4ae75e01f769c719e9257c723f036560da5fd4557325c44d655b7fcde73f8739239cb416397696c4ba634cb1e9"

RDEPENDS = " \
    libc6 \
"

