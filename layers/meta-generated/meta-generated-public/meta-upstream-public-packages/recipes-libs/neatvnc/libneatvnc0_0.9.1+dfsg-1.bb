# This was autogenerated! Do not modify
SUMMARY = "Fast and neat VNC server library (shared library)"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "neatvnc"
HOMEPAGE = "https://github.com/any1/neatvnc/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/n/neatvnc/libneatvnc0_0.9.1+dfsg-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/n/neatvnc/libneatvnc0_0.9.1+dfsg-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "e74bce34a930c097dbe24142d3fdd395"
SRC_URI[deb0.sha1sum] = "5e95d8ba83bccbe97e82dfd881ba072414206dca"
SRC_URI[deb0.sha256sum] = "ac2c8f3f8f44a31d65e19afc7e1a092ec6f32255dbe763c52f7f2b44f0db42d7"
SRC_URI[deb0.sha512sum] = "55d99b81f228e135fdc3e6712efa12d8b1402b513505fdd47c845a56b9a6950bec5564dd6d30598b30ebab0f07cd6c196b38a4cf83e2d4f9fa7fd7379d4e8c6a"
SRC_URI[deb1.md5sum] = "bd21e66a00eadbde42dd66b0d0ab1cb6"
SRC_URI[deb1.sha1sum] = "fb0c47bcb4dfe0a1d537db9c424115ff51ffef1c"
SRC_URI[deb1.sha256sum] = "038fdf94ccadac9c915cbfd795a31c323f3962c42f89f22ab0233a5431449735"
SRC_URI[deb1.sha512sum] = "d7047a0d44ed4b63ca67fdfc3a50f868251800712007b005c527c26b107bd59c8b26f909e50794782375e117b5b36936bc2cf571c2ca26d9cdc280a853f0c0af"

RDEPENDS = " \
    libaml0t64 \
    libavcodec61 \
    libavfilter10 \
    libavutil59 \
    libc6 \
    libdrm2 \
    libgbm1 \
    libgmp10 \
    libgnutls30t64 \
    libhogweed6t64 \
    libnettle8t64 \
    libpixman-1-0 \
    libturbojpeg0 \
    zlib1g \
"

