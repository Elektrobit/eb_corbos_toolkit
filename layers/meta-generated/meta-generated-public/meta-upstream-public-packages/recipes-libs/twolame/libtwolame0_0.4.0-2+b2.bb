# This was autogenerated! Do not modify
SUMMARY = "MPEG Audio Layer 2 encoding library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "twolame"
HOMEPAGE = "http://www.twolame.org"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/t/twolame/libtwolame0_0.4.0-2+b2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/t/twolame/libtwolame0_0.4.0-2+b2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "0267a9a6f9333a439470aad16a36ff81"
SRC_URI[deb0.sha1sum] = "c388bd3688f2f3c7409349a9efafd5079e99b656"
SRC_URI[deb0.sha256sum] = "f3e739c8dd8b7c77043406bb4a4eef16d192e2e0aa5f8d9f39e09ff087844e6d"
SRC_URI[deb0.sha512sum] = "ae16b8899e039f2f0a834338ecc1c31710491548c0b08e170999688d6104a757fc077d9ee7d378470637dea1cbc95758ad4a999570f3c4582551c3303682a398"
SRC_URI[deb1.md5sum] = "a4e57bfe6b6f915c42f71ea2f5700dfd"
SRC_URI[deb1.sha1sum] = "15d254a423b325f2fe56476793b37ecc8ccb3692"
SRC_URI[deb1.sha256sum] = "e83981a1c10e43b09c1b8b6624a2d814b7d0c965f0d9ddf771606feb7cd29b72"
SRC_URI[deb1.sha512sum] = "aa33787d445a5a509d8be477063f3b4cec2f81bb53b2e9d61fa6f4eeaf45c8d01bb4caa5338f66fd374d8f48720a1766dd2d2da9327d1347ed2f5ce2a552e6b9"

RDEPENDS = " \
    libc6 \
"

