# This was autogenerated! Do not modify
SUMMARY = "C interface to the Clang library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "llvm-toolchain-17"
HOMEPAGE = "https://www.llvm.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/l/llvm-toolchain-17/libclang1-17t64_17.0.6-22+b2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/l/llvm-toolchain-17/libclang1-17t64_17.0.6-22+b2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "6c0dcd10fa72c2939ae644e32742df96"
SRC_URI[deb0.sha1sum] = "1c6cbc3056d0f5c8286cdd52f8327f438fb1cdda"
SRC_URI[deb0.sha256sum] = "14d9527b6e2bb50c9707112e0a5cafe145a8e254c17ee27c60f3f5df32952181"
SRC_URI[deb0.sha512sum] = "44bc2d761b309b5365f8d2b331747a8027b1435dcacd14636da5f4d7fcd91cf5902e891795e00e7f7959c8bdd151f5634a7d08ace1b914795c33dc97da742b30"
SRC_URI[deb1.md5sum] = "6ec2cadfee5bda3c2513b64d94246b26"
SRC_URI[deb1.sha1sum] = "2f3baafc51681e01c5ca65b56d82749c5ed8966f"
SRC_URI[deb1.sha256sum] = "2ea42902c862d92663e48a311b9c8372e05c8b4e5ea4e3b47637d3fd92c2e7f3"
SRC_URI[deb1.sha512sum] = "0471db5a3b7dbe14a714bbb8bdba698a6f52ed2c152d4126c4cc059900b1863fd5c4994bd7e588365f6dd336a3e60cdf1707105f27fe8917902a73ae883816c3"

RDEPENDS = " \
    libc6 \
    libllvm17t64 \
    libstdc++6 \
"

RPROVIDES = " \
    libclang1-17 \
"
