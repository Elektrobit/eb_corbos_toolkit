# This was autogenerated! Do not modify
SUMMARY = "C++ interface to the Clang library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "llvm-toolchain-17"
HOMEPAGE = "https://www.llvm.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/l/llvm-toolchain-17/libclang-cpp17t64_17.0.6-22+b2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/l/llvm-toolchain-17/libclang-cpp17t64_17.0.6-22+b2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "26e1ec16bae122739bbda7be1c8ee530"
SRC_URI[deb0.sha1sum] = "16430805bfc60735a547f2c400bde328bc6d1225"
SRC_URI[deb0.sha256sum] = "26fc474890552f298eab10986714fff2556181f667e6f1972822b1367e53b325"
SRC_URI[deb0.sha512sum] = "699f353ac04a36a5b6a8c4e0bbbe007e6ea45ee03c7fa3e3ad61ca2e40a95909c9e731cf4b64b2f1e53c4b08be6d767bcb7d48bef99192890a591225426859ae"
SRC_URI[deb1.md5sum] = "e52c263b26af660c6933cadcff5e7fba"
SRC_URI[deb1.sha1sum] = "a31e28d76885f3516c0968db4e52a918713b826a"
SRC_URI[deb1.sha256sum] = "be53e3f547e3bd76834d9c5e0c3ff5c7766308d0df9d260973b6e0db0dc03fff"
SRC_URI[deb1.sha512sum] = "a51ad343a4c867307d4dfe70de03ead99bfa3d7be2340ccbcdc74e594e08dcd3a022ba1969f8be19918e994c6e2a8646ac5a8b349eeb3ee739079c308bec6e43"

RDEPENDS = " \
    libc6 \
    libllvm17t64 \
    libstdc++6 \
"
RDEPENDS:append:arm64 = " \
    libgcc-s1 \
"

RPROVIDES = " \
    libclang-cpp17 \
"
