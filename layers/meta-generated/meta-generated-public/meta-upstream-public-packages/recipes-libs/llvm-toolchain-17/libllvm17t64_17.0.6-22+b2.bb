# This was autogenerated! Do not modify
SUMMARY = "Modular compiler and toolchain technologies, runtime library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "llvm-toolchain-17"
HOMEPAGE = "https://www.llvm.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/l/llvm-toolchain-17/libllvm17t64_17.0.6-22+b2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/l/llvm-toolchain-17/libllvm17t64_17.0.6-22+b2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "9c18c56d19cab4d2a9645b56927ff16b"
SRC_URI[deb0.sha1sum] = "ba472cbc6c34f727e90deb322ccbdce40b6c1a7c"
SRC_URI[deb0.sha256sum] = "7a17e701bac905cc71df20abc674b4ee1b08af99b43d4c153628f23c907b8ee2"
SRC_URI[deb0.sha512sum] = "0f2619cefb83e8251da42627217d8959aab0a91adfd5749314e5bae8126c8ec0b324a8baf09fd5897ccfe106d11a401fe21dc03e3f34ca4fb269f23326ab7fb3"
SRC_URI[deb1.md5sum] = "d91f84ba4120b7fd6668fc3ab3fd4001"
SRC_URI[deb1.sha1sum] = "14f9aaefe628349738722aa135dc8fc2f000e5ba"
SRC_URI[deb1.sha256sum] = "f75e08ab89a4c2634a0c46661840b387e7977896687dea68493117442e3466bb"
SRC_URI[deb1.sha512sum] = "7f6ef6941430ef70a8bdda47373b89622ba8b1ad9675ba60edeba790e266d03b2058191fa59cb7bea4c319b0e88ada21662005e1aace5581d972669313e7aaac"

RDEPENDS = " \
    libc6 \
    libedit2 \
    libffi8 \
    libgcc-s1 \
    libstdc++6 \
    libtinfo6 \
    libxml2 \
    libz3-4 \
    libzstd1 \
    zlib1g \
"

RPROVIDES = " \
    libllvm17 \
"
