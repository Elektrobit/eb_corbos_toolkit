# This was autogenerated! Do not modify
SUMMARY = "Babeltrace conversion libraries"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "babeltrace"
HOMEPAGE = "https://www.efficios.com/babeltrace"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/b/babeltrace/libbabeltrace1_1.5.11-4+b2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/b/babeltrace/libbabeltrace1_1.5.11-4+b2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "8e4f7ab426a3cf270e8d26d5929662cc"
SRC_URI[deb0.sha1sum] = "115278b5284e99a5e23bcfac00424b3c228a15fb"
SRC_URI[deb0.sha256sum] = "ae7119a21627f296fa28a46ece67b01b1cbc87e32e971f8fd7629d0f42d1d4b1"
SRC_URI[deb0.sha512sum] = "9e89523943dac3ed7155dd01f2f485daccb6706f114d78f1a93a30e2f21ddce2f4ea35622c9276fbb80dfeeef227a78ddbf66b8d4b5e330fd6ec6cfdabc699cc"
SRC_URI[deb1.md5sum] = "4b26bf44c5b9f94c0daa678db7d27b3a"
SRC_URI[deb1.sha1sum] = "a56e342c9cffaab6a77f727aad2a802fbdc063b6"
SRC_URI[deb1.sha256sum] = "464ce803819f55c3368fac02eee326c07b95d3b7686af4c2cf52dbba6860fb02"
SRC_URI[deb1.sha512sum] = "9eb3b33fb681702c219b15ccd4486ee0bac22b25a15a725d68255eb82ea881cd483e63f631fc862ff3d9b7463f3c7de2a93e0a6f719c1cad2331a089a1757db3"

RDEPENDS = " \
    libc6 \
    libdw1t64 \
    libelf1t64 \
    libglib2.0-0t64 \
    libuuid1 \
"

RPROVIDES = " \
    libbabeltrace-ctf1 \
"
