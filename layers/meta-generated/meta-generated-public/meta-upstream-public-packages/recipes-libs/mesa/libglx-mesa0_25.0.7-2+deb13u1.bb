# This was autogenerated! Do not modify
SUMMARY = "free implementation of the OpenGL API -- GLX vendor library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "mesa"
HOMEPAGE = "https://mesa3d.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/m/mesa/libglx-mesa0_25.0.7-2+deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/m/mesa/libglx-mesa0_25.0.7-2+deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "0bb8d66a738463d614a9702e88b5dde9"
SRC_URI[deb0.sha1sum] = "454a8603a19d979ea8fc25808226ad664224193a"
SRC_URI[deb0.sha256sum] = "2e6ab57de9931e890621d3ade04213b06e7142a4ae8a72a1756c44d0271aaeb7"
SRC_URI[deb0.sha512sum] = "928f57d7f45a82915792c69304d34161e01dd902563e959c283c0237a4284fe786eb6a3baf78a21b534445635fb029f146865f3d4bf30d56501b7cb9f8654e2f"
SRC_URI[deb1.md5sum] = "895349960e133181801731081827df85"
SRC_URI[deb1.sha1sum] = "fb18f7469ba293467c78723c3c78b89d9bb4982f"
SRC_URI[deb1.sha256sum] = "18c02afcdd88f547ba66d3ae9290f93ab155381bf8d96b0127f9028374acfc64"
SRC_URI[deb1.sha512sum] = "4e1e39e53375fc5c7121161cb9a8d496f78ffdd78eecebf42d735e16e71e2e909552760ac0bf4b5061d6e4e1ea3236c557685f075190e10c85aea056515d020d"

RDEPENDS = " \
    libc6 \
    libdrm2 \
    libexpat1 \
    libgl1-mesa-dri \
    libx11-6 \
    libx11-xcb1 \
    libxcb-dri3-0 \
    libxcb-glx0 \
    libxcb-present0 \
    libxcb-shm0 \
    libxcb-xfixes0 \
    libxcb1 \
    libxext6 \
    libxxf86vm1 \
    mesa-libgallium \
"

RPROVIDES = " \
    libglx-vendor \
"
