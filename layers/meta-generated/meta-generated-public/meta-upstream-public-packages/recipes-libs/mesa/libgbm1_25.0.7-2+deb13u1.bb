# This was autogenerated! Do not modify
SUMMARY = "generic buffer management API -- runtime"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "mesa"
HOMEPAGE = "https://mesa3d.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/m/mesa/libgbm1_25.0.7-2+deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/m/mesa/libgbm1_25.0.7-2+deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "08fc4af786f5d93877c51babe7134c5f"
SRC_URI[deb0.sha1sum] = "4915e01890c54c787034e3078869073ee9aee146"
SRC_URI[deb0.sha256sum] = "31fb6d76b9ceaf13848fa617df53f85f62626b4fe7464a93811c720af6d5f2dd"
SRC_URI[deb0.sha512sum] = "5230a88fcd0d3fd301e826c07d12ef447547587c2eb07c62b8f396e3ff2752df808548b60be1f6aefb9c2824912753d47d216a85f5e495e7f1a2376b1d731603"
SRC_URI[deb1.md5sum] = "7dfa597a81ff02d43ddc4c22413a7074"
SRC_URI[deb1.sha1sum] = "c43463a42f22adb74f6305bc6cb3de5dd3bbe3c8"
SRC_URI[deb1.sha256sum] = "2beb8d20ca715a01b7b2352c1167c0d7097c9d8a486704a9a966f95d4077cdfc"
SRC_URI[deb1.sha512sum] = "80873b3a75417a852a4e4909e2ab647ba7fb5d7fd2d6a46c13c01370c9966e6f6944ff25b2931a49e504c940c4867daf6c7782bc4d7fea92d5424ad33cb8929a"

RDEPENDS = " \
    libc6 \
    libdrm2 \
    libexpat1 \
    libwayland-server0 \
    mesa-libgallium \
"

