# This was autogenerated! Do not modify
SUMMARY = "shared infrastructure for Mesa drivers"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "mesa"
HOMEPAGE = "https://mesa3d.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/m/mesa/mesa-libgallium_25.0.7-2+deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/m/mesa/mesa-libgallium_25.0.7-2+deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "b0e449b27b77918abfb89d1de90c8cc8"
SRC_URI[deb0.sha1sum] = "db9e693da3dd917f355e19757296971de7d1130a"
SRC_URI[deb0.sha256sum] = "3e610f29321cdcc61337c86e6b4031ff60f0c9915fe19e6a862ac06480620ff4"
SRC_URI[deb0.sha512sum] = "74bc62eb662676edfeb42435046d5d0be98eb83c8c690726c97013162b61c8f8387d105505047f11fd9af9080ca68d555ce4457a6b8f3fd969a214a511b2abbc"
SRC_URI[deb1.md5sum] = "9abc0145cfc5f58574ec8406cf7ce683"
SRC_URI[deb1.sha1sum] = "241fa04930c00780651a6af76cd6ce18128d4032"
SRC_URI[deb1.sha256sum] = "a27576030704ff305adaef8bd143954b281680861d5bfe21aabd7d376a939149"
SRC_URI[deb1.sha512sum] = "4fb12576990a5b4749660fb3f5249b519d27af8f068f71353bdccdddba6761bb44cd77a29aee193591c8bba22f0cb08fd5b12d24e6c70eddce9cc837e7a2468c"

RDEPENDS = " \
    libc6 \
    libdrm-amdgpu1 \
    libdrm2 \
    libelf1t64 \
    libexpat1 \
    libgcc-s1 \
    libllvm19 \
    libsensors5 \
    libstdc++6 \
    libx11-xcb1 \
    libxcb-dri3-0 \
    libxcb-present0 \
    libxcb-randr0 \
    libxcb-sync1 \
    libxcb-xfixes0 \
    libxcb1 \
    libxshmfence1 \
    libzstd1 \
    zlib1g \
"
RDEPENDS:append:amd64 = " \
    libdrm-intel1 \
"

RPROVIDES = " \
    libglapi-mesa \
"
