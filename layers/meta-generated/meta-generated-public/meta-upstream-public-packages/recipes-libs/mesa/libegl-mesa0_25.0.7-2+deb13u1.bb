# This was autogenerated! Do not modify
SUMMARY = "free implementation of the EGL API -- Mesa vendor library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "mesa"
HOMEPAGE = "https://mesa3d.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/m/mesa/libegl-mesa0_25.0.7-2+deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/m/mesa/libegl-mesa0_25.0.7-2+deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "613f4ce753ab26afbd05d6e873af131d"
SRC_URI[deb0.sha1sum] = "699e7a2d26666aeae3cdffd8307308816a39184d"
SRC_URI[deb0.sha256sum] = "0ddebd7e91b048aac812611d6bd008343386cb140b51e5e66df74c6b6263be65"
SRC_URI[deb0.sha512sum] = "42fc31c108053d7a0332590ffeb3130381f2dc46e30a33416b30b0766924cb70513af5f7b65436e26c2181b664ce63dc36ca37d63a9ee858f50cdcdd51cab2cc"
SRC_URI[deb1.md5sum] = "4317cdf54d820990eff52e32fe94ee09"
SRC_URI[deb1.sha1sum] = "20d27d5d002ca20067e6176939e312ec090da09c"
SRC_URI[deb1.sha256sum] = "e344e0c87657d91ebfcb059bee3a3c87ba05871e2918079c3f9393665d4472af"
SRC_URI[deb1.sha512sum] = "608a734c2988533986d884c353b2ed377bb1db0df8bf51bf179dcafc5e558f72633697db423413c18267f34f72f213776c9970e53d8b26ea07e13a951ed82c6b"

RDEPENDS = " \
    libc6 \
    libdrm2 \
    libexpat1 \
    libgbm1 \
    libwayland-client0 \
    libwayland-server0 \
    libx11-xcb1 \
    libxcb-dri3-0 \
    libxcb-present0 \
    libxcb-randr0 \
    libxcb-shm0 \
    libxcb-xfixes0 \
    libxcb1 \
    mesa-libgallium \
"
RDEPENDS:append:amd64 = " \
    libgcc-s1 \
"

RPROVIDES = " \
    libegl-vendor \
"
