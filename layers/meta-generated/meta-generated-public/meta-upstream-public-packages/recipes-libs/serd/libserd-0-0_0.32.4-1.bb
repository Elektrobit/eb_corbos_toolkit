# This was autogenerated! Do not modify
SUMMARY = "lightweight RDF syntax library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "serd"
HOMEPAGE = "https://drobilla.net/software/serd.html"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/serd/libserd-0-0_0.32.4-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/serd/libserd-0-0_0.32.4-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "953bef44831407de46eef876202b759e"
SRC_URI[deb0.sha1sum] = "eb5eb2ad7bf81d3940c6c1663f12974d5de528de"
SRC_URI[deb0.sha256sum] = "a2e1097666c09bf2fce41bff40b8d4cfb8c3c419da99fcb746ea175c5d48fcd5"
SRC_URI[deb0.sha512sum] = "50f787abaaf9f2fed49634f2472d6e79ada2c08259aae157cbeea57e2b65f540a16860a6aa2cc1b8685c302e0dabdf20555c7ca9ae338e3e957fc82b19cfa275"
SRC_URI[deb1.md5sum] = "dcb663827b5fa1d2fb3bbd0496403457"
SRC_URI[deb1.sha1sum] = "e74f3f5087fe43ebb79bd26981cd177f174b95e8"
SRC_URI[deb1.sha256sum] = "01205ff5c346ae395ec3066034e151e8100e46f596afc65d9bba7a80cce129ae"
SRC_URI[deb1.sha512sum] = "e395f73e7147658599d9a4e880f7d248a8d555dd803a93e41d25e39c0784b8c7bec7b15930597cee1dfbd069b26cc30a4985d0b79f0ee48ac02a9563f76cf618"

RDEPENDS = " \
    libc6 \
"

