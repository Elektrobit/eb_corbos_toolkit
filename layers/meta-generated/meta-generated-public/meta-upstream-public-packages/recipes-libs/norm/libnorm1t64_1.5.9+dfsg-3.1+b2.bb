# This was autogenerated! Do not modify
SUMMARY = "NACK-Oriented Reliable Multicast (NORM) library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "norm"
HOMEPAGE = "https://www.nrl.navy.mil/itd/ncs/products/norm"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/n/norm/libnorm1t64_1.5.9+dfsg-3.1+b2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/n/norm/libnorm1t64_1.5.9+dfsg-3.1+b2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "4084834ef2ba3516846627f28b0b6183"
SRC_URI[deb0.sha1sum] = "c6f0d0f90311ce461e118ecaf47beb0f7d4620b2"
SRC_URI[deb0.sha256sum] = "cf48143ffa3886224cd0af63a8ecfac6f87177d80e7a053793c8621781b944ea"
SRC_URI[deb0.sha512sum] = "f60021eb9b1ac3d957cb3767cb2bca2119e9247a22ee1e71d84f39f28ee5d6ea00faa719e927b69ab525517e6cc961cd09db5ca0bcdf0515a83a26b09746b203"
SRC_URI[deb1.md5sum] = "3e2bfa7e9fd499eec241c8d6bc3b3e1c"
SRC_URI[deb1.sha1sum] = "8bf6a7f7696694156cecd8142a790b0dcd2d56a4"
SRC_URI[deb1.sha256sum] = "5e814795f4cb6ba23c5bb091ecabe1ef1e3336f128e2bacf0f64ad593f918168"
SRC_URI[deb1.sha512sum] = "f327067f04811b0073ff6e3012977b8045f8c8689d3e6f5d8aca41ad307f663c591d23ee1f22feea3cbd17c6ae780dd62422359868174ceebbcf490951804d8b"

RDEPENDS = " \
    libc6 \
    libgcc-s1 \
    libstdc++6 \
"

RPROVIDES = " \
    libnorm1 \
"
