# This was autogenerated! Do not modify
SUMMARY = "Free Lossless Audio Codec - runtime C library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "flac"
HOMEPAGE = "https://xiph.org/flac/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/f/flac/libflac14_1.5.0+ds-2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/f/flac/libflac14_1.5.0+ds-2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "c28ba8931f9ee1bc8a4ea89ee095195b"
SRC_URI[deb0.sha1sum] = "79e1df6362ec1da5ffacf6316d44bcab7c0bf01c"
SRC_URI[deb0.sha256sum] = "658b9f77d35638caf75dfaea4f6d5cde196104d5662f0776e23d7cc450bd4cb5"
SRC_URI[deb0.sha512sum] = "832eabfb89d713385b53c749af0832472d3eb9becf49b61cb85cf68390f586d94f0383c8479af0e5f66666b36e199cb2476aab9d6246a3ca6456d089527d43b6"
SRC_URI[deb1.md5sum] = "2c6c93ee700a8914eaaf4ffbe2a414fc"
SRC_URI[deb1.sha1sum] = "fa38b7eeb6ad9fb3f087957cd55a8ca56c750684"
SRC_URI[deb1.sha256sum] = "11800827306e56fcbd1a65ea67d9d13126fc02bf87fdfecd35e0f48a145b3c59"
SRC_URI[deb1.sha512sum] = "eccdf35755fcf9d6c70f46accd45d9a721468999a9f0b3aa60ac8dfe5befe37a9f34bb0281e6cc4df53d76a12876f1c68be9ffc89d66b2809eb2fd2d97cf2061"

RDEPENDS = " \
    libc6 \
    libogg0 \
"

