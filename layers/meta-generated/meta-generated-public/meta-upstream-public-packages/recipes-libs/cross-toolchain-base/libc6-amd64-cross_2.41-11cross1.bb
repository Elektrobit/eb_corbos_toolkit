# This was autogenerated! Do not modify
SUMMARY = "GNU C Library: Shared libraries (for cross-compiling)"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "cross-toolchain-base"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/c/cross-toolchain-base/libc6-amd64-cross_2.41-11cross1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "7d8c8d97ae47aefc5d612548331564b7"
SRC_URI[deb0.sha1sum] = "729c46640953cdebc5457982335b2779b0c60a55"
SRC_URI[deb0.sha256sum] = "b0e7cce4eb4029b5f23a67c439f0e13b5b8418be949390fd22ebc67e30a659aa"
SRC_URI[deb0.sha512sum] = "dad30a9a98de26cd2419f02080b8492cd8cad2548b77b8455523b875062b050f5f2b9895ddad3c720cd0ba5be2fe7e9f0c6459c5ceb5ade93a1fdae7b693561e"


RPROVIDES = " \
    libc6-amd64-dcv1 \
"
