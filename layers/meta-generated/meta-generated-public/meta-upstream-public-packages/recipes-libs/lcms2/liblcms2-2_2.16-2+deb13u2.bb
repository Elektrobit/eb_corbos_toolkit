# This was autogenerated! Do not modify
SUMMARY = "Little CMS 2 color management library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "lcms2"
HOMEPAGE = "http://www.littlecms.com/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/l/lcms2/liblcms2-2_2.16-2+deb13u2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/l/lcms2/liblcms2-2_2.16-2+deb13u2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "263113687b91aafa4e934fa16d91291b"
SRC_URI[deb0.sha1sum] = "630d8b123968eed342cef2f8d3f38ad0f4303715"
SRC_URI[deb0.sha256sum] = "32e53c2002ccea8c60c02779bea0ba49ac132fef702988a30d64af79b6617806"
SRC_URI[deb0.sha512sum] = "f3b7ebf31a5a23d09114dbeabf9dcc7156001885a64923a662da431d55ed2f88f48fdc83c1d0089db88bce6053776c7100de00a11f706f1f863c15769e854e66"
SRC_URI[deb1.md5sum] = "928c13c532147b23913f9a050c1f6f77"
SRC_URI[deb1.sha1sum] = "9f15dfc3e0cff9948bb6598f793cc42931095a46"
SRC_URI[deb1.sha256sum] = "6636997fc488327a8d0951a038df6e5178a52b3f5e5cc2386d42655621f5672d"
SRC_URI[deb1.sha512sum] = "93b6011b5cfcedd5548e6ed02ad233de7c0063a803dfe30717373e5efe5fad9b2ebdffaec9b2868fb01adc5e71f5fe36f9b0bd44dac376165d1b0ade411a9b72"

RDEPENDS = " \
    libc6 \
"

