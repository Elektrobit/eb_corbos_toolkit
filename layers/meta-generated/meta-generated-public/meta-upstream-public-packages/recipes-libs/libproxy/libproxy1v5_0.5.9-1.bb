# This was autogenerated! Do not modify
SUMMARY = "automatic proxy configuration management library (shared)"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libproxy"
HOMEPAGE = "https://libproxy.github.io/libproxy/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libp/libproxy/libproxy1v5_0.5.9-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libp/libproxy/libproxy1v5_0.5.9-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "0ac8329cfa8d53f2002fbf50206f784f"
SRC_URI[deb0.sha1sum] = "ada141da86043c77550ea4b9cf661adcabf1aa69"
SRC_URI[deb0.sha256sum] = "794a8526989464cb17f1dec9dab921f0e5afb82bcc665e938fac925be47698eb"
SRC_URI[deb0.sha512sum] = "55a6315c5f75da4a328504a07d8ac23b6fce58cb496374e0834829cc81f387075951ac932718edf6a7cc8807912e6224baf5b0a2b9a087910e17eb9ffbffdaf8"
SRC_URI[deb1.md5sum] = "234a54feaddaaaacaaebcf90ebc0f73e"
SRC_URI[deb1.sha1sum] = "e11c58fd501190e6a80ae4a5b7a7a47ec476c507"
SRC_URI[deb1.sha256sum] = "7758242ac0263b1fcefc01622160c6a965a25d7f284ee6a62a46a8784cfedd6e"
SRC_URI[deb1.sha512sum] = "c0d1b6823948d11ff10ecb22f0792ccb7ca80b092cc3a4fb38915d6bba2d932054a585c2e52d35dcb941514cf0b71707dd67beff41a73289e667f4a6943082fb"

RDEPENDS = " \
    libc6 \
    libcurl3t64-gnutls \
    libduktape207 \
    libglib2.0-0t64 \
"

