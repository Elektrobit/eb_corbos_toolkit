# This was autogenerated! Do not modify
SUMMARY = "embeddable Javascript engine, library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "duktape"
HOMEPAGE = "https://duktape.org"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/d/duktape/libduktape207_2.7.0-2+b2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/d/duktape/libduktape207_2.7.0-2+b2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "18602197c00402c6e59baec9d6c1e6b4"
SRC_URI[deb0.sha1sum] = "4ae7e9c8b93c7c6e5bcdafd6be65ce2ef1dc3d94"
SRC_URI[deb0.sha256sum] = "2d92606f49cf79e23fb4ea67ab7702d52e016a671d32edc51482c4f1e3bade7c"
SRC_URI[deb0.sha512sum] = "f9843ef08d3b05e93163a413fab31d8181c9c5d255f9e7b25855941fd9e24f09e5f72eb8a6ffbdb6fdeea8f8dc7a6ef21aa8689b4c6537c4c1139dd936ec7e80"
SRC_URI[deb1.md5sum] = "0e19f941a8b31b5e67e9998c31a4ad80"
SRC_URI[deb1.sha1sum] = "046dcb8fad954c2cfac080640136d1e11935167f"
SRC_URI[deb1.sha256sum] = "9dcf4d316a8ece7277d21bbdd26b75a5d7d829faf3c7cfd861e30ba89d385516"
SRC_URI[deb1.sha512sum] = "83902c009432f483a8e4e6262bf35acf0a6636c4be042a6b1de671a7746d9d6f0edf06fa6cca216132c227fa130bd549441d60ab5c8e65020b910ff810982c74"

RDEPENDS = " \
    libc6 \
"

