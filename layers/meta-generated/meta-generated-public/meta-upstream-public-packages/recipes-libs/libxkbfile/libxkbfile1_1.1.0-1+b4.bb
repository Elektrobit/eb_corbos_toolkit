# This was autogenerated! Do not modify
SUMMARY = "X11 keyboard file manipulation library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libxkbfile"
HOMEPAGE = ""

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libx/libxkbfile/libxkbfile1_1.1.0-1+b4_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libx/libxkbfile/libxkbfile1_1.1.0-1+b4_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "3c81c7fcbc1990f19890745829bcdfd7"
SRC_URI[deb0.sha1sum] = "0bdc09ddc7f50a5a3154f973160cec44af43e327"
SRC_URI[deb0.sha256sum] = "989b61e0eb7f1f99d0e969a5957e9a857a95941d5c0e86d5e2b502008b4ac28e"
SRC_URI[deb0.sha512sum] = "0495e07b7199cb2e3519afbe289b5e57a44aaf977a88b80a8de9047a9fb09a036c7bbf7a0e578ab4003088e2e54914c43d5ae911e2b43c03750b0447c72addfc"
SRC_URI[deb1.md5sum] = "286698791df7966e4be83a8c4bcba62e"
SRC_URI[deb1.sha1sum] = "c07a59d96ffe496fb72edd7b6b395cce93f9bc9c"
SRC_URI[deb1.sha256sum] = "b63a122db743b338f65c9d50a15185aa1595f74cdcd42d70e61b48dcf6fd10ce"
SRC_URI[deb1.sha512sum] = "65565dd88f8a1ac03747dc5a76d466effeb41a1d986c8ceb0bf19e3b6495db808d740c62173306701d48081a3978e19225f02f64afd6062a23c5d7aef52f3df7"

RDEPENDS = " \
    libc6 \
    libx11-6 \
"

