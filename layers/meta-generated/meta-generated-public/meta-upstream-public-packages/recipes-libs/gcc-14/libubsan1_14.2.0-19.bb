# This was autogenerated! Do not modify
SUMMARY = "UBSan -- undefined behaviour sanitizer (runtime)"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "gcc-14"
HOMEPAGE = "http://gcc.gnu.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gcc-14/libubsan1_14.2.0-19_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gcc-14/libubsan1_14.2.0-19_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "a216e2e96287a76cbee144756b873247"
SRC_URI[deb0.sha1sum] = "53a0e29312de0b90b4cf033a5cf9b91acd6ed153"
SRC_URI[deb0.sha256sum] = "9205a1bef7d6a52ffc06548e0cde169ff303e688c12d9be3a98f734449077e22"
SRC_URI[deb0.sha512sum] = "2c36c96d70e23a17ea3e630538146020bead34a8d50d4050042b4cbab2abec49cd40e33bbda0763e369383c7d7a21f944ba3a84856187a6eaf4e67ab1ca72a13"
SRC_URI[deb1.md5sum] = "8f7ac2ed13093efd13c0a788dfa1b481"
SRC_URI[deb1.sha1sum] = "6726c825b4cf31a0f0016f4c5ee170dceca76a49"
SRC_URI[deb1.sha256sum] = "b5539003465ea1e60f66b9e3a1019da182e826c82d480944f3656b12351c74c8"
SRC_URI[deb1.sha512sum] = "c1563b12af8b1771563094efeabc03496a132d4bf3e18057335acb466cfff1733ae6d07612ee429fb21609a13fd8bf1f0e9a649bf284faa4ab93ee3d5331ab2e"

RDEPENDS = " \
    gcc-14-base \
    libc6 \
    libgcc-s1 \
    libstdc++6 \
"

