# This was autogenerated! Do not modify
SUMMARY = "GCC, the GNU Compiler Collection (base package)"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "gcc-14"
HOMEPAGE = "http://gcc.gnu.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gcc-14/gcc-14-base_14.2.0-19_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gcc-14/gcc-14-base_14.2.0-19_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "8c82dcf89447f04e600379a1a1871f3b"
SRC_URI[deb0.sha1sum] = "20e45f847eb9c2433ff936af7d3e425abb6c6390"
SRC_URI[deb0.sha256sum] = "5b6825de4263824b78c4c51f6476414f3b4e89c2ab63e81dc8b9b5501e867cf6"
SRC_URI[deb0.sha512sum] = "372defee254080b998da134bfe02ca1b8122ac28247776f7d2f3c36f1c18b2739232b6363c74d17217558e5c4326887ac2270fd642240a14eb391fd67ec532fe"
SRC_URI[deb1.md5sum] = "997abac31f8022d31dcda6d27ab7aa1e"
SRC_URI[deb1.sha1sum] = "87c09e6876e5e1f88c9ed4a8bb7d1bbaaf2b77f8"
SRC_URI[deb1.sha256sum] = "34ee90679b018c0e64234747a4c4c0ae6b7f63541115037465a8627c2dfbc594"
SRC_URI[deb1.sha512sum] = "39bb505b163ec38b840530b6de11d7021ce553451e749fa6caaed2010b3c7d4c9f438fe5e89544bcbcb383d4dd3b817c60ed073d024950834d134751eec57471"


