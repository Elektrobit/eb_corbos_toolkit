# This was autogenerated! Do not modify
SUMMARY = "GCC Quad-Precision Math Library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "gcc-14"
HOMEPAGE = "http://gcc.gnu.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "amd64"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gcc-14/libquadmath0_14.2.0-19_amd64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "002522328d0e10d30642fb25c075fdf7"
SRC_URI[deb0.sha1sum] = "71836091317421d399f7961093c95f4a1861ba92"
SRC_URI[deb0.sha256sum] = "f5b51cf0ece3ec3bb7494d0cdbff3ce715ae00cfb2b6ed787f7db91319d64a7b"
SRC_URI[deb0.sha512sum] = "b795a0bddb209e91bc427ee7839434ec737031833793047cd4c4d163b4c4d7093060bf6bda7d0bfcf103837bfe98ffa82502b183df96821cd76c2854b6df7bf5"

RDEPENDS = " \
    gcc-14-base \
    libc6 \
"

