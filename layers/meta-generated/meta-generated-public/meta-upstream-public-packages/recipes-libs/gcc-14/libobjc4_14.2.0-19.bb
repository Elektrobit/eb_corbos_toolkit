# This was autogenerated! Do not modify
SUMMARY = "Runtime library for GNU Objective-C applications"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "gcc-14"
HOMEPAGE = "http://gcc.gnu.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gcc-14/libobjc4_14.2.0-19_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gcc-14/libobjc4_14.2.0-19_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "ab807f497d07c9d37fe7cb035e72abf7"
SRC_URI[deb0.sha1sum] = "2e644eb6d3991e3c21b58ec7b3578a049ecbf958"
SRC_URI[deb0.sha256sum] = "d48411ec79114d5941256dddb1720fc65cbe4733285b29d5ecc87eb452ab30d9"
SRC_URI[deb0.sha512sum] = "8acb5e8a8745f90f971cd38f3b0fe67fb2e29c8e28930149485c6f10b2a0071cf27b60543d891848199aa7a271386982b0a7de0721ee6ddd905d2adf22f2f6a2"
SRC_URI[deb1.md5sum] = "db01f4257c8f535d1701750900e49f50"
SRC_URI[deb1.sha1sum] = "66f511f981db3d987cb54cd2aa57cb20a4cc862b"
SRC_URI[deb1.sha256sum] = "2c402e31c3636f8c5be1f1c4a4716e9335e570862b7e393ade1e63bde9ff933c"
SRC_URI[deb1.sha512sum] = "ddf2e7c68355375e1b67b2e17a3f9b20bda09823f4525a275de49232ea1738368ff271c494b47eeeccf479c31ff9939512317c29fe044146566c6cb822dbc018"

RDEPENDS = " \
    gcc-14-base \
    libc6 \
    libgc1 \
    libgcc-s1 \
"

