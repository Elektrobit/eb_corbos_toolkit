# This was autogenerated! Do not modify
SUMMARY = "GNU Standard C++ Library v3 (32 bit Version)"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "gcc-14"
HOMEPAGE = "http://gcc.gnu.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "amd64"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gcc-14/lib32stdc++6_14.2.0-19_amd64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "382258b43dfab8621293b0915199f12f"
SRC_URI[deb0.sha1sum] = "31b766b79e42ced2321900a1eff52524822f32f1"
SRC_URI[deb0.sha256sum] = "326011247094e9a5e5b7dd431b67ccf6dddfd9c4ee5078a8d1a15661883791c2"
SRC_URI[deb0.sha512sum] = "7d97f1ddc92ae3b66ff67cfd0cdc6acabd35dc835563f6629ee27526460932ade4ef77e82bf9c9d36ba7db3775141ca9242a6d943913952105a3d70b05f3481c"

RDEPENDS = " \
    gcc-14-base \
    lib32gcc-s1 \
    libc6-i386 \
"

