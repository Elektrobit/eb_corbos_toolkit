# This was autogenerated! Do not modify
SUMMARY = "GCC OpenMP (GOMP) support library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "gcc-14"
HOMEPAGE = "http://gcc.gnu.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gcc-14/libgomp1_14.2.0-19_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gcc-14/libgomp1_14.2.0-19_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "802973e7a4112ca440303b5beecfede6"
SRC_URI[deb0.sha1sum] = "af0e867223a0b3568ffa77c27fe172fd90ca1487"
SRC_URI[deb0.sha256sum] = "72b7a1a33c48f3195efeb044111b34ae684b1e640bb6495c832443b798601cd5"
SRC_URI[deb0.sha512sum] = "e3bb5bb3f7b64aa8d9dae39dd586a64d7e822e9d03d5532064cb93c7d0e0542cbeb883f99c0055af78c47b6291393161cb5b46e03d5c7b81c22b0cfe6607b76e"
SRC_URI[deb1.md5sum] = "e57a11737d6019268f3b3a1f68eb8f65"
SRC_URI[deb1.sha1sum] = "a4c77962e01764215646ae523d4b1d4dde544e4a"
SRC_URI[deb1.sha256sum] = "43e84cb7971d8a4d8870cab6204e998ea4f23ee1339bb0ff556dd881bac82d25"
SRC_URI[deb1.sha512sum] = "0dddb75ae21af7e3284889fa8b8d082c5d6e99137083bd7c172f16c6c9df1aa1e0da5e075e9609b631847666fd75f3e1de728d1252dff84bf8f463b89e039e51"

RDEPENDS = " \
    gcc-14-base \
    libc6 \
"

