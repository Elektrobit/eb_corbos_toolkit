# This was autogenerated! Do not modify
SUMMARY = "Runtime library for GNU Fortran applications"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "gcc-14"
HOMEPAGE = "http://gcc.gnu.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gcc-14/libgfortran5_14.2.0-19_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gcc-14/libgfortran5_14.2.0-19_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "4aa25c9245458f20151c1fa228d9209c"
SRC_URI[deb0.sha1sum] = "f90caa947938a8ba95c248a98f3e818e00501dbe"
SRC_URI[deb0.sha256sum] = "11b62b53f4704de557e44b510e18a1a2106bcd9a3fc31a475a45952a9aa3dbb2"
SRC_URI[deb0.sha512sum] = "7788a808f29825bc692f23a90e2e2ae486ce069db30b927bd2bc6812f8b0d9f482302466baabead9636cb70b54eb69f7a85a4feb8dfbb9c7ac2a3dba7b133bcc"
SRC_URI[deb1.md5sum] = "6503ef60f8649846cac984bd1ba0c507"
SRC_URI[deb1.sha1sum] = "aed5d2b531bc2bf4e77512f4756b8e7e0322f8bd"
SRC_URI[deb1.sha256sum] = "5f771ed84bf8779d4598e66b719121ab1413c11412c87629e50c79d26b042612"
SRC_URI[deb1.sha512sum] = "dd8ed8a542247b056c0f422610ec5c1d4c7f4afd8f87bbf565efa2ff86d64c6812fc5c2bad7e1f32291a7d64f7fb2d55ffe57f7c475c959c31e74a104edd19de"

RDEPENDS = " \
    gcc-14-base \
    libc6 \
    libgcc-s1 \
"

