# This was autogenerated! Do not modify
SUMMARY = "AddressSanitizer -- a fast memory error detector"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "gcc-14"
HOMEPAGE = "http://gcc.gnu.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gcc-14/libhwasan0_14.2.0-19_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gcc-14/libhwasan0_14.2.0-19_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "85c6e76097f5ecba39c87ab41548b06d"
SRC_URI[deb0.sha1sum] = "9f565e9b731dcf084216fa6ed867cc53c2a820ed"
SRC_URI[deb0.sha256sum] = "2cdaf797cad8ac30a964ab081370682dd065ae1b0305a0be9d8e0e14cd0657d7"
SRC_URI[deb0.sha512sum] = "54dbd873e1e335c2deba7b673760943b80baf8db1aece1d95bb2cb4b8b34447ba18ccffb30bb157529bae4708166157c76c88db1712ffdd0ecf7dea216aeecc8"
SRC_URI[deb1.md5sum] = "1c7c7023fcc6117dbb52147fe2937876"
SRC_URI[deb1.sha1sum] = "0a4464dc41d050884ecdebcad3f028b4ec1a4883"
SRC_URI[deb1.sha256sum] = "5a758db399fafd354b6488c4f250b7670fb1f61c31b4e4f329d0fbb750a17084"
SRC_URI[deb1.sha512sum] = "470a0daf774d317af4f5541d3bcc68431934147838c604a0a415d928c8c4e7c039e542edaf79c9510ddb0e1780e84402f595c20e6afa7247f95f0c7305c40550"

RDEPENDS = " \
    gcc-14-base \
    libc6 \
    libgcc-s1 \
"

