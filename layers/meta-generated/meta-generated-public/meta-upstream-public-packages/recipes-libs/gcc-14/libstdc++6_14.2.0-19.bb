# This was autogenerated! Do not modify
SUMMARY = "GNU Standard C++ Library v3"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "gcc-14"
HOMEPAGE = "http://gcc.gnu.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gcc-14/libstdc++6_14.2.0-19_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gcc-14/libstdc++6_14.2.0-19_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "8954f7d89eb15031f88e9f3047be059e"
SRC_URI[deb0.sha1sum] = "88eff3277c2e74be3878264096b958aab6ed33dd"
SRC_URI[deb0.sha256sum] = "ab1fa05837aa7a92aae748fd07a18a35f7d18bb4a71c4724fe2bbf0e32089de0"
SRC_URI[deb0.sha512sum] = "604bf6e4c810b083402b609a464fd86dcd55c5d0c7dedf00ae4543470eeb423f03589b6dc1c3f0dad28b9b7f4fa1aa9f24be265d56a9df2517d230183c50ec17"
SRC_URI[deb1.md5sum] = "55f8a034aaedba9fa762c4890a65de5c"
SRC_URI[deb1.sha1sum] = "4582e5523e677deab65d98eae40f56372f6dc456"
SRC_URI[deb1.sha256sum] = "6669b0c52a2e7c6af9adfdabce3ff6e286065cdfbc7b85280862b5f799daebee"
SRC_URI[deb1.sha512sum] = "8a16eb948227fb65b9dae018e54b1b812d87e2184104111fa292094047edcbddd5cfa390ee2d6b83c95259cff26c6fef38582910d4d737ff5fc8b08e521051af"

RDEPENDS = " \
    gcc-14-base \
    libc6 \
    libgcc-s1 \
"

