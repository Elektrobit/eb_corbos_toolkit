# This was autogenerated! Do not modify
SUMMARY = "LeakSanitizer -- a memory leak detector (runtime)"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "gcc-14"
HOMEPAGE = "http://gcc.gnu.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gcc-14/liblsan0_14.2.0-19_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gcc-14/liblsan0_14.2.0-19_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "8d645f840bfe65d23f4d252b471a2e53"
SRC_URI[deb0.sha1sum] = "aec3197f6bcf7e2291d03ec699d088f590a33f83"
SRC_URI[deb0.sha256sum] = "a0df07da76287a45e665d584363dc2a6a1c4e240aee41b8bbc0f67cdff97cd68"
SRC_URI[deb0.sha512sum] = "80c0f096f2da54334360f80b3c6a2a59278044c4e2603f003e1086aa8bd073a6b4b785a6ad61abc6e35d216f47bba76403e2c4d2fdf8f055fe2de27c2931efb2"
SRC_URI[deb1.md5sum] = "c8a268b29fb5b07331ee88ac0fbdf855"
SRC_URI[deb1.sha1sum] = "9db50485a2bbfab12823bdbb5192ff00442d2f74"
SRC_URI[deb1.sha256sum] = "488a54a5fe01a926ae16d73dc7ea9f530f1bf63fae73640f741695eec2541a38"
SRC_URI[deb1.sha512sum] = "a0a93d99822e9a21de76f251f5a598d77fd8f9bc0df0a8641cad9ba7ea1790dc040ec0212f3f6bc37d4d93b635ccceb1a3569a5077feca98d7a01c9ada4443e9"

RDEPENDS = " \
    gcc-14-base \
    libc6 \
    libgcc-s1 \
"

