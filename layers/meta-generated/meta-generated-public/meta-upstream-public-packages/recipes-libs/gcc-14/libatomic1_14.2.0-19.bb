# This was autogenerated! Do not modify
SUMMARY = "support library providing __atomic built-in functions"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "gcc-14"
HOMEPAGE = "http://gcc.gnu.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gcc-14/libatomic1_14.2.0-19_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gcc-14/libatomic1_14.2.0-19_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "ac6daa5a9f8809b24584507f08e54de5"
SRC_URI[deb0.sha1sum] = "a478fbcba038f4a18db43b9771ee01a7da5ab23c"
SRC_URI[deb0.sha256sum] = "212b399aae2f7299203d261a57e49372e09565a9a5ea971905f94a3960366c05"
SRC_URI[deb0.sha512sum] = "bd0d73086c37ac7262699fea42e30616e0ab18bc16fc47ff2085b2b15b5356f735ba8d0b1d00c8891a6a73eb443791d8522fd380ed1cf369ed75d2eea47f14e0"
SRC_URI[deb1.md5sum] = "2b84ca975bf55fb934d5e6c0c3d803f8"
SRC_URI[deb1.sha1sum] = "1c253948664b91d1351b0fe793a8528d75369561"
SRC_URI[deb1.sha256sum] = "7ccff90234484bf21ae5ecb79d25b6a84b2f4038f65dd139085b2e3a937cd8dc"
SRC_URI[deb1.sha512sum] = "46a017608375c77055c176912082cbd1836a4015eee883fa148f5ae64bc725c92b4438d9a70782a50eb36bf6a1ff49e55d7c952eb55b8d8b9045539929ed63d4"

RDEPENDS = " \
    gcc-14-base \
    libc6 \
"

