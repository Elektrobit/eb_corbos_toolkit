# This was autogenerated! Do not modify
SUMMARY = "GNU Transactional Memory Library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "gcc-14"
HOMEPAGE = "http://gcc.gnu.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gcc-14/libitm1_14.2.0-19_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gcc-14/libitm1_14.2.0-19_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "73c00683cc2eee651925b41f15e321a4"
SRC_URI[deb0.sha1sum] = "fa3386e16d30fbd33004c03a0a8e3ffc205f4cc3"
SRC_URI[deb0.sha256sum] = "febdb3c528cde1a3abe952e17a1d3cfa7ccaca5b6f506d983d34385dad199490"
SRC_URI[deb0.sha512sum] = "de53dde852e93f358b7640e3a9ed0c7c4ce386f0ac77cf5f8a3560bbca78625a527f8b88cda9818caccab30497dd427c9127b2633deda357f13457b9779aee03"
SRC_URI[deb1.md5sum] = "a7b8d73df48f0c6283b0827846a12354"
SRC_URI[deb1.sha1sum] = "ba38cc3b5403fdab8b9eed4adb77e36ccdea4b18"
SRC_URI[deb1.sha256sum] = "d6f0255b498af876ab7bf4420672e43cbe58dcd577f0711131cbfbcbee283cdb"
SRC_URI[deb1.sha512sum] = "374f28460c8358c0e37b3ee30bd428b9001cd5eb19823702ec70e35498f64da6c1280ab8cca8946d8029869ab94ab7281f68fcd4a7ec199936574f506f54263d"

RDEPENDS = " \
    gcc-14-base \
    libc6 \
"

