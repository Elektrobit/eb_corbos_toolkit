# This was autogenerated! Do not modify
SUMMARY = "GCC support library (32 bit Version)"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "gcc-14"
HOMEPAGE = "http://gcc.gnu.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "amd64"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gcc-14/lib32gcc-s1_14.2.0-19_amd64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "a612df3e2041123654077ff1253e8f8c"
SRC_URI[deb0.sha1sum] = "ffdead6540631f309b700f684d693fe5a81f81cb"
SRC_URI[deb0.sha256sum] = "aa7674a786d58a1efaacb3ce377c06a2d3153c1fa7360b08375c7dd67c90c3fe"
SRC_URI[deb0.sha512sum] = "93624f8bae268fbda6ad5502e537f23c1992bccc1cb14f17a107e88b1b603bd6531afe0e6f6a7aeee3f802a8d73d945f056a7804c2fef42d1e6490ab36ce6d0f"

RDEPENDS = " \
    gcc-14-base \
    libc6-i386 \
"

