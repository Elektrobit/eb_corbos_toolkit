# This was autogenerated! Do not modify
SUMMARY = "GCC support library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "gcc-14"
HOMEPAGE = "http://gcc.gnu.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gcc-14/libgcc-s1_14.2.0-19_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gcc-14/libgcc-s1_14.2.0-19_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "6064bfcea6a7553d15ef00ca9d3e8df3"
SRC_URI[deb0.sha1sum] = "bdc0b54ff7f971ecd56ae54aea604d2ab0e47aaf"
SRC_URI[deb0.sha256sum] = "3c71917b490d1a17aed43196a2787a256ecf060526cdb20216a74bedc061b150"
SRC_URI[deb0.sha512sum] = "a772ead03f938d76c09b3efba8c77652262be015cf44a8cb881183769c5ab19138afb95125d4b9563ec682d15163df1d3d9317563cd7ac3633178f5ae81185e9"
SRC_URI[deb1.md5sum] = "473debe834d7b77ff74483d6f3fdbd76"
SRC_URI[deb1.sha1sum] = "8f3629cf95590aa5492ea87bbfd3ae785c99ebf3"
SRC_URI[deb1.sha256sum] = "1108bc87879833d6d9a145f22a4a15cddb34e065b4b5f4b97bee586adbac2851"
SRC_URI[deb1.sha512sum] = "134d5404a297ccf303642328538fb4e46ec6d71d8e0cdf5ed16bce8c7b98d9a08237973170157f0cbfe37786b91ce9e03a83f0d4eea412829b1524ebcb641633"

RDEPENDS = " \
    gcc-14-base \
    libc6 \
"

RPROVIDES = " \
    libgcc1 \
"
