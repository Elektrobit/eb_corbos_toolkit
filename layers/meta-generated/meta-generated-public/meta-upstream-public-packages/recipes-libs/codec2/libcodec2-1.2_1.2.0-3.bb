# This was autogenerated! Do not modify
SUMMARY = "Codec2 runtime library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "codec2"
HOMEPAGE = "http://rowetel.com/codec2.html"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/c/codec2/libcodec2-1.2_1.2.0-3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/c/codec2/libcodec2-1.2_1.2.0-3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "4d9424cc2e92f2bf174074c70beca76b"
SRC_URI[deb0.sha1sum] = "299694d738dd767844e0bdad19cfe1d89c7bff77"
SRC_URI[deb0.sha256sum] = "d68a3b754be7aa2d724d01d2079c542fc7cfa53eaa4ac89fbc6e63d950c02bd6"
SRC_URI[deb0.sha512sum] = "550c2e57ff17575d8625705fde9a81cfb7d608f9958c117229d01573321c29619a76b60e3094f8adce52454af8a39f3249a40b5b24bc7933e7156d837d4fcd73"
SRC_URI[deb1.md5sum] = "721a9023d92ba3e20f1f727396f3754c"
SRC_URI[deb1.sha1sum] = "664350f8f363f59e8842b972d5c0b9d402d08689"
SRC_URI[deb1.sha256sum] = "33e971eb87601c32b330dc1915b92f3fd88ea74380a30a2d10b657065d36e920"
SRC_URI[deb1.sha512sum] = "b9869a411a0d73aee0d2ed79f93707e79c032cb141a6e1895555a4736490375e97059f5986ec2607885e5799c9c39f3671e3511054020f4616d8d2eaa441a01f"

RDEPENDS = " \
    libc6 \
"

