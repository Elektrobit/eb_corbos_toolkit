# This was autogenerated! Do not modify
SUMMARY = "X11 client-side library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libx11"
HOMEPAGE = ""

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libx/libx11/libx11-6_1.8.12-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libx/libx11/libx11-6_1.8.12-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "723fec07f977145e0ed2c6ff8048a69d"
SRC_URI[deb0.sha1sum] = "56ae4d0487891c46be6f33fb030c750950259511"
SRC_URI[deb0.sha256sum] = "b5a3fd3bf8c8fd0364bfb9bea00dcba7fc301229bd02dded084632d31f5b0fb3"
SRC_URI[deb0.sha512sum] = "3cdb7cbac4435ee337056e93bb5a2435deaf73d118cb2050485a41f9421e23c3740453a921ccfeb6a13fa0a124b461699a980bf7068cf72ef17d4c569329fa8d"
SRC_URI[deb1.md5sum] = "05dc0b6526a8a10bd5c8b64809331dcb"
SRC_URI[deb1.sha1sum] = "4195307cb11c46508bd19548a650565d5aa70177"
SRC_URI[deb1.sha256sum] = "646f2d3f2165c8eebceb7f4aaca31e97a818bb11a045964833a9f764b738bac2"
SRC_URI[deb1.sha512sum] = "a9599bdae3a22cc7cad743d483f63dfa17a3a592e8eb5af8184c6d4eab2bc10d8c783b4c2fbd3cf3b2ec3b2ee5f1a0e2a2ffb896218b656c95f497f4a7b62096"

RDEPENDS = " \
    libc6 \
    libx11-data \
    libxcb1 \
"

