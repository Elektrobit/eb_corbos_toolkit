# This was autogenerated! Do not modify
SUMMARY = "Xlib/XCB interface library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libx11"
HOMEPAGE = ""

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libx/libx11/libx11-xcb1_1.8.12-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libx/libx11/libx11-xcb1_1.8.12-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "4b35848e6933d3c1dcde949ef8c070b4"
SRC_URI[deb0.sha1sum] = "5f0ce4427e2625e0246e4a3d896720686317b0d9"
SRC_URI[deb0.sha256sum] = "e05f94d21a932fba5b09b9b13d99df776b155d3bc792c0e294451df9ffe1ba25"
SRC_URI[deb0.sha512sum] = "7bc3d3bd41f1e54b5d27d777e62d3df97132a25d12e2aa26565931dcdbda4f9797d7414365791adf40c6556f3bf63203e8f8adfe0d8407a243e3b42eeedcaf43"
SRC_URI[deb1.md5sum] = "5b4ea4498e6e333ad889b6de18524bc9"
SRC_URI[deb1.sha1sum] = "1c8a65b11ac304203af3b8831df4880f33fb8ab3"
SRC_URI[deb1.sha256sum] = "1eafaa4295e129d6a81e742ab8da43194daa6b916199923c8cef8ad358985894"
SRC_URI[deb1.sha512sum] = "919e132a18ea3149605465e15ea5539b1e7bbe7114c8cd7f7ffe247986fbe1966cdd42d7cf7ae984ea33b281f3eb0af01af4279722bf572922f00022ec149f5c"

RDEPENDS = " \
    libx11-6 \
"

