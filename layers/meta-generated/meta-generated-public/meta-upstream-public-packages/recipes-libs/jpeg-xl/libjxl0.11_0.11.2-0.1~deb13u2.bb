# This was autogenerated! Do not modify
SUMMARY = "JPEG XL Image Coding System - "JXL" (shared libraries)"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "jpeg-xl"
HOMEPAGE = "https://github.com/libjxl/libjxl"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/j/jpeg-xl/libjxl0.11_0.11.2-0.1~deb13u2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/j/jpeg-xl/libjxl0.11_0.11.2-0.1~deb13u2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "b704208bf6b2ade3a93ccb580c30d1be"
SRC_URI[deb0.sha1sum] = "588237afb91b41e2cc0691486ae0943ef863507a"
SRC_URI[deb0.sha256sum] = "cd1ca3a52cb0d8fdce1d994bcbf0663de28c64add1cfe8096639ae8fa9808824"
SRC_URI[deb0.sha512sum] = "135ade2e272b9620706f69bfa796801895a0eff4420e6c27f4b1aaa48d9adb00d4dd8e2965e331a2d4f992b5ccc9e58beb9f28ffe634567559047d983a379ab2"
SRC_URI[deb1.md5sum] = "eb497b7920eef7f18f3d6998e3985269"
SRC_URI[deb1.sha1sum] = "c45469f6119a4863367039c8dc7fd4bdc52bb431"
SRC_URI[deb1.sha256sum] = "c8b2923516f9d2c4a3569e741e698b0db0a918beeac9e5e10fb9c7344cd46e8b"
SRC_URI[deb1.sha512sum] = "592803159ca6eda65877772410124ff233ff55ffd2e5e83a3af170181c1ef6b1b07865b43520eb45476231aec4ad24bd10ab24f7b426234543be740e0ae9bbcc"

RDEPENDS = " \
    libbrotli1 \
    libc6 \
    libhwy1t64 \
    liblcms2-2 \
    libstdc++6 \
"
RDEPENDS:append:amd64 = " \
    libgcc-s1 \
"

