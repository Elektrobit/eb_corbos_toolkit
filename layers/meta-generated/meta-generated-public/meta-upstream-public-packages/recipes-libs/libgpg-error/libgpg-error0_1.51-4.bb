# This was autogenerated! Do not modify
SUMMARY = "GnuPG development runtime library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libgpg-error"
HOMEPAGE = "https://www.gnupg.org/related_software/libgpg-error/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libg/libgpg-error/libgpg-error0_1.51-4_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libg/libgpg-error/libgpg-error0_1.51-4_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "6421456dd84b8f477ec14ff504b3a7c4"
SRC_URI[deb0.sha1sum] = "593590485c9a6c59d0771cbc852019d83b503df1"
SRC_URI[deb0.sha256sum] = "22b95570fd41c113ef6f5651563b4d748292844baab1278a46eb940c1dec2322"
SRC_URI[deb0.sha512sum] = "edf5e8fc65ed0a08ef2f9f0ddcbe673e4afbc302e2a40ca23068d975bac543634869443d1df9108888e7181fdca5e3e4dd65c409cf4db18a58bf6d9757bb441d"
SRC_URI[deb1.md5sum] = "a56057340a3e2fab83fc0d15b5081cf0"
SRC_URI[deb1.sha1sum] = "9610bcd5aa0df7f5cbc28456fff7efb37a4f48a4"
SRC_URI[deb1.sha256sum] = "f9a8ee3f325360dbbb1c98331c60c7aa454a054a8a4564bc36b3e52fb53e019e"
SRC_URI[deb1.sha512sum] = "02db2780cc15f797740c2b19494e7b75464b69a1fad4bda5ffffc1625034bedc3178285f478cb76f2512e671391e849a27a4658e8d9e859ff22b699e738b7426"

RDEPENDS = " \
    libc6 \
"

