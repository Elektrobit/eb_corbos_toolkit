# This was autogenerated! Do not modify
SUMMARY = "utility libraries for X C Binding -- icccm"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "xcb-util-wm"
HOMEPAGE = "https://xcb.freedesktop.org"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/x/xcb-util-wm/libxcb-icccm4_0.4.2-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/x/xcb-util-wm/libxcb-icccm4_0.4.2-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "0a8c715ec83c505ae255e59388149976"
SRC_URI[deb0.sha1sum] = "76c1124e016c60ef93db0ef8fc6208b0fd6f18f0"
SRC_URI[deb0.sha256sum] = "28f04c7fa76939bbc03fbaa1191dc58200c0c894d48ac6105a7039ba4d223b4a"
SRC_URI[deb0.sha512sum] = "28a50fac23dc6a7cebf9e80d221b10a3a0d5dd8f6544682eb7fe9b47b323d18abd79c64d721ddc7b73b199d7c0fcba39c590cf65eb0e826abe58e3c97b054e3f"
SRC_URI[deb1.md5sum] = "b7fb459397285c51cab706eb6d8106b6"
SRC_URI[deb1.sha1sum] = "89844aa6f81a5863d729f6bdebe4458151b9271c"
SRC_URI[deb1.sha256sum] = "4f9b048b98cd9cd7b0a553c8eff05bcd25cfc4fbfddbe4f83e9d6a9c82e2d876"
SRC_URI[deb1.sha512sum] = "833c53412689595453001f22360a393d7425b1e53510a02c2813b136d05bc20dad19fd2a5267d505a0a9d2e4d0e7fcd730acdc604e0f23b90ed1710aacd683c4"

RDEPENDS = " \
    libc6 \
    libxcb1 \
"

