# This was autogenerated! Do not modify
SUMMARY = "line breaking library for Unicode (shared library)"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libunibreak"
HOMEPAGE = "https://github.com/adah1972/libunibreak"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libu/libunibreak/libunibreak6_6.1-3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libu/libunibreak/libunibreak6_6.1-3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "c1140b8d0125a190b858e1e32c9fed5a"
SRC_URI[deb0.sha1sum] = "e72ac9f1a0dec9b564701d48d29da82a8e0a6617"
SRC_URI[deb0.sha256sum] = "a5d5fa113f195288ed145d48d0e886671c94416ae7c800f943bc21cc4ef628cc"
SRC_URI[deb0.sha512sum] = "b8fc78f75587bf5f9d3953d4dbfb51c7aebb260e3f4d8317827fed6a6f2ac807abc1c2e8fad509ec4fcbf64a9128efd528182c1bec5bccb4a220627403efdb81"
SRC_URI[deb1.md5sum] = "d5cca1d38175c550dafe3ed690c6b2ab"
SRC_URI[deb1.sha1sum] = "b69e93109ac26a43343c83cc6452421e5cffa316"
SRC_URI[deb1.sha256sum] = "8689f3761d5ac0dd9119f187561dd61dbb8b273d3a684fc57fbcc3de9daac9ed"
SRC_URI[deb1.sha512sum] = "75a70f5c12f4221ee98cbae006f70b14b10ecd65d2012b70df29eb45d949132a69c2e3cceb06f29ded08adc1644acd3533d2b867f706e2ae042555abc42fe649"

RDEPENDS = " \
    libc6 \
"

