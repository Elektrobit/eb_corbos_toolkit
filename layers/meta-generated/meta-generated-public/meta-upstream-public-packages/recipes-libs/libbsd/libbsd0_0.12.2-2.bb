# This was autogenerated! Do not modify
SUMMARY = "utility functions from BSD systems - shared library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libbsd"
HOMEPAGE = "https://libbsd.freedesktop.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libb/libbsd/libbsd0_0.12.2-2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libb/libbsd/libbsd0_0.12.2-2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "e3b9d9c161b809d77b9a08134304a58a"
SRC_URI[deb0.sha1sum] = "e4894bcb1b3c28477aa780a66131998370c83aa3"
SRC_URI[deb0.sha256sum] = "e5a85986fa6bec3307ab1bc860736b478b331882bc45e17675a7bdf88eecb43a"
SRC_URI[deb0.sha512sum] = "a3b18b41de17bebf65f541b50bb4e91ffad620b3965cb65b4f91649e356c21e0769cc6082d13d2ae2fb2618fb48a7f2fae1bf40390397a34726b19b3126a4d6c"
SRC_URI[deb1.md5sum] = "a12346422b7e5f978fd40af79e8e80ca"
SRC_URI[deb1.sha1sum] = "bf9e11cc725cba043e9bc68835837aa9deaf746c"
SRC_URI[deb1.sha256sum] = "6827c1b3ad8dcbf3478803f9150359433e3376a3bde01c4503888a22eb3924e3"
SRC_URI[deb1.sha512sum] = "3f187a0799c5d1aa2079108c6f49be0aa2f5a3e88b56e3260aa09f0cd72581c31d11c3c1e2efa844d70a01b59f3f2ce9b1dc6eb27208db9a91095b5733578cc5"

RDEPENDS = " \
    libc6 \
    libmd0 \
"

