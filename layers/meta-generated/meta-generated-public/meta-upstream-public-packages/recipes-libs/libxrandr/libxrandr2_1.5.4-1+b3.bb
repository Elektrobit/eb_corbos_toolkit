# This was autogenerated! Do not modify
SUMMARY = "X11 RandR extension library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libxrandr"
HOMEPAGE = ""

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libx/libxrandr/libxrandr2_1.5.4-1+b3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libx/libxrandr/libxrandr2_1.5.4-1+b3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "8e8011a0428fa68750d3eab1673066ac"
SRC_URI[deb0.sha1sum] = "50fcec8eca0f898064530eeab76853aa65c0276a"
SRC_URI[deb0.sha256sum] = "11e3490de93a8bbee3daba719cb8e1325a26fb3c125525c34bdcb7deb05eb9b2"
SRC_URI[deb0.sha512sum] = "2c2dcab320a5e5576c7115865bb7237a22f4a31a93a1da7cdb868a854ac50ef7c7a6dee18540525feddf76a952ef602ae34dafb0fb9e221630b2f51de7e0cb6f"
SRC_URI[deb1.md5sum] = "b5d531fe8a3446bbe866c09447f903ce"
SRC_URI[deb1.sha1sum] = "ce9554f88ab229b40dcd1dc06c93d14b67ce5179"
SRC_URI[deb1.sha256sum] = "607a23d6d2cb920e000b24870531a86821cf4e141a4eb0bf38212b47b892d597"
SRC_URI[deb1.sha512sum] = "fdc3774746033c38a35e8f01b237f7241d49d184a197f187b5e372a24a1605aefe6104dd5483d67373c6df6782b592b3fe5292ad8ca271960ea1f938f928d14d"

RDEPENDS = " \
    libc6 \
    libx11-6 \
    libxext6 \
    libxrender1 \
"

