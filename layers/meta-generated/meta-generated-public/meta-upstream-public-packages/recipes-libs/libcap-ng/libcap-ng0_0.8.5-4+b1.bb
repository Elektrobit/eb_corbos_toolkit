# This was autogenerated! Do not modify
SUMMARY = "alternate POSIX capabilities library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libcap-ng"
HOMEPAGE = "https://people.redhat.com/sgrubb/libcap-ng"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libc/libcap-ng/libcap-ng0_0.8.5-4+b1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libc/libcap-ng/libcap-ng0_0.8.5-4+b1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "e04dd4fde0a940901b89f48ce9a85056"
SRC_URI[deb0.sha1sum] = "fb0d8bea0ba6659624410e3671e934ab564e283e"
SRC_URI[deb0.sha256sum] = "20a9e4b0619a3eb2566338223bed135dde5a601eaa2f8fdd5f20b94506addcac"
SRC_URI[deb0.sha512sum] = "5c90477f653e926033b758a5b385a2e20da338d9a0b5e83a5b06394614f8a95cfa60d9ff017f5af9ff68bfb9ecfd4b21036c8c99e4023ddc73049257bb6988c9"
SRC_URI[deb1.md5sum] = "b0e3467cb8ed52dff5aec010e641b5ce"
SRC_URI[deb1.sha1sum] = "40dc57a3e46bbb086791328b695425e9dd13918c"
SRC_URI[deb1.sha256sum] = "eb6da83296e4710a8600c1426692ed9b9eadcab7ebd36dbabc2a562b5c1ab691"
SRC_URI[deb1.sha512sum] = "4c93f2ad15d6e009c2df9b137d11a8dc2c7cc7e38533ff0fd7908e6ab42c9f00e56f1356f8083e129ae299412275217aae5eaa3f5d69e6d651d69cc5e2c0d04c"

RDEPENDS = " \
    libc6 \
"

