# This was autogenerated! Do not modify
SUMMARY = "libkmod shared library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "kmod"
HOMEPAGE = ""

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/k/kmod/libkmod2_34.2-2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/k/kmod/libkmod2_34.2-2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "85d3b74c7245a075775d26b9aebdf13c"
SRC_URI[deb0.sha1sum] = "8ad0a77c374d6e58fa17c465e6eaaf4718bd908e"
SRC_URI[deb0.sha256sum] = "ee6c50ebac79aa9795e8bf9aa01d94c99984d09d22598c66be0f8ba917b62179"
SRC_URI[deb0.sha512sum] = "2a7fa5ee62eb3795325b4dcacd20e946329b5ca54fdd6564b501fa0295c567c1089113e7fc58d6fc8b83cc1b7cb8e173d336a4d6810ada450d82fc11cadc4b51"
SRC_URI[deb1.md5sum] = "562f5ebd21a4df736908c8cce5082bab"
SRC_URI[deb1.sha1sum] = "b226ee21bf9dea7d1033e524c6ad2f385cc03639"
SRC_URI[deb1.sha256sum] = "01d2bf4ead7f6da5aca7f1ecc108cbe858a349ca55368742ead758fa7383e10a"
SRC_URI[deb1.sha512sum] = "377cfb2a32ab39c13fd5ceeac0a377f15b0e0f7571c6c9dcce787f52210d5d0b9b65d924e078fccd7f7775bd86bbb3f47c969d19a484bfa51da5e4b933a6a093"

RDEPENDS = " \
    libc6 \
    libssl3t64 \
"

