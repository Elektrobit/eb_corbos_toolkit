# This was autogenerated! Do not modify
SUMMARY = "library for accessing process information from /proc"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "procps"
HOMEPAGE = "https://gitlab.com/procps-ng/procps"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/procps/libproc2-0_4.0.4-9_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/procps/libproc2-0_4.0.4-9_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "c446e0ae1fbcab149c5b386d3a680e79"
SRC_URI[deb0.sha1sum] = "023abaa2f21ffba84247a595f46ccfd057547582"
SRC_URI[deb0.sha256sum] = "c9d61caab1b2ddfc3f17edb95be31b9809fcb2daf27d853dff615bc4ebd08b4b"
SRC_URI[deb0.sha512sum] = "a8abfaaaf12c64de453bc43e619d1e03b54649ed0cb5e78189bacba29b51467fe5b7e07b937ebcfbc1c88fabea9f899777cb2a7b27ae45d9ebffc89713e39951"
SRC_URI[deb1.md5sum] = "205261009460ea0dfbe510b9184691ed"
SRC_URI[deb1.sha1sum] = "ac10d61b7652a3b784312d491f43377b081ead1b"
SRC_URI[deb1.sha256sum] = "e81069b58fe82223c71fcd74c760cb0fd3b0e61792fbaf2e5675fd948dc16dba"
SRC_URI[deb1.sha512sum] = "4b4da227869189bf2befbdc3340e5fb817adc5db34f3051d92d961bb61bca85ccbca3c6fe053658525bc89158e0903a04d447dff37d0852fc9b9513f2039eec0"

RDEPENDS = " \
    libc6 \
    libsystemd0 \
"

