# This was autogenerated! Do not modify
SUMMARY = "shared library for pkgconf"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "pkgconf"
HOMEPAGE = "http://pkgconf.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/pkgconf/libpkgconf3_1.8.1-4_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/pkgconf/libpkgconf3_1.8.1-4_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "7d9f0289ee7565e845db6a8445558114"
SRC_URI[deb0.sha1sum] = "2f2c7dbb9a6ab04a149b44daf47a719f0715fa71"
SRC_URI[deb0.sha256sum] = "85087cd04e57fd4ab7d6e816d348c335047823ab60c78878336b74f07b352ca1"
SRC_URI[deb0.sha512sum] = "65252d3a16cc1be90f804b9a451f7a011aa83441a44ad08df3e6de52808b165dd8d545fe9bfd35901827dd60b7a8315c5f3de012b159603233ad617dd3fe35aa"
SRC_URI[deb1.md5sum] = "f2ccacf0fcb92d5f438a5d2ad32dee19"
SRC_URI[deb1.sha1sum] = "fe6fee2208fb6d0516818f2ff02203ada701d96d"
SRC_URI[deb1.sha256sum] = "8a9477ed7af47d7ddefa1fe02bf9f87d6778e8cc59062064f1b076880a7a14a5"
SRC_URI[deb1.sha512sum] = "451cc9ffc2081e2c2605baa628fb83773ab4584e2d6770927830b0c74de2a5dbaebe9c6fe9cf1b5c6533d687a38ab67ff397d8404ffc74e03440b18e6f2bf243"

RDEPENDS = " \
    libc6 \
"

