# This was autogenerated! Do not modify
SUMMARY = "Library to access U-Boot environment - runtime"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libubootenv"
HOMEPAGE = "https://github.com/sbabic/libubootenv"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libu/libubootenv/libubootenv0.1_0.3.5-0.1+b2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libu/libubootenv/libubootenv0.1_0.3.5-0.1+b2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "3596cd751bd60585e70632b01228cb7b"
SRC_URI[deb0.sha1sum] = "882626c2bcd5f731018db271273ad44983924f1b"
SRC_URI[deb0.sha256sum] = "b9e75f613e63156c3832e4442fe06b7eea2b1b3707d177533af400182877e8f9"
SRC_URI[deb0.sha512sum] = "efa218bd017ce167d0937846e9ff97a41ce237de1080021234949bde48ed85a9dcbd5f85fd715042bc43db07ae3bb2d4514dfb361e44bf5dbef9c52b9c5dd823"
SRC_URI[deb1.md5sum] = "c610938d64c056ef04f6451e248ecf6f"
SRC_URI[deb1.sha1sum] = "ad9bdf93983a011cfb416540663f95f8a275c3a3"
SRC_URI[deb1.sha256sum] = "4f487333a1d0010b87db9b9642e50bfbd4761192d8c298c6da47847b1cb3397e"
SRC_URI[deb1.sha512sum] = "a9ac60f07b765879d1553146b0fcfdb3b6e2daa89554a14c9b033c5039e2bb58a797aead871a5024c79c95d33ce57cd7351a7211f830ffce5e3b89a9215ff0a8"

RDEPENDS = " \
    libc6 \
    libyaml-0-2 \
    zlib1g \
"

