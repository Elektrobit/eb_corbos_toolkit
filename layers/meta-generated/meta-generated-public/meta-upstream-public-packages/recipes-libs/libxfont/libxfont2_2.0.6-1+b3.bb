# This was autogenerated! Do not modify
SUMMARY = "X11 font rasterisation library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libxfont"
HOMEPAGE = ""

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libx/libxfont/libxfont2_2.0.6-1+b3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libx/libxfont/libxfont2_2.0.6-1+b3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "6fb779b7cc8003daadd2a113ea735bb9"
SRC_URI[deb0.sha1sum] = "781b5320776f5ecbd6fdf31594aec32f236e6574"
SRC_URI[deb0.sha256sum] = "f24ea08c923d68c7ff7c16286f2e13db54ba37c542ddc500e89b52dde479bc54"
SRC_URI[deb0.sha512sum] = "ef52b6351e6d89efc4da0485ac8fbc8b29fceb442d7adde904ee626c93185147bc7b9ce4e4d37ecdf067ad466aed16d57dd4a0431e2791939ad9c8692cd96f8e"
SRC_URI[deb1.md5sum] = "54b4c40495d2f203b9a728fa39c93bb1"
SRC_URI[deb1.sha1sum] = "014bc7b0415d7c50317e9de406c01e8476de5602"
SRC_URI[deb1.sha256sum] = "5f8529993c044696ecaa8fb3ab4e45937f5530eff976e6f9a524ac0283dfb81c"
SRC_URI[deb1.sha512sum] = "932b926d41b169a37739e625b0760eab3a19678b48a096d58ade4afc8e35f994883479d510140c9e882f0e710939dc89bb69aa1370ad030bf8fe670df8efa398"

RDEPENDS = " \
    libbz2-1.0 \
    libc6 \
    libfontenc1 \
    libfreetype6 \
    zlib1g \
"

