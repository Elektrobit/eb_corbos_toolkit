# This was autogenerated! Do not modify
SUMMARY = "EDID and DisplayID library (shared library)"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libdisplay-info"
HOMEPAGE = "https://gitlab.freedesktop.org/emersion/libdisplay-info"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libd/libdisplay-info/libdisplay-info2_0.2.0-2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libd/libdisplay-info/libdisplay-info2_0.2.0-2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "44f4734848c515eb7c6e91e219b79c28"
SRC_URI[deb0.sha1sum] = "adf3887cfb4bab1a64a371800b50b08ae3748154"
SRC_URI[deb0.sha256sum] = "961924d484d4c14b6decb76cf0e860a1e7b6c89bfc85e527d873a89faf24b846"
SRC_URI[deb0.sha512sum] = "e10269da0e84d8d145201a4c538d2077f5f73e12dd0c02e5c62e1dd0c221b3f7e324aa31ef497a3d4e9a3bbca72bdb1fe5fa901de5896420d2c119f25977c583"
SRC_URI[deb1.md5sum] = "394eb962b8ebbb61d5a01ec9843836fc"
SRC_URI[deb1.sha1sum] = "8d95410fddef27eca62872ebb6841f403d217cfd"
SRC_URI[deb1.sha256sum] = "9719d01a5eaef520f41ee576af111c8f4c59246a8861178504d066b86d2ba7c9"
SRC_URI[deb1.sha512sum] = "f3c3f5e036d60586cd30bf05da0ea4116ea2e39cb907ca3e7002a4c5287524e15585df6cfc6b387c4337d82bd727ed00cebc5f6d7a9a70107b18f8dde4598250"

RDEPENDS = " \
    libc6 \
"

