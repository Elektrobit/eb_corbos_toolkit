# This was autogenerated! Do not modify
SUMMARY = "manipulating sets and relations of integer points bounded by linear constraints"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "isl"
HOMEPAGE = "https://openhub.net/p/isl"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/i/isl/libisl23_0.27-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/i/isl/libisl23_0.27-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "b3588a435f44ab74fc24e85d6ac4d807"
SRC_URI[deb0.sha1sum] = "1d47b6af368facc2d560a7eaa2f827aea5671aba"
SRC_URI[deb0.sha256sum] = "ac8518042e81c00de1effb72bba7e88ac4ecd488f7ea8b9e3ebc63159cb53b35"
SRC_URI[deb0.sha512sum] = "d1d012275271b6cddc579e0bf84375d7bde579f03abfdd08f86fa57ade790835ff1b7d1b65fd92e72c9ee394c3ed6fb4e554e235a5e422d5f21b0709c995213e"
SRC_URI[deb1.md5sum] = "931439f41ceff5db22c64c2bcc64fa13"
SRC_URI[deb1.sha1sum] = "7425c29776fa1ebd2a4fb5602327d1f5e0f3bf6a"
SRC_URI[deb1.sha256sum] = "21c490db3fa5f0a517c55090a199334da6164589772ebd922dff1e569c78515d"
SRC_URI[deb1.sha512sum] = "3769cfd370bf786a1868b47eb73003e4e171c0fc2e9c9ab9962a0c447185b58c4c7b257beaa03f535ab8ae2eb271b3c55cfa0622cd80c87937b99ea4c4ca2133"

RDEPENDS = " \
    libc6 \
    libgmp10 \
"

