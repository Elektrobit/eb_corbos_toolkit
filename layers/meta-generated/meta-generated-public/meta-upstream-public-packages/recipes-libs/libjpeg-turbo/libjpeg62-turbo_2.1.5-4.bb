# This was autogenerated! Do not modify
SUMMARY = "libjpeg-turbo JPEG runtime library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libjpeg-turbo"
HOMEPAGE = "https://www.libjpeg-turbo.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libj/libjpeg-turbo/libjpeg62-turbo_2.1.5-4_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libj/libjpeg-turbo/libjpeg62-turbo_2.1.5-4_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "529794778276370a5b4830dbd8481747"
SRC_URI[deb0.sha1sum] = "56bc7cbd9936f62ca59294724011b5bc24bb7540"
SRC_URI[deb0.sha256sum] = "5504299ad0e3c0a9ca9f962a68a650a040db52f9f416a109e74df48d55601d3f"
SRC_URI[deb0.sha512sum] = "ee4cd5ccade9e0a4137889c8ebf610fddd3204db0f41833147ccaa9a151ae6aa8c0b60454b478c15ab1159cc2748d628a61fcafd4c4f1c6e9f8cf362b712c991"
SRC_URI[deb1.md5sum] = "758111721e42876d7d747590af00c595"
SRC_URI[deb1.sha1sum] = "f1b51df93dc6344f4cb30d3cb7e0984aedbb2b36"
SRC_URI[deb1.sha256sum] = "e4989073bb0bac8a6ec043c7adb80e1dfe601d8552233da48bb24ab45d1a1d4a"
SRC_URI[deb1.sha512sum] = "380d763f1f9921e569df20936432633b66b144e49b5623f618e2560aba2c020d23e23253acf6d7512aa6aea539aeeae64f146620d9bd97b8947b9c9dd444c4c5"

RDEPENDS = " \
    libc6 \
"

RPROVIDES = " \
    libjpeg62 \
"
