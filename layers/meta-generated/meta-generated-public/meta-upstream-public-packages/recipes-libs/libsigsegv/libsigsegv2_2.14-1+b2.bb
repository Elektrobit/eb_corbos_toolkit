# This was autogenerated! Do not modify
SUMMARY = "Library for handling page faults in a portable way"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libsigsegv"
HOMEPAGE = "https://www.gnu.org/software/libsigsegv/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libs/libsigsegv/libsigsegv2_2.14-1+b2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libs/libsigsegv/libsigsegv2_2.14-1+b2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "3657f1763e36ecafad0d8f18f41a91fd"
SRC_URI[deb0.sha1sum] = "6026eef886baacac1032a5b1b377245ef350ecfc"
SRC_URI[deb0.sha256sum] = "bac603b965f303ea88dc39cd723b3d88cd86e3be9c948783f0d5e0d00e971302"
SRC_URI[deb0.sha512sum] = "d1440f8f47e34598090b6bef1e7e32bac5ba3e18c9c49156d121a0679ccc8b2056d3ab8213b51f08f5565e9142720f6a668b3fde836b2784164f70da3518dafd"
SRC_URI[deb1.md5sum] = "292efffeb91878ac04b67d5782826caa"
SRC_URI[deb1.sha1sum] = "1e7517d5ac0e5b81e689bc8feadf70a13db07330"
SRC_URI[deb1.sha256sum] = "4fd72af654e2a72c84093cc2a38c856fba9492ecd828721117867e99c2c9cd92"
SRC_URI[deb1.sha512sum] = "1bfb911abca5d714c3569854e75f4ecef6860c6e463196b3cfa9c6326e8c8216131118ee589e1bc76df9e9fe336148c0dd1291eebf0db1234be770d9f1e27e30"

RDEPENDS = " \
    libc6 \
"

