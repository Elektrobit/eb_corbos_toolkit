# This was autogenerated! Do not modify
SUMMARY = "fast, whole-buffer DEFLATE-based compression and decompression"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libdeflate"
HOMEPAGE = "https://github.com/ebiggers/libdeflate"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libd/libdeflate/libdeflate0_1.23-2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libd/libdeflate/libdeflate0_1.23-2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "7c4b5c0d85726d2d9475d48d3587c775"
SRC_URI[deb0.sha1sum] = "a4de19585b88f367cc983002e28820af8e9f129c"
SRC_URI[deb0.sha256sum] = "5fe37fb79d53f5c91da6ba3ac4c1a8453e1f2b1ff0e0ea45189c5338bbfdbf82"
SRC_URI[deb0.sha512sum] = "b94b16af4d5387285454797d64d7f1b25b6402efce97619f682537b4ebbd274baeb42337262c4ba40fec4d83c5c3d609c6ae4001d1e27ca1fcfb054b8314c704"
SRC_URI[deb1.md5sum] = "ef53f2a6a44d5b412f9c2661f374b689"
SRC_URI[deb1.sha1sum] = "7eec5cb1cd0acb9f0f4743a5de7c736b17570baf"
SRC_URI[deb1.sha256sum] = "ddd23094f9608f2ff9ea2256df2e917e315524371a6a82cb9daa921557c5a595"
SRC_URI[deb1.sha512sum] = "949db7bbab37657aece39919d891ec74f3dda82e9ca31c51adb1db5c046c86ea5091d255f78ab15503f407559d8fad147cf9ed8181f0f0e28cb6ea8bbfd71908"

RDEPENDS = " \
    libc6 \
"

