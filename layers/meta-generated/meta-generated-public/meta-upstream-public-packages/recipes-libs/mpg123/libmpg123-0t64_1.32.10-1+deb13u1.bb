# This was autogenerated! Do not modify
SUMMARY = "MPEG layer 1/2/3 audio decoder (shared library)"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "mpg123"
HOMEPAGE = "http://mpg123.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/m/mpg123/libmpg123-0t64_1.32.10-1+deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/m/mpg123/libmpg123-0t64_1.32.10-1+deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "3427e2d224dc6aafe70047378f5b50a4"
SRC_URI[deb0.sha1sum] = "d79d15e76653d5212254999493cb23006761371e"
SRC_URI[deb0.sha256sum] = "31fa6ef638f1fdbe198faee0b6fe50d9dd468077f8247cc3dbf6b2250abb6101"
SRC_URI[deb0.sha512sum] = "0f57247be4bce3c05dbe0e144c413c112e114907f2671943c5b748be82d9d16ad74de2760e971aff4c86e5755be9d800f4996d89da64221a39334dafca3c1f24"
SRC_URI[deb1.md5sum] = "5c158327f10d3d26263d0d8bc63ece66"
SRC_URI[deb1.sha1sum] = "885210a83e9e84a36b192e0ed978e57745fae317"
SRC_URI[deb1.sha256sum] = "d284df39ff3b64f1cdf274352613c52534c55eed82c3a2ff0fc7ba154acd7bf0"
SRC_URI[deb1.sha512sum] = "2a9aaa9ae6e6db5c2eb9cf62cbbb685ccb00f680b203dc45f580233bb982d1c90ead0f8c3cdccfd0fb403c5ce966c0522db34f55d985ea596bd3df2ee9d3e399"

RDEPENDS = " \
    libc6 \
"

RPROVIDES = " \
    libmpg123-0 \
"
