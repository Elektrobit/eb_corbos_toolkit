# This was autogenerated! Do not modify
SUMMARY = "lightweight messaging kernel (shared library)"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "zeromq3"
HOMEPAGE = "https://www.zeromq.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/z/zeromq3/libzmq5_4.3.5-1+b3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/z/zeromq3/libzmq5_4.3.5-1+b3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "10ace5f8fc2e1abfbc8c06196f6cfd99"
SRC_URI[deb0.sha1sum] = "97d0d5dcc6d3308773bfef779894edc169abe6e8"
SRC_URI[deb0.sha256sum] = "82348834b94ae5288dd1dde1c6a59488d30e3ee97fd4183c0b60ed79c3ab0b57"
SRC_URI[deb0.sha512sum] = "1bd70e6a46084319a5a0254d9ff068441cde7c5ba82477ade6f4238a3be5cf0f7c897d145fe37a0c08cca650e61f066d4b7fba9846960e4257d7d5c3739656c3"
SRC_URI[deb1.md5sum] = "24bb69a535d0991e04957c0367191cc9"
SRC_URI[deb1.sha1sum] = "dc60a1cad7763193ee36aad9311ea75c12b084e5"
SRC_URI[deb1.sha256sum] = "6a83a68a091963c59b00ea68b5ed78180206fb2d93fe32432c5be5dc9d624d1f"
SRC_URI[deb1.sha512sum] = "cd4b8f8109bb75d25bc42e18346d72121e9a131b2c5aba3262da85f19a0b9afa76da230a1ab07334e3bc375fa09fa38e78d3870ed179cf535466fc899543ef7b"

RDEPENDS = " \
    libbsd0 \
    libc6 \
    libgcc-s1 \
    libgssapi-krb5-2 \
    libnorm1t64 \
    libpgm-5.3-0t64 \
    libsodium23 \
    libstdc++6 \
"

