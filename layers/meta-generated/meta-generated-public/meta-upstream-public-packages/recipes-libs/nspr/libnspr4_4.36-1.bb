# This was autogenerated! Do not modify
SUMMARY = "NetScape Portable Runtime Library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "nspr"
HOMEPAGE = "http://www.mozilla.org/projects/nspr/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/n/nspr/libnspr4_4.36-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/n/nspr/libnspr4_4.36-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "dc825d7a7868119890f38608de1b5e21"
SRC_URI[deb0.sha1sum] = "30df8b2d965fb066b689def7a85c6a62cd8cea20"
SRC_URI[deb0.sha256sum] = "87fc2039ee89cff2b8010fa9535706b1def40031acfc52bf12197dcb3cb7b064"
SRC_URI[deb0.sha512sum] = "e9f930ea3c1cb9f031cd0705ca16180ddafbf1b859245ac96cff4465474e99ff14722d04c70e57c9d54b69c454416ff81505b925ec0a3fd9598d5627a5cbce1a"
SRC_URI[deb1.md5sum] = "c2f90f94fd029fa71bb749329f0f9e2d"
SRC_URI[deb1.sha1sum] = "762c7faff100136f62b8478560d4f87137e17a8b"
SRC_URI[deb1.sha256sum] = "b8cd0221e4c35a77ec6e3b89959ca96deb75919a3c55b6735ca0288a1b61bdbb"
SRC_URI[deb1.sha512sum] = "fa64b58a17a4ae957d70207c202f63d1da3500e4a7242082582161592aecff6cac1c3612a9f06e808bc97ad20cf0c0b4b7744f7b51b2226f4d804fb8b4c8e02a"

RDEPENDS = " \
    libc6 \
"

