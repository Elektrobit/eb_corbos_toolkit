# This was autogenerated! Do not modify
SUMMARY = "GD Graphics Library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libgd2"
HOMEPAGE = "https://libgd.github.io/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libg/libgd2/libgd3_2.3.3-14~deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libg/libgd2/libgd3_2.3.3-14~deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "8eec47d67886f21be6dd6b30e3207941"
SRC_URI[deb0.sha1sum] = "2e0b7dd6a7cf126c88e3e26e99653ddc1cfbec86"
SRC_URI[deb0.sha256sum] = "26814d821656ef587e841d186aa8be1e3794214acb7bdd0d938e2a6d172aa0a9"
SRC_URI[deb0.sha512sum] = "36967be7bdec0ac221010eef6e946e371ee367692d70648c98f86dbb365444be8b4e49abfd96f060cbc2157da3a6475c2edc333766d72da67c2e4b90192b649b"
SRC_URI[deb1.md5sum] = "8c9faa9e8a8910c10c738430a93c9a63"
SRC_URI[deb1.sha1sum] = "7a47b52199ffafa0b4162ccf17f1ed97b6ee4632"
SRC_URI[deb1.sha256sum] = "8664657bfecdd25ba555d27781f1a40f6bf05053d249c2997be8e250f8f353e9"
SRC_URI[deb1.sha512sum] = "2eda1204ceaf76556f54cdba259f8ca8dc5fe41fe9ce5dd093f9d0c9e9c9c513889b8898a9829ea8ff334908d61c0e934902b20d823abeaac6e66d78c423ba71"

RDEPENDS = " \
    libavif16 \
    libc6 \
    libfontconfig1 \
    libfreetype6 \
    libheif1 \
    libimagequant0 \
    libjpeg62-turbo \
    libpng16-16t64 \
    libtiff6 \
    libwebp7 \
    libxpm4 \
"

