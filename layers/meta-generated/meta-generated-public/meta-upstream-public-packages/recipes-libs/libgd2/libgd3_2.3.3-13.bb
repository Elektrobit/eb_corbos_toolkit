# This was autogenerated! Do not modify
SUMMARY = "GD Graphics Library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libgd2"
HOMEPAGE = "http://www.libgd.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libg/libgd2/libgd3_2.3.3-13_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libg/libgd2/libgd3_2.3.3-13_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "059ffa783dd2eeef6368470735a8a9d6"
SRC_URI[deb0.sha1sum] = "4c4f480af52f60a63e0b8219b4ec8f2fc31b8bd3"
SRC_URI[deb0.sha256sum] = "79ba1a3ceb098236c7fca7d896964eb478b0c3f368d5ec4fd2c1713788033af8"
SRC_URI[deb0.sha512sum] = "5b7837df089ecd44bff785ba04e8e2df5258c741638bbaebebf5ca8fa3309e93aa521ccbaa98419e2010937a15e9aed6233511f79f81eec348f23faa83f09caf"
SRC_URI[deb1.md5sum] = "34028ec3574d3ba591760115e191fdd7"
SRC_URI[deb1.sha1sum] = "d3966eb044fc62c73ff4f298b0e3552d7d222b21"
SRC_URI[deb1.sha256sum] = "399a4a092faa196c18ef14dc057afdd4b4254b354a1ee99fd2893677c27e5fdd"
SRC_URI[deb1.sha512sum] = "0d526f285582fdc945f4b094416a69bb2c2c09cb603f4a34d5fb311467ab3ac302071a36f216e49d8a27ae59acd1f4c00ed2276c8641d4cbcb4156a801eb9c26"

RDEPENDS = " \
    libavif16 \
    libc6 \
    libfontconfig1 \
    libfreetype6 \
    libheif1 \
    libimagequant0 \
    libjpeg62-turbo \
    libpng16-16t64 \
    libtiff6 \
    libwebp7 \
    libxpm4 \
"

