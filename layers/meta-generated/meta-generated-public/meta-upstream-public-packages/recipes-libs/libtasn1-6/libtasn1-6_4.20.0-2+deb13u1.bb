# This was autogenerated! Do not modify
SUMMARY = "Manage ASN.1 structures (runtime)"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libtasn1-6"
HOMEPAGE = "https://www.gnu.org/software/libtasn1/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libt/libtasn1-6/libtasn1-6_4.20.0-2+deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libt/libtasn1-6/libtasn1-6_4.20.0-2+deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "0dee8d137e0d8bbc8a57e721c13a5f66"
SRC_URI[deb0.sha1sum] = "16154349d857a93b3e689959b9cb2e72886edeb4"
SRC_URI[deb0.sha256sum] = "23fec6e06583ce2bad9b2c04c9b485e90440e259b1abf8677cd80d3ce60831ad"
SRC_URI[deb0.sha512sum] = "dbce58a92b174581b56b7f01c3ed36bb4b34c14dc1a77a43c6d69bcd4dfc397bb88420a41708b80b462ba291745f332cd5fcded45c64a479a0706aa8672d96c2"
SRC_URI[deb1.md5sum] = "99cc6b244eddd1b10a0c5ad1843da6c1"
SRC_URI[deb1.sha1sum] = "2cb2efefcc23a14be23a188f9f31e172c60ce261"
SRC_URI[deb1.sha256sum] = "e421da949cd26245f24c594265d6a01900b5e060e80793f68b977f7bfaa009ef"
SRC_URI[deb1.sha512sum] = "651b2505e6cebfd904e1d776aa6e6674292e36089b63b137c63dcfe5e363493d09329ebd719e861803401651d730ce0c4731296fa850480b656ef6abffac86bf"

RDEPENDS = " \
    libc6 \
"

