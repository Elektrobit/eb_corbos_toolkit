# This was autogenerated! Do not modify
SUMMARY = "C library for commands execution"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libexecs"
HOMEPAGE = "http://www.virtualsquare.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libe/libexecs/libexecs1_1.4-2+b2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libe/libexecs/libexecs1_1.4-2+b2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "b3534f369319025f3935b049659a5051"
SRC_URI[deb0.sha1sum] = "07d6444e74351143f26abcb2ca6b053319368c27"
SRC_URI[deb0.sha256sum] = "05b578fead365a81141fe834c3b3b6df89d17a050784a237f736489fbd426105"
SRC_URI[deb0.sha512sum] = "339242323a4156090df1632f31804f1376fa81507d5064bfaa2a0d2f19be69ed988bf53872b60b1a19bf343e5e19fc476ce9a201b9df518955166734a7ba98e7"
SRC_URI[deb1.md5sum] = "b693aaab59a010f8b2628ab8c46ba631"
SRC_URI[deb1.sha1sum] = "a95d90d50886897cfdf82f6402047b273b6839bb"
SRC_URI[deb1.sha256sum] = "749229c6aa58a6595db3352c4d3ac3bfbba6991e94a6196bec7d21624d33d88d"
SRC_URI[deb1.sha512sum] = "12ffdf68c65ca6b963b32b04e44d334d12de1cc5a6cbc1413faec81a5b559107d58a35499ec88b1e3fa33a72d74424ef9a621b66554fd4b3a1df8ae2a5e54891"

RDEPENDS = " \
    libc6 \
"

