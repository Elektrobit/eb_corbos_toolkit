# This was autogenerated! Do not modify
SUMMARY = "DVD navigation library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libdvdnav"
HOMEPAGE = "https://www.videolan.org/developers/libdvdnav.html"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libd/libdvdnav/libdvdnav4_6.1.1-3+b1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libd/libdvdnav/libdvdnav4_6.1.1-3+b1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "cb64dabb8f13d4fdb34f75c69fff0f1d"
SRC_URI[deb0.sha1sum] = "e80cd62e45c49c232cfb065aeebdd62adde97873"
SRC_URI[deb0.sha256sum] = "8368250b65cc26911fd37acdeeed58e9ce5bd390e941f687abecca9d5cd659f0"
SRC_URI[deb0.sha512sum] = "458e3b39baedd95bbedabeb3c151f2b2316ed1d3f02537ff190000d490005f6712c1485347cc16d516a9c772ecbede1c7447134b40eea7a2bd93946537d4c107"
SRC_URI[deb1.md5sum] = "3ea1993dd35373ae5bb2238312d9f548"
SRC_URI[deb1.sha1sum] = "f07725af07c23d7e679c7a5c7425b7756dcf30cf"
SRC_URI[deb1.sha256sum] = "42c7fbfbb8c048f64c5099d3a9174ebb510ef591022c0bbb0c6a03c5acd7c51c"
SRC_URI[deb1.sha512sum] = "91b8810900758c2f49dd090059983fa728618b9157383471481aee27fb722095c59a568dd1688b5f60dc61c976cb6f024a911d4450fbbae214d62f823b00477e"

RDEPENDS = " \
    libc6 \
    libdvdread8t64 \
"

