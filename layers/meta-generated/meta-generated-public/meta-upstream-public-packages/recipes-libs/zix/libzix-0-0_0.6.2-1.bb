# This was autogenerated! Do not modify
SUMMARY = "library of portability wrappers and data structures (shared library)"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "zix"
HOMEPAGE = "https://gitlab.com/drobilla/zix"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/z/zix/libzix-0-0_0.6.2-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/z/zix/libzix-0-0_0.6.2-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "ef3e9f3f75fe273c0d54217253d4bd86"
SRC_URI[deb0.sha1sum] = "0657ba339271b48c70ccd9e1963b9f2202b03e6c"
SRC_URI[deb0.sha256sum] = "896d3b244020120b17a21ded38508582ee861ffa90fc0fb0fd539e27698a96b6"
SRC_URI[deb0.sha512sum] = "737c18c1c9f9ca2530a1f1026c6c829a35a60cd9a4ed3d5b0039f500224dddb81e2c3060418d2181db7f6aa07b89e3b52514ba20ba96022a78f239f3a7f97dbc"
SRC_URI[deb1.md5sum] = "5dba540cca3fbe4aca18544249c6739f"
SRC_URI[deb1.sha1sum] = "5aa49882fd2a0b78e81966f4d66703de2c1950d5"
SRC_URI[deb1.sha256sum] = "6848ea4b2911b670c8b7bf106c932eabd715c56819af4998f77a09a6be69a479"
SRC_URI[deb1.sha512sum] = "bd5a188f0bb2f66d7ee88912be22e7929d41e7bbf54705ec428504e760ead6f93561e2a2ecb98818142be0bf4d300f2b2b6cf1ac3621ade9ba338d4cde71c811"

RDEPENDS = " \
    libc6 \
"

