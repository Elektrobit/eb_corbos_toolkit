# This was autogenerated! Do not modify
SUMMARY = "userspace USB programming library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libusb-1.0"
HOMEPAGE = "http://www.libusb.info"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libu/libusb-1.0/libusb-1.0-0_1.0.28-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libu/libusb-1.0/libusb-1.0-0_1.0.28-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "2a47b89544acfb2b882e96b8d00ab410"
SRC_URI[deb0.sha1sum] = "7bca87bb54a1b2dc90d598b224d70ce484e746d5"
SRC_URI[deb0.sha256sum] = "bb6467a002915c4ac464aa1b22204907951a30e43bcb86596ebd3539e84458e9"
SRC_URI[deb0.sha512sum] = "e947784c12eb8acc16627887e36012c20a100152fc33f5298b855b4cf171789ecabacb8d8db07c43eb7d2195269310da9f9211bbbe6f352471c8850c70f6c6c7"
SRC_URI[deb1.md5sum] = "1a592e22da33e4c20a0a1fe62f584140"
SRC_URI[deb1.sha1sum] = "5a56b39123022a801ba51b7dbec6e7fa1ea97145"
SRC_URI[deb1.sha256sum] = "1eed4dc72f3e6fe22dc8c20aba32f0c0c596a51d3e1c1e4c401937005e78ef11"
SRC_URI[deb1.sha512sum] = "e9ce6f96a8e2cd6d91b173c78933ed6136d6c9019e558d4ee61e4b31ded2a242dd7b3d3591751959b225218f34602bd07b8fab427800e702d8e42f8a9e9f7380"

RDEPENDS = " \
    libc6 \
    libudev1 \
"

