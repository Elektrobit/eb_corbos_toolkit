# This was autogenerated! Do not modify
SUMMARY = "GNU C Library: Shared libraries"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "glibc"
HOMEPAGE = "https://www.gnu.org/software/libc/libc.html"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/glibc/libc6_2.41-12+deb13u3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/glibc/libc6_2.41-12+deb13u3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "ac4d23a0d789d1d6463c3c80b585fbe6"
SRC_URI[deb0.sha1sum] = "11449623c6859d9164dff8aedbcf023edaddc513"
SRC_URI[deb0.sha256sum] = "8ffd13165b9ee3f067e2ee670df718e48c1bdaa18676ac93d1de761dbbb3913c"
SRC_URI[deb0.sha512sum] = "0cf9ff5890367dcd641c7b0e58006daa4e608a1f6fe9d10aed427cdacddba2f5537176b0b76a1aef71fccc40ca659b2112e8198ba746592ea505732209d6de22"
SRC_URI[deb1.md5sum] = "8f52fb06f1a025e23bd532569cd42ae3"
SRC_URI[deb1.sha1sum] = "8dd0cfbe0f5bd2c3923c8252c00c868bc6ac945e"
SRC_URI[deb1.sha256sum] = "ff529924782d3286181188fc265a6a92e7fe28975fb3a925dc0e05c0ca66e52f"
SRC_URI[deb1.sha512sum] = "05692b8258220d36333e8c76b6ab275d9ebc5efd598acf12106af05bd65b9f17f5ef3281410e6505507074d967ef8d6cac21043cdc0d4154b8afb8a0a2dc4a23"

RDEPENDS = " \
    libgcc-s1 \
"

