# This was autogenerated! Do not modify
SUMMARY = "GNU C Library: 32-bit shared libraries for AMD64"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "glibc"
HOMEPAGE = "https://www.gnu.org/software/libc/libc.html"

inherit dpkg-prebuilt

DPKG_ARCH = "amd64"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/glibc/libc6-i386_2.41-12+deb13u3_amd64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "02559087d931e94b34e645a9886a8471"
SRC_URI[deb0.sha1sum] = "38c0471cb20f4af3afd73447a11dfdbdd841e797"
SRC_URI[deb0.sha256sum] = "f64b92d5e5a50a03052a880d948d39492569509b4f60b53f0f9be34018cf68e2"
SRC_URI[deb0.sha512sum] = "a203532ba1a76dd8d2c4d47347883297a16288ca6bf900aa2c47349b70ba16feeeaed9a25d52687cc068a61a92ffe18d05328a2b9a3311c785d7305ea2134998"

RDEPENDS = " \
    libc6 \
"

