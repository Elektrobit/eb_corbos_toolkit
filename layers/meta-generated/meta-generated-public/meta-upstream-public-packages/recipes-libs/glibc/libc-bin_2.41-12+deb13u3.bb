# This was autogenerated! Do not modify
SUMMARY = "GNU C Library: Binaries"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "glibc"
HOMEPAGE = "https://www.gnu.org/software/libc/libc.html"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/glibc/libc-bin_2.41-12+deb13u3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/glibc/libc-bin_2.41-12+deb13u3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "06eb79a8b08db189e3bb64487bf980e9"
SRC_URI[deb0.sha1sum] = "9da59a3267c04db2c92a34345818c2cf320299ed"
SRC_URI[deb0.sha256sum] = "0105bbe1f317d8992bd73217ea9f3dd63e7f1195841f6aca346c570566628fb8"
SRC_URI[deb0.sha512sum] = "c366b012c328ff3e65d1d1ec91308f891d1605acd6b6a8fc174049ab83cbb6d2480139dc5de59c8cae6f31338214d50d034b9794353267050b8463b8862e5bf5"
SRC_URI[deb1.md5sum] = "5a9d63f88171d9515105d5b09ec24763"
SRC_URI[deb1.sha1sum] = "2f97c88e63e698b86775350598dea8efb421df45"
SRC_URI[deb1.sha256sum] = "02f366115bea79b87fe26c7dec4dc444f9fdcc76440905d88cc26dbef075511b"
SRC_URI[deb1.sha512sum] = "30bf0220cdd6b6b46427c58b0fbd536dfdc0948889f6f8aaea00b2f5174e9428532cb177f80949ad0e949fd6d2b5dde097cd0ae10d08c3437bf2e547d7191e70"

RDEPENDS = " \
    libc6 \
"

