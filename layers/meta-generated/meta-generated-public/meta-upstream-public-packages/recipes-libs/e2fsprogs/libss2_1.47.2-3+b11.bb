# This was autogenerated! Do not modify
SUMMARY = "command-line interface parsing library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "e2fsprogs"
HOMEPAGE = "http://e2fsprogs.sourceforge.net"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/e/e2fsprogs/libss2_1.47.2-3+b11_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/e/e2fsprogs/libss2_1.47.2-3+b11_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "a9398b2ca7be58034536623dcf85f283"
SRC_URI[deb0.sha1sum] = "458f436ed67e7f80aed736c6665c6b725301024c"
SRC_URI[deb0.sha256sum] = "879e8477dc20006e59788831e4f3a436d15afe3c055ae0e93beb96696f0e5eb1"
SRC_URI[deb0.sha512sum] = "cc5b552515e310eef798c118b3e64ea42ebd06a206972ff86573a24f299e687520440c227b8dac3a3d60d502454a6959b724ffba0c02a6e8e7f0aae36995e68c"
SRC_URI[deb1.md5sum] = "ae5f91a9a09dda59f2519dd48081ae69"
SRC_URI[deb1.sha1sum] = "c72507a8c5047a1bb85d488dcd0a9efc89d2d715"
SRC_URI[deb1.sha256sum] = "485551b5228b7ed05035a6340401de7e4fee59983d7ec633e827db5b279febc2"
SRC_URI[deb1.sha512sum] = "a003cbd26cc951e79abe85366c5158308c16773f6d5bd8a9b99f4adfe6c83189c321c759f9ca2d74d07bf08514ae2320ab72566abca316f3a50a5c11ba2f654c"

RDEPENDS = " \
    libc6 \
    libcom-err2 \
"

RPROVIDES = " \
    libss2t64 \
"
