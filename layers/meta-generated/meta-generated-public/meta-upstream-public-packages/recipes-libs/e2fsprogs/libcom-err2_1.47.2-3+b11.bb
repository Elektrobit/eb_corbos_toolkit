# This was autogenerated! Do not modify
SUMMARY = "common error description library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "e2fsprogs"
HOMEPAGE = "http://e2fsprogs.sourceforge.net"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/e/e2fsprogs/libcom-err2_1.47.2-3+b11_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/e/e2fsprogs/libcom-err2_1.47.2-3+b11_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "0fd0458472aad6a1a9020ad341d47543"
SRC_URI[deb0.sha1sum] = "e5c0dc0120b73d90c704cd68b3247561b7a47ebc"
SRC_URI[deb0.sha256sum] = "e1feff126b3e8b3a7b18087e88681469b70d8f6d1b7c4e4b89d98577e1a2fdd7"
SRC_URI[deb0.sha512sum] = "4d6ed71189e7790cfa249dbf2f184e01581b3b59294cfd6bd5a356f4d570fc5f7fb74d0a91ab75d6a36198b5febdf362d36beb95837971b466299c1447a348bb"
SRC_URI[deb1.md5sum] = "73e68c936dcd220da0ba1ae040e9e6f0"
SRC_URI[deb1.sha1sum] = "57c6f1e48acf1a7d7bf951d584aef37d5cbb909e"
SRC_URI[deb1.sha256sum] = "99aececea45aa2dcbd8689acd71c43f9c964be43f73b1dfeabcd51ef791f1e8a"
SRC_URI[deb1.sha512sum] = "9e540b20089974f9e92c4f1a83277cd2514c560df703db3d933750d8576763320584d6c391507e512973a7ad622c386aef99221cecc800efa04015c19d39c2a2"

RDEPENDS = " \
    libc6 \
"

RPROVIDES = " \
    libcom-err2t64 \
    libcomerr2 \
"
