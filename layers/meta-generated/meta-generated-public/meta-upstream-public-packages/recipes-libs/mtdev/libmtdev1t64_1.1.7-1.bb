# This was autogenerated! Do not modify
SUMMARY = "Multitouch Protocol Translation Library - shared library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "mtdev"
HOMEPAGE = "https://bitmath.se/org/code/mtdev/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/m/mtdev/libmtdev1t64_1.1.7-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/m/mtdev/libmtdev1t64_1.1.7-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "3e002fa42ab79be8b9fcbb2407cbd998"
SRC_URI[deb0.sha1sum] = "9f44e9c13688ccb01eb043dd2da53e167e872a49"
SRC_URI[deb0.sha256sum] = "736089af4684b6fe2fc824cb118c82a9722d6a31ad45f845998debe37714cbe5"
SRC_URI[deb0.sha512sum] = "279e75491ef43eec1f61a64f208093b91854698601841688ffed64dff8dab84eb6dfc744972510498a1e1b42a13bc28583e5a9336ea9a8f75b34d20ac0ef1c4f"
SRC_URI[deb1.md5sum] = "1752d7e79a4904a55bd86bb68c621259"
SRC_URI[deb1.sha1sum] = "5aac1150cd3e30d7919e2faa780e621571dccb7b"
SRC_URI[deb1.sha256sum] = "3433f77a9f96d0dc537e870db734a4dbb50528836782c86709845736e8897b47"
SRC_URI[deb1.sha512sum] = "45a5561de8832d6d80b1a10b188780923da48733ab334368a9edc94055037399213e232a1216b534029c6dbabed62fe45a7e2ff404ccc15152fa8a68de3b3750"

RDEPENDS = " \
    libc6 \
"

RPROVIDES = " \
    libmtdev1 \
"
