# This was autogenerated! Do not modify
SUMMARY = "Search engine library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "xapian-core"
HOMEPAGE = "https://xapian.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/x/xapian-core/libxapian30_1.4.29-3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/x/xapian-core/libxapian30_1.4.29-3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "0fbd57f5ba1ad84b7753b5678de74233"
SRC_URI[deb0.sha1sum] = "b48892a057338ce5e26eb4c4e056b45005958782"
SRC_URI[deb0.sha256sum] = "f2707a6cd37ac389318f0ab0c72e7017b26807e6d3dd1627f52070501ef7ba1a"
SRC_URI[deb0.sha512sum] = "3dc99daaa8ff3a1882d4f0cc6c780641da8689f621345c6638dd4ddc28b02ac45b90e21f3d339f17f36289519127c657a9a1530de2e7c269c8f8c04156b2484e"
SRC_URI[deb1.md5sum] = "5caafc0136c9fce6f5c34f76626e900e"
SRC_URI[deb1.sha1sum] = "b3cef6d6dfd6511f04a77442026f81811313012e"
SRC_URI[deb1.sha256sum] = "1652525c1c605b2169b3b27beecd01cbaa0e5abd7ec4d2029cbae2084dbde012"
SRC_URI[deb1.sha512sum] = "0fb15806aa3244a588f968e474ccd57dccbbb31fe705f8a24a5b217b6c041db38a0232ee178a0a4e35edf90eed33968a97b1099c2ae33d1aff00b7d291b88afc"

RDEPENDS = " \
    libc6 \
    libgcc-s1 \
    libstdc++6 \
    libuuid1 \
    zlib1g \
"

