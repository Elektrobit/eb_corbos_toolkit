# This was autogenerated! Do not modify
SUMMARY = "Library for Public Suffix List (shared libraries)"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libpsl"
HOMEPAGE = "https://github.com/rockdaboot/libpsl"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libp/libpsl/libpsl5t64_0.21.2-1.1+b1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libp/libpsl/libpsl5t64_0.21.2-1.1+b1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "09aa06d971ce5ff6d02b452c0e1f15f9"
SRC_URI[deb0.sha1sum] = "721d9692ffd65ded56bf4de880f199ec188aa04f"
SRC_URI[deb0.sha256sum] = "59d42bb1f9ebc0d1776fe616efb08a7a8568b05982e00f70b03c63863db768ab"
SRC_URI[deb0.sha512sum] = "bc85d6f65ea9d259d4b323bb6f50ea13ac2b2e0e91bce5db3ee274c90a2c5945f2ceb58b2981940d6f7a7f78e503c8aa5352295832cd67d78d88081657942fea"
SRC_URI[deb1.md5sum] = "b37c2d37e8e47ce7be994d38a9c8df24"
SRC_URI[deb1.sha1sum] = "e2dd263921705bcc2d84ddd13e6c719223630a4b"
SRC_URI[deb1.sha256sum] = "7ea03d8a7d16edce7b1b1e94980c058c0f1fb3c595eb9154b0e8590d0e7f75af"
SRC_URI[deb1.sha512sum] = "57beec78d33c6fd3904c5e8d7d0bc07bcc335dcba193a13d9297d4f27732f3481b7cb84a89074e7ed4a3cdea05d79a57e921886196882d10135adf3749c4fb24"

RDEPENDS = " \
    libc6 \
    libidn2-0 \
    libunistring5 \
"

RPROVIDES = " \
    libpsl5 \
"
