# This was autogenerated! Do not modify
SUMMARY = "regular expressions library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libonig"
HOMEPAGE = "https://github.com/kkos/oniguruma"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libo/libonig/libonig5_6.9.9-1+b1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libo/libonig/libonig5_6.9.9-1+b1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "307b75ad9aa737a908e7522ca716a453"
SRC_URI[deb0.sha1sum] = "7a8e995387646dadeecbaa160a3585ee84b24705"
SRC_URI[deb0.sha256sum] = "3abee130696244050500bcc7870e3b4cb82ddd87149ece3fd55010c3d4e1d18c"
SRC_URI[deb0.sha512sum] = "f37d46d7dcb85f404df49de036d16500bbfcb1be3f343a8d88fe1331c0750d4ed8922b308e8de929f41d143f5efd3d0bcae9b570112f1e29f0842e180fc9e3ac"
SRC_URI[deb1.md5sum] = "1debfb601bfc539391f030861f975887"
SRC_URI[deb1.sha1sum] = "113662b38ef8e746107870fcfd4e2cf5141981a1"
SRC_URI[deb1.sha256sum] = "137e708575c0622d347815d19cb471a107546b16e9602805ee27afad7bba107f"
SRC_URI[deb1.sha512sum] = "ab927683490cc360f05b643c602355107e3fc573d682bb38e04fa6d1c4cf916693895339adbe2c6688dfd39a82bc7253c4165525e051d04cd90e0d8d592b39d0"

RDEPENDS = " \
    libc6 \
"

