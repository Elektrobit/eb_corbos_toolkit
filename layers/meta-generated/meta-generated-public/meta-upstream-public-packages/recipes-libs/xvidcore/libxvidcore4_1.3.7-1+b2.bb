# This was autogenerated! Do not modify
SUMMARY = "Open source MPEG-4 video codec (library)"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "xvidcore"
HOMEPAGE = "https://labs.xvid.com/source/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/x/xvidcore/libxvidcore4_1.3.7-1+b2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/x/xvidcore/libxvidcore4_1.3.7-1+b2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "4aa9aca75ab3d5e4c06778649e1b9ad5"
SRC_URI[deb0.sha1sum] = "45fc7e2af44e7e0b97b86707a754102188419059"
SRC_URI[deb0.sha256sum] = "a3ea54e60cbc13dcd5f4a64c5635c52701274ae52baa9902d87ad742af4e4977"
SRC_URI[deb0.sha512sum] = "ad330a85f6bcfeb89a46bf63e4b5f8a832d640259ea0f8362ff24c8d8d992bbf7daf0689645f6382f87106bf82425b85b1a5715d4b350a487f63b0925e54c5d2"
SRC_URI[deb1.md5sum] = "2508c9b5840a7cde975ca96785bd8b93"
SRC_URI[deb1.sha1sum] = "f8420101d72d4c4807ca0fb033503aeda8785cb6"
SRC_URI[deb1.sha256sum] = "82ec04ee5561e5f01e0c93c4a7feb68252cd14a2cddf6622c006a01ea6bb0471"
SRC_URI[deb1.sha512sum] = "4dcf823e483dcc3e0e412ab205f187c5f8ae8d33f8dc494a2c380ee9c75929d2e0c19cf0076b2d728a071314dd94acf73f6744d9e5996158cadbdcc2ba45a3b8"

RDEPENDS = " \
    libc6 \
"

