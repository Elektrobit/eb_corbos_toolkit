# This was autogenerated! Do not modify
SUMMARY = "X11 Athena Widget library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libxaw"
HOMEPAGE = ""

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libx/libxaw/libxaw7_1.0.16-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libx/libxaw/libxaw7_1.0.16-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "d54f34f3ae3b3606c046386e7d432493"
SRC_URI[deb0.sha1sum] = "f5fbcc34625c1a9e67529ae9b06a8611bc9bc5a7"
SRC_URI[deb0.sha256sum] = "e79f3ab51ecbbfd3414a0568a8947ac59a29c30d631e6c7b6e07ea46e688c047"
SRC_URI[deb0.sha512sum] = "2532c3bb530b0b0f3238b121747e9550ac39702af47baf4441e1dcbe0dd8ce97caa8316709de7ddfc08a6ae8c76d442aafcc470e65cce97aff94c83bb568abfe"
SRC_URI[deb1.md5sum] = "0c9a1c950a3fd761db8d3fc96f7eead6"
SRC_URI[deb1.sha1sum] = "effe96def9853ee7f694573506e984b0824d9730"
SRC_URI[deb1.sha256sum] = "93a4df735b3986c3688bb24fe05add09eba807fca2d885ab280e48d093699337"
SRC_URI[deb1.sha512sum] = "fffcfcd57d269a9410dd808a4b891b9448b38f9b1fc803dcbc58bacfe113e82477720dbd43c1f35832a8cdf161445a129d412313f8bb939a05d13683781810ec"

RDEPENDS = " \
    libc6 \
    libx11-6 \
    libxext6 \
    libxmu6 \
    libxpm4 \
    libxt6t64 \
"

