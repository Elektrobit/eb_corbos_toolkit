# This was autogenerated! Do not modify
SUMMARY = "C library for encoding, decoding and manipulating JSON data"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "jansson"
HOMEPAGE = "http://www.digip.org/jansson/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/j/jansson/libjansson4_2.14-2+b3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/j/jansson/libjansson4_2.14-2+b3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "d5e30120616c31e7cfb1bf082babdcb2"
SRC_URI[deb0.sha1sum] = "863b42d49fe03ddab657301ee6c8f4a066b3bcdf"
SRC_URI[deb0.sha256sum] = "60707a62fe6c1228c3389b12a13ca4efd76defc5532473e547a29e99cf7d2a6e"
SRC_URI[deb0.sha512sum] = "b657e60922d966c70cd7da68bcbf3ae74766e3bf616c04cb12b22f5e2b046fe54147e23f07b2fb5ce3af14787f5fc7175509cc253e5109324c622be1e7604740"
SRC_URI[deb1.md5sum] = "eba75780228ac41e7d210f0e2636586b"
SRC_URI[deb1.sha1sum] = "e4a741bee41db8c2c47f74266f426cd7cd2b395f"
SRC_URI[deb1.sha256sum] = "7938472b1ddfa8b0c8f58d5f44406ae7a77a342dbb502a02f6bf292b4f853ab0"
SRC_URI[deb1.sha512sum] = "4595daea97afe6819e5645ea7656d22265b254dc46103cdf71baaf08157671f8c303bca4a1b7a4fd3b42aaf70006288fdcee6f3e5b599b9a3af2f5965a21735b"

RDEPENDS = " \
    libc6 \
"

