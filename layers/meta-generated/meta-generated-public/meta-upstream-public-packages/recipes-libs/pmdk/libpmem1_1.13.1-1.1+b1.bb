# This was autogenerated! Do not modify
SUMMARY = "Persistent Memory low level support library, v1 runtime"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "pmdk"
HOMEPAGE = "https://pmem.io/pmdk/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/pmdk/libpmem1_1.13.1-1.1+b1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/pmdk/libpmem1_1.13.1-1.1+b1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "e64516d28e7901ba3fa67ede5d89d98f"
SRC_URI[deb0.sha1sum] = "6b724853b3ad0edf6b187873058b140b5e2630b0"
SRC_URI[deb0.sha256sum] = "7d972d6958e915ce602e4b90debc6b4b91a01dfea1fe003d0b013756e7d9d863"
SRC_URI[deb0.sha512sum] = "fa3c2627e86486e084b61dd2ccc40a8294e46a087a60ee97e13bda3e7f72486736bdda55b9d2d506b20c7f1cf5a084823aef445be71ab163f11045134a0d6bb5"
SRC_URI[deb1.md5sum] = "484dd04839164ec1a3f418ed18704770"
SRC_URI[deb1.sha1sum] = "fbaaaf38cad78d8939a5c1a44efa0b1603166712"
SRC_URI[deb1.sha256sum] = "6fb4d7569f301d279211f0bc53cda7c21324aec7f2b7e4c8ed30928bbeb88384"
SRC_URI[deb1.sha512sum] = "37dc429cc6fd984fa5a684f11e07101bf7d989d4b6ebe908b6eee076367e3f8c4b60cfacff70e50c5399c3034f017e3f47d78c4bdcfb6ed401c64fdb2687ae49"

RDEPENDS = " \
    libc6 \
    libdaxctl1 \
    libndctl6 \
"

