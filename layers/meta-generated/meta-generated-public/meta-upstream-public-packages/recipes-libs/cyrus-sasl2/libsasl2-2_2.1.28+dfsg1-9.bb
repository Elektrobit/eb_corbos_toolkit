# This was autogenerated! Do not modify
SUMMARY = "Cyrus SASL - authentication abstraction library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "cyrus-sasl2"
HOMEPAGE = "https://www.cyrusimap.org/sasl/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/c/cyrus-sasl2/libsasl2-2_2.1.28+dfsg1-9_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/c/cyrus-sasl2/libsasl2-2_2.1.28+dfsg1-9_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "35ad5deb812b880a16b7ae25bbfcc6b9"
SRC_URI[deb0.sha1sum] = "d33dd3ff8f88f8ae9a84bad1df925ea1b2ea0904"
SRC_URI[deb0.sha256sum] = "66e49d7ae026811b49a0050f18b0325960a2625ffd1ff60d91b7844a815fa9d2"
SRC_URI[deb0.sha512sum] = "2e9161abd3ddeeb61401b3a619503a6b35da424df8b1bad1836517278803126c78e7e87a93257712baa56d71a7450694fe60a1351283df692091b5c91e500e29"
SRC_URI[deb1.md5sum] = "40968331034e5b1e1e95d4afa8c034f9"
SRC_URI[deb1.sha1sum] = "f4d51b39388744bebe4397b78f9e2f1f9f9827fc"
SRC_URI[deb1.sha256sum] = "6431628c62524c8397255c1c4a7c7ef63661b801f3be9a59ad41e7a2e46e6210"
SRC_URI[deb1.sha512sum] = "c748f6a8558fad5cea7776eac7782574ff3743e1ff6b3d586781d0e3f0d07a8c40ea1e762cf1f8207d7a04a55b38a94fef9fb40bb7271225ac54f53ef94158bb"

RDEPENDS = " \
    libc6 \
    libsasl2-modules-db \
    libssl3t64 \
"

