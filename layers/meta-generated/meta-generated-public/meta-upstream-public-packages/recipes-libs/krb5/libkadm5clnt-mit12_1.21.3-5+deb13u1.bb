# This was autogenerated! Do not modify
SUMMARY = "MIT Kerberos runtime libraries - Administration Clients"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "krb5"
HOMEPAGE = "https://web.mit.edu/kerberos/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/k/krb5/libkadm5clnt-mit12_1.21.3-5+deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/k/krb5/libkadm5clnt-mit12_1.21.3-5+deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "8b5dc6b0b79ee8260f7c94a16302a5f8"
SRC_URI[deb0.sha1sum] = "64500bec63771ac0a9d2ae023dcca492449d4046"
SRC_URI[deb0.sha256sum] = "9d1271f9ef8d3d308e1d9373cccc59de0e2b2b62b0ddd39cffd76cb18af24bb2"
SRC_URI[deb0.sha512sum] = "9511baa6451e73abe27ac16386dd4826dc87eaaa08f21f36ca1cfa9dac452ed89544566796191242787bc1b0d6c60b4e5fa0e06242bf9eafa2587cb1ed15f124"
SRC_URI[deb1.md5sum] = "780d0d1e0cb23d7ef34385f33aec85b6"
SRC_URI[deb1.sha1sum] = "8b887f649062f40f075aa83a348b8a477109df33"
SRC_URI[deb1.sha256sum] = "96da21fca7d97b42d6be881e22648f842ecbe481ee9051d21279696f02170e31"
SRC_URI[deb1.sha512sum] = "049b3573783eceb4cfc418e9a2b4b67270097778ae7cc4a2290c5b9ea8828e88434e65afdf00ff8d4ab0331252b5ea80fc7d097e4ecef159acbfe308546c493b"

RDEPENDS = " \
    libc6 \
    libcom-err2 \
    libgssapi-krb5-2 \
    libgssrpc4t64 \
    libk5crypto3 \
    libkrb5-3 \
    libkrb5support0 \
"

