# This was autogenerated! Do not modify
SUMMARY = "MIT Kerberos runtime libraries"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "krb5"
HOMEPAGE = "https://web.mit.edu/kerberos/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/k/krb5/libkrb5-3_1.21.3-5+deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/k/krb5/libkrb5-3_1.21.3-5+deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "c79f19d86512fadcbff5efa5317c23fb"
SRC_URI[deb0.sha1sum] = "53d94056269d541890f7e1bc61b4face03061af6"
SRC_URI[deb0.sha256sum] = "47d71d6a7f2e59b9bae5f89602397594805113b95889ad18fa703cd53abafc97"
SRC_URI[deb0.sha512sum] = "6e43febc5181dde1a3ec623e6bbf38f873a6f856c13ab18b3af7f682e97c2b5bcc644e9724bb200ba1742ca9db039bf31b5857af403d477195d26d396fed398c"
SRC_URI[deb1.md5sum] = "11797c4ef48f45575581133a114f97ae"
SRC_URI[deb1.sha1sum] = "31362ffd7d1d1733ff3dcd0f9c8707e8541eff27"
SRC_URI[deb1.sha256sum] = "1f5c46480abf894f662d894696c8a6c6510c2b20616cd453e88b27b11d3be25d"
SRC_URI[deb1.sha512sum] = "4369924ea8e8ca2500e2376ca79ec979f987b89361feb2735884973a75191c286914fffc79ac2c1b5f437f835b8c4ef41181c3b118fae5a84294f4ebcfc337b1"

RDEPENDS = " \
    libc6 \
    libcom-err2 \
    libk5crypto3 \
    libkeyutils1 \
    libkrb5support0 \
    libssl3t64 \
"

