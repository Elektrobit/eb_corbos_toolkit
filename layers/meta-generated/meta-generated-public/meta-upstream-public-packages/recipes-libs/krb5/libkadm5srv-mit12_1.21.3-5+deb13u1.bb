# This was autogenerated! Do not modify
SUMMARY = "MIT Kerberos runtime libraries - KDC and Admin Server"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "krb5"
HOMEPAGE = "https://web.mit.edu/kerberos/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/k/krb5/libkadm5srv-mit12_1.21.3-5+deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/k/krb5/libkadm5srv-mit12_1.21.3-5+deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "f25c0b43662b62b037a0275535d973a5"
SRC_URI[deb0.sha1sum] = "702103741c2faa85caf66917f3ea762e17891137"
SRC_URI[deb0.sha256sum] = "ab608b7692bcb980957c2dc83da291fa58e065955fdc6c0882c66d26502693ca"
SRC_URI[deb0.sha512sum] = "c4217a2143b13c0baec95bf576f63be933a37f9e96c9059fb3f268a57657b7913027d1d738cbd04a1c7f94cb4a6189266da3b081bf580dc49cd7c5405f4ab633"
SRC_URI[deb1.md5sum] = "5d9f74c10fcfd2fde7e2de177e5de15c"
SRC_URI[deb1.sha1sum] = "5545c41ec7e7c983b9b966ba46680f4b6954f5ad"
SRC_URI[deb1.sha256sum] = "9e25c202e883de84c2c37d8cc10cadc8fd5538cd4227a1b9f4f160ece94756d6"
SRC_URI[deb1.sha512sum] = "ae2b95b1ea4fbe6504f1253c1b50e9d30d5f719a6fc5a45a2ae150fe33babe815fa21559c0025afc84fe02b2683b8fe66b91c3cdde5607d5a321fa26f17adf04"

RDEPENDS = " \
    libc6 \
    libcom-err2 \
    libgssapi-krb5-2 \
    libgssrpc4t64 \
    libk5crypto3 \
    libkdb5-10t64 \
    libkrb5-3 \
    libkrb5support0 \
"

