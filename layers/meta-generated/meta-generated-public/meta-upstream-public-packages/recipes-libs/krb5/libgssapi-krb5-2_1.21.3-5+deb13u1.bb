# This was autogenerated! Do not modify
SUMMARY = "MIT Kerberos runtime libraries - krb5 GSS-API Mechanism"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "krb5"
HOMEPAGE = "https://web.mit.edu/kerberos/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/k/krb5/libgssapi-krb5-2_1.21.3-5+deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/k/krb5/libgssapi-krb5-2_1.21.3-5+deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "9d93b5d1adb11eec662012c1b7dcd33b"
SRC_URI[deb0.sha1sum] = "ddecd0f8bcc988780e6e7811c9c25e68e776b386"
SRC_URI[deb0.sha256sum] = "30847c1fde4240567d7ed3aeab4f655dd591203758b857e85e824045aae70299"
SRC_URI[deb0.sha512sum] = "bb0b703bd8d5ea68442a688200130bfe1d6c6ae2f484ca2098fefc0021c3cfefd6892a4e23a580e5b2326a3ef8eb75e944fc955cde6965508df07793aed43bbe"
SRC_URI[deb1.md5sum] = "c6764c2e97c8a986f6d2ee2fd774876d"
SRC_URI[deb1.sha1sum] = "a2f753f9acabb068db86ee66db359a6bd3752aba"
SRC_URI[deb1.sha256sum] = "70803e8f5b9dd0a7167671bdd0b3cd05642384c1fc49e8270d340d85bf6c7d4c"
SRC_URI[deb1.sha512sum] = "8c708c7360199aaf1b14553a9e9c313740d3536caf1c20cc59d60d77411258a9ee98a45c8f9aae3fd1ed270d47ae5fec8a913c5d211a5306a0218fade3b34afa"

RDEPENDS = " \
    libc6 \
    libcom-err2 \
    libk5crypto3 \
    libkrb5-3 \
    libkrb5support0 \
"

