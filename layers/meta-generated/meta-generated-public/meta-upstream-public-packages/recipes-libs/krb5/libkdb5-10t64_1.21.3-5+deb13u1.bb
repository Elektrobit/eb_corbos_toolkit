# This was autogenerated! Do not modify
SUMMARY = "MIT Kerberos runtime libraries - Kerberos database"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "krb5"
HOMEPAGE = "https://web.mit.edu/kerberos/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/k/krb5/libkdb5-10t64_1.21.3-5+deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/k/krb5/libkdb5-10t64_1.21.3-5+deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "1d8834fcd3d4f72276f07b4d400b2e1e"
SRC_URI[deb0.sha1sum] = "1f3d85ab7aca5a5c13467a1bd5d90e41e4da1241"
SRC_URI[deb0.sha256sum] = "d6d4ec516fe87c545862b117bc5cec294cabf06319c400720ec6c01bc215b79f"
SRC_URI[deb0.sha512sum] = "831844fa404b95941ed458aa3280a7772c5fe66ecb5c287a2106783031d3b3c50cdd822347e414d5564ebcbfd66bcbba3b9c34706227cd4e13b19b91936ba96a"
SRC_URI[deb1.md5sum] = "d6f8cb2654c93d96627e1f28667d6b7a"
SRC_URI[deb1.sha1sum] = "73b0e2aeb7a470d7ffbc46e1cb6c1024266cc4ae"
SRC_URI[deb1.sha256sum] = "169c3d2264a37097003051022e9596a6c2dc906fc8302ac0d95b566fcc00d9c3"
SRC_URI[deb1.sha512sum] = "ca3741f3d1ba7149b43f4c8dd2ccc56e00d974c8d0df6ba3fb5f9f6034c3319a840c2d6745d7d6ad2e591a3135464191c5faff04b01d9318cc0051d4f480f149"

RDEPENDS = " \
    libc6 \
    libcom-err2 \
    libgssrpc4t64 \
    libk5crypto3 \
    libkrb5-3 \
    libkrb5support0 \
"

RPROVIDES = " \
    libkdb5-10 \
"
