# This was autogenerated! Do not modify
SUMMARY = "MIT Kerberos runtime libraries - Support library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "krb5"
HOMEPAGE = "https://web.mit.edu/kerberos/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/k/krb5/libkrb5support0_1.21.3-5+deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/k/krb5/libkrb5support0_1.21.3-5+deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "20061bfd85a525d45bdce33e5300c43c"
SRC_URI[deb0.sha1sum] = "fdcbf424c12036172b67ed2d13d14fa441fb3736"
SRC_URI[deb0.sha256sum] = "3a0acd8b37955c0e102c756b52c97df2a31f67b96453c35dab70df218d309117"
SRC_URI[deb0.sha512sum] = "ee07907dd208128da5422a1bacdab02c75a1162abd2350755515ff1f1ab2bce839f5a3dfa8c15758e541205eeb57b691e2d5203808b8cd7803d48e1daaa3a6af"
SRC_URI[deb1.md5sum] = "45ad6610821eb7a7f7041f3ec8749cc7"
SRC_URI[deb1.sha1sum] = "0eddb1b8b65c0b07c31fd32c0cdf69bbc0dc5c0a"
SRC_URI[deb1.sha256sum] = "6381bcb54e58854f9ebac2dfa580c3d6112d01b4ca3f725e7263b9374f79608e"
SRC_URI[deb1.sha512sum] = "dff6bb37c6969f19303f57c5aeb1363a887b5d9c9fe94ad127ee4a73ed05400c55fe47a0d7e107a12b75a74c49ff56cd960e9f7e27e05fe6e5b72c8c1e792165"

RDEPENDS = " \
    libc6 \
"

