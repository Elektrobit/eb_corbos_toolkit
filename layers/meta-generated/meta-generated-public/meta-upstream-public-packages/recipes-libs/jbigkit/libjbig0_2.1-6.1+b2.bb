# This was autogenerated! Do not modify
SUMMARY = "JBIGkit libraries"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "jbigkit"
HOMEPAGE = "http://www.cl.cam.ac.uk/~mgk25/jbigkit/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/j/jbigkit/libjbig0_2.1-6.1+b2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/j/jbigkit/libjbig0_2.1-6.1+b2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "590134f899b900c7c9f8f87cf750ea63"
SRC_URI[deb0.sha1sum] = "eb369aacf6dd6ae54fefdbed4e4fe9775e07227c"
SRC_URI[deb0.sha256sum] = "95cbc44561651e1b3385454df08e8f2efe84498f6963a85259be2cc2fe798709"
SRC_URI[deb0.sha512sum] = "591d69b74c7db7cc3537be5b2a3a44ea3ee1b179c7935593303ef9bb92e04beaa259d60380487e5cd497a58d073b7f7e963c2090148a582f741f5900ab361ed5"
SRC_URI[deb1.md5sum] = "06074eb18d154d8cac04b97ed90bd262"
SRC_URI[deb1.sha1sum] = "67848c5723c8af1efc7e651164fc5f95a36d6961"
SRC_URI[deb1.sha256sum] = "dbecef09dbafd82ff6444aa1cb45053b6331985b20ab2590eff052d7d6b1bb18"
SRC_URI[deb1.sha512sum] = "5bb7bdbfb115f0a359d3f082f89bbf431d061fd3154f5823160f7eb4f7a36e20ee494e8e79df510da19c90e1714a7caa38b888e93a35bb648b2a45e831814ca8"

RDEPENDS = " \
    libc6 \
"

