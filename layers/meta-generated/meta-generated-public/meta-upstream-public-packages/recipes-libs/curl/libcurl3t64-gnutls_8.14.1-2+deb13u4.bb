# This was autogenerated! Do not modify
SUMMARY = "easy-to-use client-side URL transfer library (GnuTLS flavour)"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "curl"
HOMEPAGE = "https://curl.se/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/c/curl/libcurl3t64-gnutls_8.14.1-2+deb13u4_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/c/curl/libcurl3t64-gnutls_8.14.1-2+deb13u4_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "9afc089158cea4cbc7cf26c951b600bf"
SRC_URI[deb0.sha1sum] = "fc9862af999f25dc56621d2654b95f17b267d991"
SRC_URI[deb0.sha256sum] = "351bf3bb1c816c1d88900cbfe59dc79433f20fb962947d78313028a00f97c856"
SRC_URI[deb0.sha512sum] = "bd26d3a4d508c35f850c8048d677296b438eeed6e89fbbd6112413913ef9f7883f8bf09111c0ed384f31b400d105e077c1ae47956d163620a34eea1454ae4b3a"
SRC_URI[deb1.md5sum] = "f4f7136cafe22e7c1ebe48867f6bcbbc"
SRC_URI[deb1.sha1sum] = "99f1bb62c8f240a90373a92507d3879d22fa8c74"
SRC_URI[deb1.sha256sum] = "ac6e47bea2aaecd61e789c95595ff20f63f3767a30748db010077ee32e209f7b"
SRC_URI[deb1.sha512sum] = "3c9bf72bff748e22ea8db345900491a9e82bac07232ab67c38e87c7f6b5ee022afc7bd01753e86ad3301260e87b44e10bdd1ed21991462215e66ff955299b03e"

RDEPENDS = " \
    libbrotli1 \
    libc6 \
    libgnutls30t64 \
    libgssapi-krb5-2 \
    libidn2-0 \
    libldap2 \
    libnettle8t64 \
    libnghttp2-14 \
    libnghttp3-9 \
    libngtcp2-16 \
    libngtcp2-crypto-gnutls8 \
    libpsl5t64 \
    librtmp1 \
    libssh2-1t64 \
    libzstd1 \
    zlib1g \
"

RPROVIDES = " \
    libcurl3-gnutls \
"
