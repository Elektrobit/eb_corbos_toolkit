# This was autogenerated! Do not modify
SUMMARY = "minimalistic Netlink communication library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libmnl"
HOMEPAGE = "https://netfilter.org/projects/libmnl/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libm/libmnl/libmnl0_1.0.5-3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libm/libmnl/libmnl0_1.0.5-3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "7e77017e08e0d3ca64e080b125620089"
SRC_URI[deb0.sha1sum] = "6ba7c9fde78a65f23c3c430e2d6c946bb757d73f"
SRC_URI[deb0.sha256sum] = "4ec9c1096e0b954e3bdb03a62314ee7f49999045d3d55be3e4ded520ffc9baf5"
SRC_URI[deb0.sha512sum] = "e90e1af413b458515261221f7d88576bbdcdd4a1ef789c97616a2de8e1d97d503f4136627466db73ac3f7654e379fa21805b3b7a999b96cbcc66873987704056"
SRC_URI[deb1.md5sum] = "07f2ae28aa342ca7db5f4eec38f990fa"
SRC_URI[deb1.sha1sum] = "b90731b6e5689de09c4996b702e2d962606f5069"
SRC_URI[deb1.sha256sum] = "f21bb29056e9ede0031cc411ffa3b1272858fa4b950e1cd9e50756c5c2ece97f"
SRC_URI[deb1.sha512sum] = "1caad469e482af3e786be8caeb13cd1f09d2a34759e77985479b8197f2d6a7e9ae895b19a4999182a88b2e00c771dbc79dc87ed2b2fe0044166f89163378918b"

RDEPENDS = " \
    libc6 \
"

