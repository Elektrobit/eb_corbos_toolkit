# This was autogenerated! Do not modify
SUMMARY = "library implementing DNS resolution and validation"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "unbound"
HOMEPAGE = "https://www.unbound.net/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/u/unbound/libunbound8_1.22.0-2+deb13u3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/u/unbound/libunbound8_1.22.0-2+deb13u3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "c773c243298811c6336756b8317e6fe3"
SRC_URI[deb0.sha1sum] = "a4f2f5b9d8c0868a58a897e71aaa617becafa7af"
SRC_URI[deb0.sha256sum] = "39e4e5bc6f870bf8fd77e45b36588c76bf0a7f2ec1c8f9b4416b0aa662b1c521"
SRC_URI[deb0.sha512sum] = "a24862fe89da988d1b07f0698e327389b64de13e2f9375814093dc071d0b42ac167dbae4de053a668574e0d028da632944b5cc3eb0c09bb70c6111b9109451c3"
SRC_URI[deb1.md5sum] = "39cc63fb456cf5c52bbed420c2b580e0"
SRC_URI[deb1.sha1sum] = "4a3390b3c79480635f87ecb6ab31af2c8000104d"
SRC_URI[deb1.sha256sum] = "8b173b9fceffe7195084dc6d9eb93d8efb0866f8cfd565f0c5f376896ebc84fa"
SRC_URI[deb1.sha512sum] = "f29a3e2f2bc8d60868635ea0782fa024b80460d1aba60acdbb0fb8f30b368e9b86da411c936fc8a6c99834c1c61ffa74efa1afd1286944cba92f3a92ea6c227d"

RDEPENDS = " \
    libc6 \
    libevent-2.1-7t64 \
    libssl3t64 \
"

