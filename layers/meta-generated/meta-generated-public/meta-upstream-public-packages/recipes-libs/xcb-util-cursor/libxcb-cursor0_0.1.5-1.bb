# This was autogenerated! Do not modify
SUMMARY = "utility libraries for X C Binding -- cursor"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "xcb-util-cursor"
HOMEPAGE = "http://xcb.freedesktop.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/x/xcb-util-cursor/libxcb-cursor0_0.1.5-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/x/xcb-util-cursor/libxcb-cursor0_0.1.5-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "48da7e067100e8eb186fd407928f25ef"
SRC_URI[deb0.sha1sum] = "c4f40446c5ee59f8c8f1d3117be83b9dc864b602"
SRC_URI[deb0.sha256sum] = "e0c77e6e96843581ff2668dc9a10f676be0e78209ef198e98646184858efe164"
SRC_URI[deb0.sha512sum] = "9082507923390522b444039ae47eb577b4e19c3fe45860af59c4472237edde8e9fabd207b8a788fd2708c0b2de0608e823d5c797922f814554f0eec8196b70b4"
SRC_URI[deb1.md5sum] = "305f30f79e11ef6cde97d1f43d1a9a45"
SRC_URI[deb1.sha1sum] = "d65ee70cea3d3f0df88d92acd389ac4b9359a6c6"
SRC_URI[deb1.sha256sum] = "1cb16052bb33d6d2479b4b1dde95b1252a7fcdc5672d0fff72676b3bdf5e66e1"
SRC_URI[deb1.sha512sum] = "422a4857dfde090cb799d1f0d0eb2089114be2df41a9244abfe02cfd54bdbba6b6d717c4565b43bf825549eeaaacf495ba175821f9dcc0250396ee548cec9cb9"

RDEPENDS = " \
    libc6 \
    libxcb-image0 \
    libxcb-render-util0 \
    libxcb-render0 \
    libxcb1 \
"

