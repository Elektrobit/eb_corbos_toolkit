# This was autogenerated! Do not modify
SUMMARY = "Free Implementation of the Unicode BiDi algorithm"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "fribidi"
HOMEPAGE = "http://www.fribidi.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/f/fribidi/libfribidi0_1.0.16-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/f/fribidi/libfribidi0_1.0.16-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "c9ab7bfcaf0a0aac06818ca8d52414cd"
SRC_URI[deb0.sha1sum] = "8cd8558083733fbd4797157049a64357c59cadd7"
SRC_URI[deb0.sha256sum] = "f8c35ec8606d0843bd3cf020c6cfa39ddfe717ec58ed826b5855ba9927eb0d55"
SRC_URI[deb0.sha512sum] = "affa5cee1a9ad03b93027e7492b629fff2f8e7670dc8ceb10ee29e3c757eec31b8295265284e82dd5c56b3c27925f3dc271b8dde852f611a86ef391b1cddcf50"
SRC_URI[deb1.md5sum] = "751408d7b244f927f90ac9594fbadc75"
SRC_URI[deb1.sha1sum] = "859b302ab5fde6d681e47510aced93ce59de4778"
SRC_URI[deb1.sha256sum] = "5f5bfdf6ef126b0a38f8ebb8751cbbb845fe2cd4e1dd5258d241be243e09897f"
SRC_URI[deb1.sha512sum] = "fb5dd6b0e9015341651452ba620bfb8e66c8a4eedcc6f6344b47b5d66a978cddf11f9f058c5606e1ff57693f6aa42055bef327e13dd72175c0ecf10da6ae5a0e"

RDEPENDS = " \
    libc6 \
"

