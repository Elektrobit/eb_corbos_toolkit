# This was autogenerated! Do not modify
SUMMARY = "Netfilter netlink-conntrack library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libnetfilter-conntrack"
HOMEPAGE = "https://www.netfilter.org/projects/libnetfilter_conntrack/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libn/libnetfilter-conntrack/libnetfilter-conntrack3_1.1.0-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libn/libnetfilter-conntrack/libnetfilter-conntrack3_1.1.0-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "0e414478d1f985f25e82ff2c75a98d5e"
SRC_URI[deb0.sha1sum] = "ede83a59aec5cf0e3703abf97acc21252dff3525"
SRC_URI[deb0.sha256sum] = "ffbac5d06fbe432d5171f2eb5b2504968377f27be133f72c81e71250a9957506"
SRC_URI[deb0.sha512sum] = "6231f16369be109318e36d61b1f1eb5800c0085f96976a87fc6b861f38aef1fce90addf11323dbf19ca6670ccaed416e553da78fe33ed4845030f6f75400f352"
SRC_URI[deb1.md5sum] = "068d9024be70d8272bec0d82d806f432"
SRC_URI[deb1.sha1sum] = "4285de9914ddc4b65ac266ff56b3d48c70ca0b0c"
SRC_URI[deb1.sha256sum] = "25593af074c89564f903aa34acb7828a47171e232dfb4ea3457f5319c98d0a4c"
SRC_URI[deb1.sha512sum] = "2a8b200ae65c16fdda4775fee1d8b0859b4ec781b4a049835f9fecee6ca717e81e2913dc792a71e1d79e6f29cce9f5495f77eb7c5945f2f749b2d0a3c9539d8d"

RDEPENDS = " \
    libc6 \
    libmnl0 \
    libnfnetlink0 \
"

