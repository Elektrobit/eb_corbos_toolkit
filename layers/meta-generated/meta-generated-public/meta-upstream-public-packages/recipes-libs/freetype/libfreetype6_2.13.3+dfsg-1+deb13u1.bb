# This was autogenerated! Do not modify
SUMMARY = "FreeType 2 font engine, shared library files"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "freetype"
HOMEPAGE = "https://freetype.org"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/f/freetype/libfreetype6_2.13.3+dfsg-1+deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/f/freetype/libfreetype6_2.13.3+dfsg-1+deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "0994fdb58c0168b608cd1e285deda3d2"
SRC_URI[deb0.sha1sum] = "2602e72ebeb8d5aa36eb1cc60f1cabfbd7558f43"
SRC_URI[deb0.sha256sum] = "e4947f3291528f03d574f2b01d5c5fc45c58c47480f32888a5cdf0f231ab584e"
SRC_URI[deb0.sha512sum] = "69aec83b20d7f168889fe1d8be181a0d94e3331208f488fb48ae58f532c2d444382f9830020ba3df741c74cfb348fde1b4a0c6365fb4e1cb9669621cb96ece91"
SRC_URI[deb1.md5sum] = "e26cb36209a09029b67773c97e1d8599"
SRC_URI[deb1.sha1sum] = "218fd3daa2391ba367cdd38ff4f8f79f6b3757e1"
SRC_URI[deb1.sha256sum] = "0c426e83f1af816b9a4df9056fd2238463d1cd07969ee640965da9fb6ecaf107"
SRC_URI[deb1.sha512sum] = "96f637fb82ea78281570e5ec56e9c283d57b9b6ce5224af858f4d940b80493ee1a89f2c02555e2158bae785ef69b04775d71316063901ada36c48558e56e619b"

RDEPENDS = " \
    libbrotli1 \
    libbz2-1.0 \
    libc6 \
    libpng16-16t64 \
    zlib1g \
"

