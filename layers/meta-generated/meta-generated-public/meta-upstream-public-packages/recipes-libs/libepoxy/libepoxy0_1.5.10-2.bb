# This was autogenerated! Do not modify
SUMMARY = "OpenGL function pointer management library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libepoxy"
HOMEPAGE = "https://github.com/anholt/libepoxy"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libe/libepoxy/libepoxy0_1.5.10-2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libe/libepoxy/libepoxy0_1.5.10-2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "52cae0e09aebf07b65af50da00027e2f"
SRC_URI[deb0.sha1sum] = "29958c87759ec085f47a02f06b33a736ab9b9625"
SRC_URI[deb0.sha256sum] = "4c4c8024f2175086de65bca9fdc3fbb967f2863ebf249d489c66d0c8103dd3a3"
SRC_URI[deb0.sha512sum] = "8be003b29e1c625b31760965e10243980600ba53aff73c4490d50f13e2a6b860b88aa98fd06cb7c3245dc8417af47f95b29da0065ef7314b2c150d6c93657125"
SRC_URI[deb1.md5sum] = "4cff497a02844784c320bec5cee260a2"
SRC_URI[deb1.sha1sum] = "d7c66902581096d19beb8f6aedd3044d74ae6c7d"
SRC_URI[deb1.sha256sum] = "905fbc7fb73bd620a10c1c02118bb760d42826a7212bfddadcda9d10d5a23d81"
SRC_URI[deb1.sha512sum] = "0508b45a0a0d1bab68446d60769af59b1d73f03a388c9b94350242135a114ff04b8315901ae5d062c87a39069f6e051ec00f41bae88f84431208a6ea05b093a7"

RDEPENDS = " \
    libc6 \
"

