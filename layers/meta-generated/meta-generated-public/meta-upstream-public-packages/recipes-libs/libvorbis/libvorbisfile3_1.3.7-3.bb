# This was autogenerated! Do not modify
SUMMARY = "high-level API for Vorbis General Audio Compression Codec"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libvorbis"
HOMEPAGE = "https://www.xiph.org/vorbis/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libv/libvorbis/libvorbisfile3_1.3.7-3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libv/libvorbis/libvorbisfile3_1.3.7-3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "d1b49b1a3a7fadc1f09126f2edfd5b77"
SRC_URI[deb0.sha1sum] = "39420896ad0d219f3cfd7a862a704ed537c0531a"
SRC_URI[deb0.sha256sum] = "02822ab3da107b6f65bb3f7ac5bc8d68f51f998dd6886dd38f509f4d04d0ccd6"
SRC_URI[deb0.sha512sum] = "0b82d1f7a238f913cec82e0ae9900f48ed971ae82dbae5d9e1216aa580b4e40226f14ce9ad1854e3ece82f8f136f738bba443373774548ebdd1c9cbaf13b90ec"
SRC_URI[deb1.md5sum] = "e340e846ceb0feb35fb4fd1eaf8c7cc6"
SRC_URI[deb1.sha1sum] = "8caea73ef5506f6ccd23b938ead62a7e3d357fdc"
SRC_URI[deb1.sha256sum] = "6eea69ab6f851955736abe56002551e304eb36cffdc9e9a1a21fb578ca3632ff"
SRC_URI[deb1.sha512sum] = "6086733d06ee014e10bfbfad7aa445c17a647dc454d19d53179d8e757023312005cd79b12be3eae0d659820d78b4d080fe602522829d95dfed22f8def5922106"

RDEPENDS = " \
    libc6 \
    libogg0 \
    libvorbis0a \
"

