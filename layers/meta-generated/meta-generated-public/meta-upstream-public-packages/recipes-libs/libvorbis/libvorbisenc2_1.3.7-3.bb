# This was autogenerated! Do not modify
SUMMARY = "encoder library for Vorbis General Audio Compression Codec"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libvorbis"
HOMEPAGE = "https://www.xiph.org/vorbis/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libv/libvorbis/libvorbisenc2_1.3.7-3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libv/libvorbis/libvorbisenc2_1.3.7-3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "a497095e426d92d21c05915487617076"
SRC_URI[deb0.sha1sum] = "993b063bb2ff5b2aaaad1cfba395c53d3a46e67a"
SRC_URI[deb0.sha256sum] = "5fbbf06a5b196235aa2753cd12bbe7f843328571d368f15b1c337578e29f73a2"
SRC_URI[deb0.sha512sum] = "5105c14ca17bcba389d528b1be46415d06f1c43feeded13da3bb13b2827102d3685615a972b6cea2277f119323b4cabcd916723bea92be7ecd131ba271fd8867"
SRC_URI[deb1.md5sum] = "608ea26033df09c3529db9ea4e996653"
SRC_URI[deb1.sha1sum] = "15bb76c2ef4a06dfdb18be150e67c6936e303eaf"
SRC_URI[deb1.sha256sum] = "4a477b3ae19ba50a288f036c8176d61cd9f3836ba65472f88b95e3f6b3bf2dd3"
SRC_URI[deb1.sha512sum] = "611c195e1c0f216f29313809209107669e49c8df8dc81ae2ac603dfac925f54805824cb608367ba39db3ea5426428c7448c3e9d35c807a1c631851fab821e55d"

RDEPENDS = " \
    libc6 \
    libvorbis0a \
"

