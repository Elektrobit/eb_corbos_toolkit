# This was autogenerated! Do not modify
SUMMARY = "decoder library for Vorbis General Audio Compression Codec"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libvorbis"
HOMEPAGE = "https://www.xiph.org/vorbis/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libv/libvorbis/libvorbis0a_1.3.7-3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libv/libvorbis/libvorbis0a_1.3.7-3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "847fa3ce164022557c69fca9621284cd"
SRC_URI[deb0.sha1sum] = "e564493502cc30c1e8d885132b160e46a6832099"
SRC_URI[deb0.sha256sum] = "0465f7f602f7b00965e58e7273b5876060ab7946f0452a9f95d979046932cc42"
SRC_URI[deb0.sha512sum] = "b5051e169fea23c08b485ffd19edbad60bc550373f930e0626331e0414371a8ef4bc2d110d39c48c92dca435bd9b546feefc75d624f851233bf94c7bbed28008"
SRC_URI[deb1.md5sum] = "482299914ca49505ac01b9f1ab76ff2a"
SRC_URI[deb1.sha1sum] = "11099d986a777b68463ff56d306f6444f965b02e"
SRC_URI[deb1.sha256sum] = "6e8e64ebe692dd2d019af7f914f2e3b81bf13d4b1ce2516fb4248a0310ef7cf6"
SRC_URI[deb1.sha512sum] = "a107905795b4f42627dd4e9e2895b13f6a1a865e10f6da2fc7db605dc8220d9115625f2d534cefcfc81642cf5668cfefc65dc3f87d14f6d08d235e58b89f654b"

RDEPENDS = " \
    libc6 \
    libogg0 \
"

