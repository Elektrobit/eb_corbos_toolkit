# This was autogenerated! Do not modify
SUMMARY = "multiple precision floating-point computation"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "mpfr4"
HOMEPAGE = "https://www.mpfr.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/m/mpfr4/libmpfr6_4.2.2-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/m/mpfr4/libmpfr6_4.2.2-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "839426828463b5c4df709f97e7433015"
SRC_URI[deb0.sha1sum] = "2390204ccaf310cea4f55ffbcd223d403c7bf0ac"
SRC_URI[deb0.sha256sum] = "75dddce11dabc7fc543712c33dc27b7f2ee66a111763eb5eac654d010b42cd92"
SRC_URI[deb0.sha512sum] = "43aecb66dc87459b0afaad9fcd39efec4e4937dec62fe32928e34ecfb040a630e6fa56a7437a69497d5041132a9ca7cdcd4276403695ebcd56e43eba87b9959f"
SRC_URI[deb1.md5sum] = "7af721541b1760bb7c3a6b470057357f"
SRC_URI[deb1.sha1sum] = "a3efee713193cb49d771bf6c51b6e2b56717259a"
SRC_URI[deb1.sha256sum] = "628a4ef58cc6815880f72e9d3953984a379a017e4042bc575f1fcbf3954d79ac"
SRC_URI[deb1.sha512sum] = "73eaee53cc2aadae8fa4950bde5b85d6a83456313c9d791f3a2184f9f5db6ab5bf9f0be43ac6512982393e54ac33efb0901903373e4b3319e10ee27b5a9beca4"

RDEPENDS = " \
    libc6 \
    libgmp10 \
"

