# This was autogenerated! Do not modify
SUMMARY = "SQLite 3 shared library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "sqlite3"
HOMEPAGE = "https://www.sqlite.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/sqlite3/libsqlite3-0_3.46.1-7+deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/sqlite3/libsqlite3-0_3.46.1-7+deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "0c86797541ead8d6e996a28b7dc274a8"
SRC_URI[deb0.sha1sum] = "06b33d5379fe5bd7f1453379afd3e65843a2b9cd"
SRC_URI[deb0.sha256sum] = "edeacbdd6a86ee82d314dccc180b740905fd7f6392b72e5c0533079fda449361"
SRC_URI[deb0.sha512sum] = "a14ef8961281d33f173d9431914272b557b9ed591493c1b7dba1bf779789d40a7bbfd9a83d97c68286b00a4d6e8ec3d4212214ea189d4488afdb1098820e0686"
SRC_URI[deb1.md5sum] = "246e57ede53f4571e43aff428649f2c7"
SRC_URI[deb1.sha1sum] = "2d64b5d83102862a776ef027ecff80174d535674"
SRC_URI[deb1.sha256sum] = "69dd4b705eca29fe134c17f18aaa4cc9e7ecd01c0250d5e195358801514c76ac"
SRC_URI[deb1.sha512sum] = "4cc6cffa92cb66776fca93a6c26bd2834a87194b9d4845b19e43668d1e28f46f501e3d668bbfc500ebde756a28e78de8d29acfc1f4e428e05cf5c33024bdacf9"

RDEPENDS = " \
    libc6 \
"

