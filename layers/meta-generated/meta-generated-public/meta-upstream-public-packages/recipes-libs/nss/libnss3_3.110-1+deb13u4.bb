# This was autogenerated! Do not modify
SUMMARY = "Network Security Service libraries"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "nss"
HOMEPAGE = "https://developer.mozilla.org/en-US/docs/Mozilla/Projects/NSS"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/n/nss/libnss3_3.110-1+deb13u4_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/n/nss/libnss3_3.110-1+deb13u4_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "08e74796982fc84bcee7965b8000ff00"
SRC_URI[deb0.sha1sum] = "67f79ae973627512503ba6088154cacfc64558ce"
SRC_URI[deb0.sha256sum] = "8d20d0754039e15e9bd2c8484e98dc9c2982907d4f20834da29a9501913d00b5"
SRC_URI[deb0.sha512sum] = "91c32b5c5bb948db172fd1b226dc46b4846db90844c9c3f5010d4584242d23bfde2e8e30e2c02fee974a6c624b98ccb0ad4049cb7e34edf4d0ae3e94aa898631"
SRC_URI[deb1.md5sum] = "2bba137a9097d3d741cdce303c15eb65"
SRC_URI[deb1.sha1sum] = "af19fbca4496791244008eedc707164832de2b22"
SRC_URI[deb1.sha256sum] = "1a9f35c238e8bbb570fbdae88ffe43a3cf3462e1582cbe0903a9aa949e61f3e8"
SRC_URI[deb1.sha512sum] = "290fad58117da85b123909ddbd4ff0f9080baa984508d612e3dc7307569a2cf4908a1ab2bf0add3b910106bd8f607cabe2114ba64ebb3cf9c3e99b3e1581c7ae"

RDEPENDS = " \
    libc6 \
    libnspr4 \
    libsqlite3-0 \
"

