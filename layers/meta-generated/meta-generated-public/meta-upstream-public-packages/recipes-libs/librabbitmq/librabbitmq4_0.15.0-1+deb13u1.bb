# This was autogenerated! Do not modify
SUMMARY = "AMQP client library written in C"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "librabbitmq"
HOMEPAGE = "https://github.com/alanxz/rabbitmq-c"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libr/librabbitmq/librabbitmq4_0.15.0-1+deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libr/librabbitmq/librabbitmq4_0.15.0-1+deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "ea8d173a82e0720bf42df7fe3511ced3"
SRC_URI[deb0.sha1sum] = "4df6868de6392af298ff827fb644f34e904a7eb8"
SRC_URI[deb0.sha256sum] = "60b4dafbd86eb9b31f088212305abf9bb70e1ede9abf633c759fbd440ebeefba"
SRC_URI[deb0.sha512sum] = "f06a0f3b4d541683b5107bf150f55959cb5e9cbba207c662a5225e7682052ed2ab06e8870497726fc1e3d0f273b98b75e91a8574393a5e17ca79a48e8fe36384"
SRC_URI[deb1.md5sum] = "f5cedf6dda8d79f975ec2ce63adc45d0"
SRC_URI[deb1.sha1sum] = "1c4c427c619c4857bea0084acc75f793ed9f3385"
SRC_URI[deb1.sha256sum] = "76174decede31e489d68831b1e3774bbdfb4975cb9a9b4eaaeb95b29fc687009"
SRC_URI[deb1.sha512sum] = "bb2c73da8cf614a0168586a5a327ea687aff8a6c808c335c8552518fe38f0e2aec5659d3d40bab0efee48d18c8a65dc256484cfef14175d6330cbe4985140d36"

RDEPENDS = " \
    libc6 \
    libssl3t64 \
"

