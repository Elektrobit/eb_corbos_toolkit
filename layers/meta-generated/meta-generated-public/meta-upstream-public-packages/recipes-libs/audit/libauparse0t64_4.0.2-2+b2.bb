# This was autogenerated! Do not modify
SUMMARY = "Dynamic library for parsing security auditing"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "audit"
HOMEPAGE = "https://people.redhat.com/sgrubb/audit/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/a/audit/libauparse0t64_4.0.2-2+b2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/a/audit/libauparse0t64_4.0.2-2+b2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "82d8b63a010f538e5e1d482821607cda"
SRC_URI[deb0.sha1sum] = "888d43ea9a9507a5f114f41d3cfd1157febe3fc0"
SRC_URI[deb0.sha256sum] = "dfe6c103f1413d2c802f48b6aeb27a0eef6b7a97d3075a22e198f3f11cfab341"
SRC_URI[deb0.sha512sum] = "b0078049e6264ba4f649c43e53b9232030285a4e4ee257ea266b65ea27d454697c65766a96378dc41da1619e18010b12a5c5236c73ecb7357273ae5f8d5e08b9"
SRC_URI[deb1.md5sum] = "253f7b432fc00fa9340cda2e822fb880"
SRC_URI[deb1.sha1sum] = "8f5a7d4a8a8958088270224c0440dd0dc6433358"
SRC_URI[deb1.sha256sum] = "d6a117b040e3333f5c9ed053315eb74eb9695b5428937bdbd03dd1fa07b1192f"
SRC_URI[deb1.sha512sum] = "fa575ae4df8a991d711f5bb5619d84feebf9ed078adad5abcb3579110e6bfb318f5b9b3ecac502fe7877f6fa22c108a741d818a4209b6e9da4487a8f2d306548"

RDEPENDS = " \
    libaudit1 \
    libc6 \
"

RPROVIDES = " \
    libauparse0 \
"
