# This was autogenerated! Do not modify
SUMMARY = "Dynamic library for security auditing - common files"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "audit"
HOMEPAGE = "https://people.redhat.com/sgrubb/audit/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/a/audit/libaudit-common_4.0.2-2_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "db8824e85e136daba1f3c864224fa159"
SRC_URI[deb0.sha1sum] = "d4657962ca3a903c5f26f0d7f2b1a46b5d7ec6c0"
SRC_URI[deb0.sha256sum] = "b6edcd7aa36a2a5a1abd2c52966d69a99eebdb69c8f5cb33cbf415b0875775e3"
SRC_URI[deb0.sha512sum] = "ffe89c5735fd00be50614c9614bebdc33dad9e68d0d6b8566211c3248105269e86db2c99df9aae12f83740e1872db2f87470baf165e7f1d23178332bfe08a59e"


