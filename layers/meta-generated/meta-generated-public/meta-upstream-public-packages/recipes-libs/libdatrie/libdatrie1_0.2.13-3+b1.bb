# This was autogenerated! Do not modify
SUMMARY = "Double-array trie library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libdatrie"
HOMEPAGE = "https://linux.thai.net/projects/libthai"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libd/libdatrie/libdatrie1_0.2.13-3+b1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libd/libdatrie/libdatrie1_0.2.13-3+b1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "c6aacfaf094c1405f6470db80a2a48aa"
SRC_URI[deb0.sha1sum] = "9e7858159e8efd9307100982fa4b277b27924cd7"
SRC_URI[deb0.sha256sum] = "339eb88f23d72b8f0b7b1aebcefbab6de600d97b88bc6222dd8aad11d2ca9051"
SRC_URI[deb0.sha512sum] = "403eb73cffa65244c2f5692d4497f70b44a0f4ada5981d38f822efc4f92621b6b83821839053577378b6eddb88baf44df427986433fbfaa6fc728aac87b9cec3"
SRC_URI[deb1.md5sum] = "4b37edaa17a824ec04c4a8f6bca005d0"
SRC_URI[deb1.sha1sum] = "9a90c350d5833791cf328acb183be02a40702b5c"
SRC_URI[deb1.sha256sum] = "d513d0602836c4df782c15dc9472c17ab5a815343aabc9ebe7dc9604c0acfaa0"
SRC_URI[deb1.sha512sum] = "97321e88912da9260443e30d9fe9dac92bf39de06787f73a22b184aee090e9a394c9b2b3912637b450eee0200ef28797d3959b06c1dc8e37a91f1972b1711ca3"

RDEPENDS = " \
    libc6 \
"

