# This was autogenerated! Do not modify
SUMMARY = "compression library - runtime"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "zlib"
HOMEPAGE = "http://zlib.net/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/z/zlib/zlib1g_1.3.dfsg+really1.3.1-1+b1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/z/zlib/zlib1g_1.3.dfsg+really1.3.1-1+b1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "32f24a3a36446828f2645417b52e718a"
SRC_URI[deb0.sha1sum] = "6521c4fb859cda27142c655d2aa30c9d31e40ff7"
SRC_URI[deb0.sha256sum] = "015be740d6236ad114582dea500c1d907f29e16d6db00566ca32fb68d71ac90d"
SRC_URI[deb0.sha512sum] = "99707ae371d970a774a7e0fffcceb48ad7ae611ff8513488f8fab809a4eb69a3d9df734d1a211f7b6e9104ada25a75f9a86fcf137000001006ce64bf0d38057d"
SRC_URI[deb1.md5sum] = "47323069c3fef2f10ccdff2be39964f1"
SRC_URI[deb1.sha1sum] = "37dbdb01f106b4b2246e8b4e2a09988081baae4d"
SRC_URI[deb1.sha256sum] = "209aa5cf671e97b9eb0410844fa6df4cae2e75b0c72e7802ab6c8ece13e6ddef"
SRC_URI[deb1.sha512sum] = "17fae1070ab2d235dcb756e46fb62e3846176f271a660a5c13f5e6c70d590741658cf86a7c6a6303430d0bb51b2019dddba88fabc5d4e7afa3f82db96bb03961"

RDEPENDS = " \
    libc6 \
"

RPROVIDES = " \
    libz1 \
"
