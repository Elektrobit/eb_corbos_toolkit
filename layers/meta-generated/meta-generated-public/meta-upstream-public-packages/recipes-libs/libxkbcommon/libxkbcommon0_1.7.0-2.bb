# This was autogenerated! Do not modify
SUMMARY = "library interface to the XKB compiler - shared library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libxkbcommon"
HOMEPAGE = "https://www.xkbcommon.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libx/libxkbcommon/libxkbcommon0_1.7.0-2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libx/libxkbcommon/libxkbcommon0_1.7.0-2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "d39cb40622b6ec6d3bff7c40536e10a3"
SRC_URI[deb0.sha1sum] = "064b646790ea13ff68650011edfae16e22d25755"
SRC_URI[deb0.sha256sum] = "f75ee544f55acc6a271debfab3ea4ae0458afc89d81cfe1a71137e07d4895b86"
SRC_URI[deb0.sha512sum] = "401e35824eec015eb22b16dea3ff2159f95031a07084585f6534cf7272b32b5454f8de42f41a1bcf9d195649a8071029aee6071e63ee5039bc1bb6ee5e2f59f1"
SRC_URI[deb1.md5sum] = "e3d67a4d84e2520d89f38a557ed1039f"
SRC_URI[deb1.sha1sum] = "0898c5f0777a752ff8b32e906e81bb5a578245fb"
SRC_URI[deb1.sha256sum] = "866888d3cfeb32388dd88a2615c4f78ebf8dd7b272821a83494cba260d8fa7d1"
SRC_URI[deb1.sha512sum] = "54e50fd98f0ff1eb03593fe640118cd391b34fafc11ca273f638b537847a6c7fcb9e91984682e1d0d777bf48a45afe149de312c1355de581842c00c2d7ea8330"

RDEPENDS = " \
    libc6 \
    xkb-data \
"

