# This was autogenerated! Do not modify
SUMMARY = "library to create keymaps with the XKB X11 protocol"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libxkbcommon"
HOMEPAGE = "https://www.xkbcommon.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libx/libxkbcommon/libxkbcommon-x11-0_1.7.0-2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libx/libxkbcommon/libxkbcommon-x11-0_1.7.0-2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "c4a2758e22b0d74030f5eeb3ae4f5976"
SRC_URI[deb0.sha1sum] = "75467cb14aedd84d7ae15c8858cec47dc64a0b35"
SRC_URI[deb0.sha256sum] = "b5cff6287d0d90b66224edfb7208709c5d35511215d87d2836919e4f7d367653"
SRC_URI[deb0.sha512sum] = "5c4064a1623637868a8eccbcc9be7c2b34a783875fc0fcdc1b555401144f41d2373c93addbe29e4003baae3df7a07a4320acd60043254bceeea8627f592eac19"
SRC_URI[deb1.md5sum] = "22d219e07549fd5e3fb52af434054faa"
SRC_URI[deb1.sha1sum] = "25270644a7dc2a67f7c9d016ece4e46d689fd994"
SRC_URI[deb1.sha256sum] = "414ec70596c8193b309279dc6d8a35f809ffe5047addc3587a6d52eb462bebc5"
SRC_URI[deb1.sha512sum] = "cab4ece341509c5a6ed91d6d679b0feb9ff4cf8eaec2a302ecb1b64d4df051dd91fccb82333b2c1b8e48791d3c2279365dabe64294a7cbf8eba9e9e7ba2cfd63"

RDEPENDS = " \
    libc6 \
    libxcb-xkb1 \
    libxcb1 \
    libxkbcommon0 \
"

