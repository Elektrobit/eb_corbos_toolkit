# This was autogenerated! Do not modify
SUMMARY = "theorem prover from Microsoft Research - runtime libraries"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "z3"
HOMEPAGE = "https://github.com/Z3Prover/z3"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/z/z3/libz3-4_4.13.3-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/z/z3/libz3-4_4.13.3-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "1c9abad2a783eb84b1898e06fd260f82"
SRC_URI[deb0.sha1sum] = "ad1b2f8fe0da1d5987182d6ad9f81420dbf50dc0"
SRC_URI[deb0.sha256sum] = "71383373523ef62d47eccf660cf6535c3febcbb3f88e54cb7a43124014b57359"
SRC_URI[deb0.sha512sum] = "4345b780e8ad132d13f1ec3b92eb29ae296382f0f8487da1a6269ddb39746bad8bdd8fd8ea596b4c848838d06efdd4b42b6c1be936ac5c2f6a9a4525b9c75ec7"
SRC_URI[deb1.md5sum] = "484bf18daaeb4fab0c8a1d7d53d6714f"
SRC_URI[deb1.sha1sum] = "9e2f9ad127db834d80df467507c52424db02eee8"
SRC_URI[deb1.sha256sum] = "29a7b924a5a38c9ac4e2a64aa11586a9c54f26b579b18e4f75adf8f7c1106e45"
SRC_URI[deb1.sha512sum] = "5a03d0bfaa939dcdb60cdeb56754426c5c6f87feb4f9aef046dc3eb84135f5964ef6109757bf287da31127a79fe083c2b9de3fe5c2acf8fa8b729395aaa65bfb"

RDEPENDS = " \
    libc6 \
    libgcc-s1 \
    libstdc++6 \
"

