# This was autogenerated! Do not modify
SUMMARY = "X11 miscellaneous utility library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libxmu"
HOMEPAGE = ""

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libx/libxmu/libxmu6_1.1.3-3+b4_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libx/libxmu/libxmu6_1.1.3-3+b4_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "8e973694fe2411e16aab510054ab74dc"
SRC_URI[deb0.sha1sum] = "a05d2319e8feb65cd0f14144c77170bf66df17eb"
SRC_URI[deb0.sha256sum] = "cfdf1dee8f9abd87f503222fc8b04a30ce820fb1255247b7c3a28ff9c244431a"
SRC_URI[deb0.sha512sum] = "b702b113fa01848bea62d408950111df7cac8e4e88a18e187f5deb7fb26f6095663f582b0f42e6cfeecca8399864130b96584123f1e48e402a4e14cb503d5bf3"
SRC_URI[deb1.md5sum] = "68a62e52332763c9dbe600ab077d3ebc"
SRC_URI[deb1.sha1sum] = "c5104cea3a1bf819e6663ff92bc05351f6a878de"
SRC_URI[deb1.sha256sum] = "5b43d4b7bd1df59a58503f7a4dfa3eb1e3833d2db0ab8c273a251e7be34a6fe7"
SRC_URI[deb1.sha512sum] = "3e3b483b41de183bd539182c2cf165e2b796a64797b641f1daa116870ad51dcab75f776d0e6c9e416f5205f17113e0037432be5fdb88fd1be60e63e2351da685"

RDEPENDS = " \
    libc6 \
    libx11-6 \
    libxext6 \
    libxt6t64 \
"

