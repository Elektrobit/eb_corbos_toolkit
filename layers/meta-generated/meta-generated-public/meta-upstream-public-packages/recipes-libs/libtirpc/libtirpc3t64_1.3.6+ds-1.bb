# This was autogenerated! Do not modify
SUMMARY = "transport-independent RPC library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libtirpc"
HOMEPAGE = "http://sourceforge.net/projects/libtirpc"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libt/libtirpc/libtirpc3t64_1.3.6+ds-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libt/libtirpc/libtirpc3t64_1.3.6+ds-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "a53fcff1f56e64fb19db15eb07756ddd"
SRC_URI[deb0.sha1sum] = "3382fc0968af380b8966d46342738234478b4c95"
SRC_URI[deb0.sha256sum] = "ef4536c09bf5063554310e22d586ae90990100ba66d2fe7c35660e9e658913b6"
SRC_URI[deb0.sha512sum] = "5815562873d2916aa166ebbf5b882caa6a4417c2d3d753368f03e703ee44afbef9e8f66162690c8c9a5cd01f10fa15be9a83212892411f8d6570ea134ea02f96"
SRC_URI[deb1.md5sum] = "9b7e780ab6ed99d6cfc401ef47c2cfe9"
SRC_URI[deb1.sha1sum] = "56b6e3056936fd87c30aa3caf47bb0233865f1fa"
SRC_URI[deb1.sha256sum] = "ae390ce96435829f0d5252305fb9b22001f5bcc85477e452373ddb2a4fa4dbc1"
SRC_URI[deb1.sha512sum] = "3d0f0dd649b70408890e396773d4be9b9ae7234448afa21844095d350d7ff4639b791edd1e4d9ec47d824117d607bd01a38d60c6fd3fe10de64d21725decef5b"

RDEPENDS = " \
    libc6 \
    libgssapi-krb5-2 \
    libtirpc-common \
"

RPROVIDES = " \
    libtirpc3 \
"
