# This was autogenerated! Do not modify
SUMMARY = "transport-independent RPC library - common files"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libtirpc"
HOMEPAGE = "http://sourceforge.net/projects/libtirpc"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libt/libtirpc/libtirpc-common_1.3.6+ds-1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "d536fb98a02d3d13a7b1a29e3a038131"
SRC_URI[deb0.sha1sum] = "703a8577b17b52095c1af5c01842e1b18e7aedb5"
SRC_URI[deb0.sha256sum] = "300f582e2c9151a8d329568c705cadc76252c417147312fe331c4560d2c7a6c3"
SRC_URI[deb0.sha512sum] = "960e4b66f35282142ad180e75be9f26d8e4a270c7d7d7884c707fe3af702f5ff3664df08654993b4d1ed2954312ca3f792759c2c4565da55d3ec8e45183e49e4"


