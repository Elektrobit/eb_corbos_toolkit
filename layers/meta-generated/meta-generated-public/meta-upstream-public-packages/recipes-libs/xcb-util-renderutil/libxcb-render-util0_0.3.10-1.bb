# This was autogenerated! Do not modify
SUMMARY = "utility libraries for X C Binding -- render-util"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "xcb-util-renderutil"
HOMEPAGE = "https://xcb.freedesktop.org"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/x/xcb-util-renderutil/libxcb-render-util0_0.3.10-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/x/xcb-util-renderutil/libxcb-render-util0_0.3.10-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "1a45556f66e886a0bfd315af7304d21d"
SRC_URI[deb0.sha1sum] = "f7d80f7bba76d14c24324e3d228cc1f32cc263e7"
SRC_URI[deb0.sha256sum] = "9bdd6247e45cea5047e4da883dabf168366474fb1b00a37bb194359ca1f975ab"
SRC_URI[deb0.sha512sum] = "3e1e8d0c500282e9d20cf68d7ee70885744d2febbb9454db58d41918f78a8aeff8e0b81f9aa69b7ec8bef19e28e35777e8d1dbdfb6d879b0fe45346ad411f97d"
SRC_URI[deb1.md5sum] = "6e5baeb575e2d4e01bb03c59da06c271"
SRC_URI[deb1.sha1sum] = "5dbd080c01abe920397342ebb3102ad2674f57fc"
SRC_URI[deb1.sha256sum] = "f4a33bcc7780f404623a608823b48b91d9ac776a1396d56e9916cbfee49b182c"
SRC_URI[deb1.sha512sum] = "2a76e6822949a2199c98d5ad596795935b29f3c336419995a5bf36f9d7ea35df5ca4b0ad8b7ca14bef62d81150ec73a8fdcb402821343b518f15ba92b93cba8b"

RDEPENDS = " \
    libc6 \
    libxcb-render0 \
    libxcb1 \
"

