# This was autogenerated! Do not modify
SUMMARY = "library for generating and verifying FIDO 2.0 objects"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libfido2"
HOMEPAGE = "https://developers.yubico.com/libfido2/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libf/libfido2/libfido2-1_1.15.0-1+b1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libf/libfido2/libfido2-1_1.15.0-1+b1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "76d91934a4acd64d8b1c24a0fcd416d8"
SRC_URI[deb0.sha1sum] = "894c8972a7309e6431b8c99a8bb9ddf36c6822d9"
SRC_URI[deb0.sha256sum] = "094fc0fe20c652be848ab2a8b3793eb03bc4327140ebd232145356352004e6c0"
SRC_URI[deb0.sha512sum] = "1e92e0e960086d21b395967eca1b7c6247aad1e30dc546679bc192f7607c749202d69a1265a54c64106858c4aed37a0b79d43ab5f3938228655b01f8b13f73c5"
SRC_URI[deb1.md5sum] = "558adb2fdf7da7c7d5d1d9221e2e2a94"
SRC_URI[deb1.sha1sum] = "4a4636c1cc85f2426b588fb9a0ac77c7daac9b33"
SRC_URI[deb1.sha256sum] = "510f81957f2905c57d3d8681c3ed9bf68a17bfb254d721a578c88edd8158477c"
SRC_URI[deb1.sha512sum] = "326b36ec4ca48c34d02235d22ff757155c51b1229f2ba91aeffe596d4b267a4eb60dd981b6ee857e7ca925df0e25e2bd47d4b4a8d1c3edf6102d005a79b02b4a"

RDEPENDS = " \
    libc6 \
    libcbor0.10 \
    libssl3t64 \
    libudev1 \
    zlib1g \
"

