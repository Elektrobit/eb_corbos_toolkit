# This was autogenerated! Do not modify
SUMMARY = "shared library for ALSA applications"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "alsa-lib"
HOMEPAGE = "https://www.alsa-project.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/a/alsa-lib/libasound2t64_1.2.14-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/a/alsa-lib/libasound2t64_1.2.14-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "3c1b64072506a7312ccbb147ff26c6a2"
SRC_URI[deb0.sha1sum] = "5937f78a111b425941c0c4782c9764381a81a082"
SRC_URI[deb0.sha256sum] = "f03a2bd9d234f4e6d283c36520d66befd0952d6f5ba454badd8fae2305ad70a1"
SRC_URI[deb0.sha512sum] = "2a4a03fb7ce6a448a01fd6591b8ffc99ec7407f0a65e31d7f9611133ec06585bb37431fa87d5585625b52d5c2aa725830c129199f09fb54635db656ca4cd4ff2"
SRC_URI[deb1.md5sum] = "7aa0ba1820916c38c390df8d27fd9916"
SRC_URI[deb1.sha1sum] = "c38916d5f7d5c56d49ec9f4449c061e6cf44f182"
SRC_URI[deb1.sha256sum] = "b89f299d77281df9984795701c915c92e736ca3840fb552604a305d1e9813a4a"
SRC_URI[deb1.sha512sum] = "e3583491d60925a2bf0516205de7786ffe18a69fba95b4fa22c6f106294275a4eaf143e32086f54b932d66d3994bced75d5573c930b4dcca2dd973f8f6967287"

RDEPENDS = " \
    libasound2-data \
    libc6 \
"

RPROVIDES = " \
    libasound2 \
"
