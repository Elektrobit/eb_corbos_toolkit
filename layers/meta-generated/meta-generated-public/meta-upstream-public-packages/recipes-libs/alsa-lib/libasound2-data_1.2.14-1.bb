# This was autogenerated! Do not modify
SUMMARY = "Configuration files and profiles for ALSA drivers"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "alsa-lib"
HOMEPAGE = "https://www.alsa-project.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/a/alsa-lib/libasound2-data_1.2.14-1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "b59a094ef4ea8369d6d1f2e125d895c5"
SRC_URI[deb0.sha1sum] = "74074c327419008074875e7b647565826bfb24e1"
SRC_URI[deb0.sha256sum] = "fe973f6467a6fc553ead004bd5aebfea4eb45c5da827cd3fb32650d9672ac947"
SRC_URI[deb0.sha512sum] = "d08c8cc8a7a01d30b54a6b3662919280c33ac2cbeaf07c599174e8f35059b73f66e1994b3df3116394bf4285d45b8fc3cdaf9dd026796bf6f5705955050301e9"


