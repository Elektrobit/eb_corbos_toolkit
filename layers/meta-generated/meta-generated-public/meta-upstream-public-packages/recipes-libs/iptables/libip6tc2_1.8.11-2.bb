# This was autogenerated! Do not modify
SUMMARY = "netfilter libip6tc library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "iptables"
HOMEPAGE = "https://www.netfilter.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/i/iptables/libip6tc2_1.8.11-2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/i/iptables/libip6tc2_1.8.11-2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "aa9f72bfd282cef10000ba69e34dc519"
SRC_URI[deb0.sha1sum] = "433a1e1cb68faeaedd65df006117de96a6979c32"
SRC_URI[deb0.sha256sum] = "d5ecaad5595dc88d08f317997beb53a4906c45ea79ee14ec89103f72573e3f99"
SRC_URI[deb0.sha512sum] = "9d42c3fa75be117a15e5098be9b9c52961f4c2dcdbc94dc8b63b2d0826df2bc4e766134957ec7ce42f0098211831afdbaa8eb0a050d49fcde5843ceb78a061ee"
SRC_URI[deb1.md5sum] = "b18ee2348a4eea6afe039a2e858342bc"
SRC_URI[deb1.sha1sum] = "2f9401c86fe64c35e64061470fa5a08f89fedce0"
SRC_URI[deb1.sha256sum] = "3ab7581ae06d0b7109ec60907a063ef167446e492f30918dcb20faed810d172d"
SRC_URI[deb1.sha512sum] = "0860bb42235bede8c510e8b356495180edbd61b7611c9a501ae35e755af81bb3fe4aba70958a0f5959e1c68b129e3a20e6467ff34294ef57b048ec574f038f45"

RDEPENDS = " \
    libc6 \
"

