# This was autogenerated! Do not modify
SUMMARY = "X cursor management library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libxcursor"
HOMEPAGE = "https://www.x.org"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libx/libxcursor/libxcursor1_1.2.3-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libx/libxcursor/libxcursor1_1.2.3-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "078436cdd0ee333685887e20ab431015"
SRC_URI[deb0.sha1sum] = "41fdbb9e55d21fef363aca5b47f659e7f5b3c6e8"
SRC_URI[deb0.sha256sum] = "bb0dbf58b804faaa74ed9efdae61c4b14bb0b4855680798f63e5ca6a4954976b"
SRC_URI[deb0.sha512sum] = "a2602c5cd85b4602391374011925613019d7a34f8e5ba73e56107d932a09d33e431b00713319ee351aef5d22b9367a0cc8f1c07b10ba193e4802e03c8adb66e9"
SRC_URI[deb1.md5sum] = "b5a751cd4b5df34a54a937a186709601"
SRC_URI[deb1.sha1sum] = "4a50f45b90631f3e5f2de06e0a7af41671d52f89"
SRC_URI[deb1.sha256sum] = "76d13a27c444f88c44cf50e209e8f9dc5088da330680bd35f6eba0430662a4b5"
SRC_URI[deb1.sha512sum] = "560eefba34f1eb929f22484569dcdea75fbe5e845422d707f8ec39ce07b68ab9404c44ce5794c77a5bf90ac02d669aa0156e56861a2b1c063c4f6ce8c8202e6f"

RDEPENDS = " \
    libc6 \
    libx11-6 \
    libxfixes3 \
    libxrender1 \
"

