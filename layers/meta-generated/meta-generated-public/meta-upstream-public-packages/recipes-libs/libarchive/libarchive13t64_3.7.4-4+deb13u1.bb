# This was autogenerated! Do not modify
SUMMARY = "Multi-format archive and compression library (shared library)"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libarchive"
HOMEPAGE = "https://www.libarchive.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/liba/libarchive/libarchive13t64_3.7.4-4+deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/liba/libarchive/libarchive13t64_3.7.4-4+deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "83f24237c142f5f485720ad944e2d692"
SRC_URI[deb0.sha1sum] = "48241cf426371a2a003fb094c450f954586287c1"
SRC_URI[deb0.sha256sum] = "12e06195a899e8db371803ed70111fc7302573d3ed84e967d3d48ef2d543ace8"
SRC_URI[deb0.sha512sum] = "68dde2dfdc4f046513e285916b19653aff14e280dcfe77afe0c3b647ec2a7ff9392d44870b83eb42eaedaf135a07a4a2fca812854138728b77e06fad2bc04137"
SRC_URI[deb1.md5sum] = "8f783e240ef6b6868ebd7608c4773282"
SRC_URI[deb1.sha1sum] = "caa4a31b37d67f3a86d5dcd664e03101c3f98fdf"
SRC_URI[deb1.sha256sum] = "9dc7897bc1c83b03a69c581018010fbd9723ce199b99433639343d8b3a5bcf81"
SRC_URI[deb1.sha512sum] = "eeb232b03518400d80cb77f08c2adae74cf331879b1c7d99c250c5228192c6ce450741cd9b897caad27324370e93c9f67857ee98826653593baa18c86e234447"

RDEPENDS = " \
    libacl1 \
    libbz2-1.0 \
    libc6 \
    liblz4-1 \
    liblzma5 \
    libnettle8t64 \
    libxml2 \
    libzstd1 \
    zlib1g \
"

RPROVIDES = " \
    libarchive13 \
"
