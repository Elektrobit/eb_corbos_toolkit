# This was autogenerated! Do not modify
SUMMARY = "Scalable Video Technology for AV1 (libsvtav1enc shared library)"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "svt-av1"
HOMEPAGE = "https://gitlab.com/AOMediaCodec/SVT-AV1"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/svt-av1/libsvtav1enc2_2.3.0+dfsg-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/svt-av1/libsvtav1enc2_2.3.0+dfsg-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "8246119a4f34194b2952d38703a823b3"
SRC_URI[deb0.sha1sum] = "94ab0e8266db1aa0a8f3a41a4bb80419b3739686"
SRC_URI[deb0.sha256sum] = "cdaf961c3cc4fe78a19ff18c17d83d813f78a378fdcc4c86ccbb9b54e84ae599"
SRC_URI[deb0.sha512sum] = "00ef0d08b74fd0bd72f30211199f6045419fb05b3439bfe0803eaf1923c1deb5df356fca38f942cbebe4aa3f3f4858f5302f01f61423a8904a66cdf6b60590b7"
SRC_URI[deb1.md5sum] = "105c18aa35874e5b0ea9a4f99e297823"
SRC_URI[deb1.sha1sum] = "2fe5e8a3ffde4f1d24e5c6318a5e72758469cbc4"
SRC_URI[deb1.sha256sum] = "9b7de4fcdaba3fdc0fe8eed956cd5ce270158c858493db901bfcb9bd4a432fb6"
SRC_URI[deb1.sha512sum] = "5904440ffdbccc69ecae087258e03ccbf27d7f58588c0cd4f03c715535689ab53ce6b3fb41868fc9c43d8c51d3b859aac2058db75bfa23c9b3a650876d89010d"

RDEPENDS = " \
    libc6 \
"

