# This was autogenerated! Do not modify
SUMMARY = "International Components for Unicode"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "icu"
HOMEPAGE = "https://icu.unicode.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/i/icu/libicu76_76.1-4_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/i/icu/libicu76_76.1-4_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "0108420129712229eade1cc128d04675"
SRC_URI[deb0.sha1sum] = "64267d4651f634bb7e01190e6cd56da176a792ed"
SRC_URI[deb0.sha256sum] = "c1bf762996de9ecba9b9d871e4928a8090f023a3e9e7fa3240b3d90f892a01dc"
SRC_URI[deb0.sha512sum] = "b8dc79227c2055a71e9d3919726186451cc9afe4bbc70363f80ad45ce7751ef4e7cafcfe55a54c0c3f6e0a9d84e060d897ec20d315e14b1ba85dc0a875a8ec11"
SRC_URI[deb1.md5sum] = "13a3d27db14961c0b9bddaae53c1e53f"
SRC_URI[deb1.sha1sum] = "8bfd53ff793d1cb46b0fe3905bb123634e1c5830"
SRC_URI[deb1.sha256sum] = "62eb15577c881b7d02aa861e3eb860902335630cc8174daf525b48c2fa39298f"
SRC_URI[deb1.sha512sum] = "7a63bad37dea6e329d12b0ea50d7d70a8e7f4bbe5658b132f7a53f7433e7249928ae11dcda32cf0113d092ad04265b7047f86f049446038f386c1a5815c18bf3"

RDEPENDS = " \
    libc6 \
    libgcc-s1 \
    libstdc++6 \
"

