# This was autogenerated! Do not modify
SUMMARY = "multiple-precision integer library [runtime]"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libtommath"
HOMEPAGE = "http://www.libtom.net/LibTomMath/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libt/libtommath/libtommath1_1.3.0-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libt/libtommath/libtommath1_1.3.0-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "15db83e3324cdc24a2a37fd51b69933d"
SRC_URI[deb0.sha1sum] = "038c91c94aca1d1a38b5be438c490bcadce207be"
SRC_URI[deb0.sha256sum] = "0e6025c5c3c07c7055993eb23fd1eb8e55ec037ef46eca2e7622825e85f56a60"
SRC_URI[deb0.sha512sum] = "9bf545f1ba7402ae39a94e602bf344b64d4c601898d70faaf94ca3da49abda649e45f4f792159e8aee033daae98278740b4918031dc8be85ba6de79575ca258c"
SRC_URI[deb1.md5sum] = "82e38ebca35e48fecd93f74314fcff1b"
SRC_URI[deb1.sha1sum] = "f09d3f40c6bfdc6dcfcbadb6c3b9e59eafbf5099"
SRC_URI[deb1.sha256sum] = "7e53ae5d16d06801b1c0c88e2fcb3b38e08d76aa3855bcbd6abc8e9639cb6945"
SRC_URI[deb1.sha512sum] = "87521e9fa67fdba2a391d0ec2fa86e98ca63e582def4fe2f15d00e2cb9cdf3d307f2ac0fdbb4ae32426f32187d68352d77eee389535ccf13f5b5fa505ed1f69c"

RDEPENDS = " \
    libc6 \
"

