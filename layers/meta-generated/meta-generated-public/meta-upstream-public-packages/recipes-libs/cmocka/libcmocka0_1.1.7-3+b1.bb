# This was autogenerated! Do not modify
SUMMARY = "library for the CMocka unit testing framework"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "cmocka"
HOMEPAGE = "https://cmocka.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/c/cmocka/libcmocka0_1.1.7-3+b1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/c/cmocka/libcmocka0_1.1.7-3+b1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "8853e436271b6b38ac4f9494ba8d69f8"
SRC_URI[deb0.sha1sum] = "e36596b78d47f96368e0a749848249f0231a6dfb"
SRC_URI[deb0.sha256sum] = "c2d793dd23487ad083d3894b0c2ae6fbbd965d0e1c445b3b25614919addefdf0"
SRC_URI[deb0.sha512sum] = "0088d706c0cb1f60e46313fcf1c134cb1211a5735aa5576d6a229988ea03a3b13d1766b9f2558f6a6ee0ec573bbe93dd0ff60b4b4193fc9ed974bac17066eb03"
SRC_URI[deb1.md5sum] = "fda9c4e11e805bc8948a9d3b2f0a04b5"
SRC_URI[deb1.sha1sum] = "ebedc8627388fb674a88665bed83d9d663c4fb66"
SRC_URI[deb1.sha256sum] = "9dd3dbaba3ac642cd689dec932317ee5cec16e9f8dd90277f54670d4357ba563"
SRC_URI[deb1.sha512sum] = "0ebbbd4c7f72ea168e96d569efbe2f5169ac2a58eabde18042fcebc188a7b350eceb871115b21abdbd1ada74f5ca370d38fe101ea08f5b4823061025eb97c069"

RDEPENDS = " \
    libc6 \
"

