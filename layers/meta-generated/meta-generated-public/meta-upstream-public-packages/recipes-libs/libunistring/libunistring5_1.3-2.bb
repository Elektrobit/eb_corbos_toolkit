# This was autogenerated! Do not modify
SUMMARY = "Unicode string library for C"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libunistring"
HOMEPAGE = "https://www.gnu.org/software/libunistring/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libu/libunistring/libunistring5_1.3-2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libu/libunistring/libunistring5_1.3-2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "954d362e7a674be8969e0c223782de72"
SRC_URI[deb0.sha1sum] = "49e3032a7bb85c144d013d237eb8022e499a640c"
SRC_URI[deb0.sha256sum] = "6dd3490bef06ea1096f32d10766b7e016cf579bfae8451d1b7df15ce05b8aa46"
SRC_URI[deb0.sha512sum] = "a35e4b4cd06c5ad954d3f259add24c4056364b740cc4152f90d89395a20c050e496ff4b38dd6ff9a054d1320965d2e267008fd330016e4ac401004a622d1b13f"
SRC_URI[deb1.md5sum] = "faf73e535b17f172564a34c8971e3522"
SRC_URI[deb1.sha1sum] = "1fa10cb479bb203c4e004130ddfdfd8fa3258724"
SRC_URI[deb1.sha256sum] = "4847467a0e47039837895e88f5a99a4a86a3d8266be40c3c896fc7c10d552dc7"
SRC_URI[deb1.sha512sum] = "deb6c181be5e4016d616258e59bbe3374d5f664300a31abfa7e1e7f4f65ded61112820818a2b77814976249bee5db163c247bc05074c12861c26238f75dcd001"

RDEPENDS = " \
    libc6 \
"

