# This was autogenerated! Do not modify
SUMMARY = "wrapper library for evdev devices"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libevdev"
HOMEPAGE = "https://www.freedesktop.org/wiki/Software/libevdev/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libe/libevdev/libevdev2_1.13.4+dfsg-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libe/libevdev/libevdev2_1.13.4+dfsg-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "f03577bcd0cb413696066857bdb88928"
SRC_URI[deb0.sha1sum] = "ef3c337975091880514cbd5936c09ee11673b02a"
SRC_URI[deb0.sha256sum] = "02e85fb9461b85b23f775d5fcf5a31c55d37bec40b63fd98ca5d3a2763714ae7"
SRC_URI[deb0.sha512sum] = "e6c4ae25641bbb161ecc6140ca95f241316217365fcbc79a3b75b0f95e0ceea4be71a0e93be591133d5149342a07b8b4224de858b9193b69a421f1eb4472819c"
SRC_URI[deb1.md5sum] = "e38edbc72c701308003bfe60ece6717d"
SRC_URI[deb1.sha1sum] = "0b706dec03c137f392a5f0c2d2f309dfe0f4e84d"
SRC_URI[deb1.sha256sum] = "abdb9ca2f0a27d88ec16b480f346d1d6c183c59e3d071734ba8d8b9794aacfc6"
SRC_URI[deb1.sha512sum] = "6ab02d5c6797f8b2ca972007fe72da5db7db14f4089aefded94ae759daf20f064c1c0c9c8001de3c5bd6560fc0052846b9ddfa7ebd92d2239db340de8fdeaaab"

RDEPENDS = " \
    libc6 \
"

