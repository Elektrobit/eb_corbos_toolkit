# This was autogenerated! Do not modify
SUMMARY = "extended attribute handling - shared library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "attr"
HOMEPAGE = "https://savannah.nongnu.org/projects/attr/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/a/attr/libattr1_2.5.2-3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/a/attr/libattr1_2.5.2-3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "2c3100a9dc9aae8ec609dcbfd62e5ace"
SRC_URI[deb0.sha1sum] = "d1dffc98c6790ab73e95de59821202732374e4b6"
SRC_URI[deb0.sha256sum] = "606b5ee12ea2786be607a17f40c1fb5e65c76ceaff66665bdf8f8c6c1b71d1fb"
SRC_URI[deb0.sha512sum] = "93e29587b995ca6918623aec7282b619d207ae5302befecc22f9ec6d04e361d2c083f4ebd5fca32c78530d315488254551c1bba32c37a2ae354856bc610dc20c"
SRC_URI[deb1.md5sum] = "cb81884bbd25294d8a1404dcacda8a80"
SRC_URI[deb1.sha1sum] = "4f777954e8edf1dce56d006195e1c425c45d4e6e"
SRC_URI[deb1.sha256sum] = "25057d7bfba969a76cdf18ae88ce7ff6e664520726ddf02cdde97c03d5e9a43c"
SRC_URI[deb1.sha512sum] = "26dd364d4b84845d54912cf2683a9c6a8885954b427805fca62d9aaf7820f516c6e21e1da39c1fc6bfff2cfc419845027e12445cd426a01e1a659e6fd81390a7"

RDEPENDS = " \
    libc6 \
"

