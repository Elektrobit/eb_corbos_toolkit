# This was autogenerated! Do not modify
SUMMARY = "X11 toolkit intrinsics library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libxt"
HOMEPAGE = ""

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libx/libxt/libxt6t64_1.2.1-1.2+b2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libx/libxt/libxt6t64_1.2.1-1.2+b2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "1447757cfbcd88e8c4d11ea1f8c89f76"
SRC_URI[deb0.sha1sum] = "f86b6bf0b69e2187cb2f063a790fda7387f481a1"
SRC_URI[deb0.sha256sum] = "a1f4557c03113681ee24863495adc244cecec95fe3ab7256ce76e87320157300"
SRC_URI[deb0.sha512sum] = "b63603a9e2c48a36f27464abafc62745ee8d746b04bb4587d8338dca9b908eec3009e4d00d08841629d659b996f45f18ef4b09f8b4428ca3a964781ec0d79185"
SRC_URI[deb1.md5sum] = "988b110c0c9d6992a2cf04c9626c6677"
SRC_URI[deb1.sha1sum] = "a19d784bea1124d90c421e5af297618722273719"
SRC_URI[deb1.sha256sum] = "5890026a20d10d0e3c031b93d0b831d398b38f66f15f351035c802beaa6d726a"
SRC_URI[deb1.sha512sum] = "676e96a7b83f2bc1554a13b5e0d56725ff551d1e99e4507b63d885898b7d2881603073f02d126bc410cf4723d369f075c8a8f2eb10f27ebb04332f54b1578723"

RDEPENDS = " \
    libc6 \
    libice6 \
    libsm6 \
    libx11-6 \
"

RPROVIDES = " \
    libxt6 \
"
