# This was autogenerated! Do not modify
SUMMARY = "Shared Python runtime library (version 3.13)"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "python3.13"
HOMEPAGE = ""

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python3.13/libpython3.13_3.13.5-2+deb13u3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python3.13/libpython3.13_3.13.5-2+deb13u3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "5faeee74318f1afee3601658466b3c86"
SRC_URI[deb0.sha1sum] = "ed011d41c474c7e592245aa26b599b4bad2f84e2"
SRC_URI[deb0.sha256sum] = "0df7a5d9a1c4d5834aab7594f3aee96ff80a17e81110370a73e7f804a0ad1747"
SRC_URI[deb0.sha512sum] = "23f8720f744268556669b9bb0220d54377ed0b9200a3004d48bba63a088715384b8279704f9c9cd7f398a1297c449238f2406a105ce543a672cba9732c5d24ba"
SRC_URI[deb1.md5sum] = "bce0a93b94619bb66cb8de9c3344c85b"
SRC_URI[deb1.sha1sum] = "5b120b78e99bc8a82d91d327bca87b00d22ef790"
SRC_URI[deb1.sha256sum] = "6b60b4fa828edfd97c8aa15aa26798b539b15ca0e6f67638b6d88dd78316123c"
SRC_URI[deb1.sha512sum] = "0b806aac059121b13909979a0cf75b868b7457737487eb3a377df26e91091e71810de19329300dd3731040d312e217e5a3faccb45a01ba10c75ea0c804a62ca3"

RDEPENDS = " \
    libc6 \
    libexpat1 \
    libpython3.13-stdlib \
    zlib1g \
"

