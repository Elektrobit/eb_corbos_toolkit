# This was autogenerated! Do not modify
SUMMARY = "Shared Python runtime library (version 3.13)"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "python3.13"
HOMEPAGE = ""

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python3.13/libpython3.13_3.13.5-2+deb13u4_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python3.13/libpython3.13_3.13.5-2+deb13u4_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "df91938d3af3fb87d7665606566c8647"
SRC_URI[deb0.sha1sum] = "a817f92905b030fcbca7d433db7dc4dcccf91c3d"
SRC_URI[deb0.sha256sum] = "2381bdaa2462b186db27671507e53eba9515c5341575fb72189b6228c73e3df8"
SRC_URI[deb0.sha512sum] = "ca98fac2dd462610533d4f3310c4337c405a84ef13daaaa2aae84d897b3b5e59ed2209fe1a9af27a75253bf9267cf64cd4a8b0795749d57c69867b070d9cd1a6"
SRC_URI[deb1.md5sum] = "f9709670a689f72c276ef3583e57068e"
SRC_URI[deb1.sha1sum] = "aea74f4c49aea43a3cdb0dba3f8407b87cc6f240"
SRC_URI[deb1.sha256sum] = "d8f0a0d8d829988605ad66aff280c8c9770060b21868aae14a45e8ef872589ec"
SRC_URI[deb1.sha512sum] = "d9eafdd9b1b89f280a80c3ede1d12fd618eb1de04315d3b8a77aa530512783555c295e1e0ad8d3262b510a7edbb82be9318c8da0d33314d952bc6641cefbb8b7"

RDEPENDS = " \
    libc6 \
    libexpat1 \
    libpython3.13-stdlib \
    zlib1g \
"

