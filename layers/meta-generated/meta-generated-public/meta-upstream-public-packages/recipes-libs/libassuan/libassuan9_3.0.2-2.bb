# This was autogenerated! Do not modify
SUMMARY = "IPC library for the GnuPG components"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libassuan"
HOMEPAGE = "https://www.gnupg.org/related_software/libassuan/index.html"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/liba/libassuan/libassuan9_3.0.2-2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/liba/libassuan/libassuan9_3.0.2-2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "905ecd7eec31cabebdf750f5bf6670f0"
SRC_URI[deb0.sha1sum] = "b95cc7cf5bfa4e1956fa5ff22d53f868ba28f2d4"
SRC_URI[deb0.sha256sum] = "9d78ef8f016e7f24b5e20d1ce91939fe0f1f897e5f9059793201e930ded7eb8e"
SRC_URI[deb0.sha512sum] = "fee3d8610c148f170398556149e5754baf4cbd25fc3472e9be039e201554216af3b062919d1a6ed312c68b0117e4f30e5ff9e4d8b7cbff9f6aa9474634cb5573"
SRC_URI[deb1.md5sum] = "e3459d479fe0ed651fa16cada40c5c4d"
SRC_URI[deb1.sha1sum] = "377429f7e377fa0c4772db9a22651ab9aa28a00a"
SRC_URI[deb1.sha256sum] = "a4c36f4cbc7c09064fa944bf4f5d704ed6e2290b12d07a4d766a5d415b7c120d"
SRC_URI[deb1.sha512sum] = "b15ef26bfe6e23409cc113ce87dcbbb9c8c642658e5b969ec069c322bebd618cfb5f7174af8d5babd96dcd433ae26fc640cd260dfb07ad894b3987a7cdf87f87"

RDEPENDS = " \
    libc6 \
    libgpg-error0 \
"

