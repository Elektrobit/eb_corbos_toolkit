# This was autogenerated! Do not modify
SUMMARY = "Library for computing Fast Fourier Transforms - Double precision"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "fftw3"
HOMEPAGE = "https://fftw.org"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/f/fftw3/libfftw3-double3_3.3.10-2+b1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/f/fftw3/libfftw3-double3_3.3.10-2+b1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "3de1637c65aa5d5fe60bed8e564f6e3a"
SRC_URI[deb0.sha1sum] = "e35394de47ab5e593704e393d72a274241303c16"
SRC_URI[deb0.sha256sum] = "5808e90242319a7ec7c0d50b40cdb1ebec9d0e695dcde14a4e7f1cd84657dc96"
SRC_URI[deb0.sha512sum] = "2b2f69af0da3bcce3c06b7dc0572c5f1437e52720b6c7bafc8fc953eec18025e82596e83f492209df073df6db4be64cb35bf2bd190b28d575a8a13e7f187e410"
SRC_URI[deb1.md5sum] = "8d97efaa7791ede667b284e47c3c00c3"
SRC_URI[deb1.sha1sum] = "e8f968d0510c08b6a0918dfc633e6024efe71fd1"
SRC_URI[deb1.sha256sum] = "afdec5b3cdc381b1c9e80892ba12a054dbf6e529e8a8a518a8611064fdafaa0e"
SRC_URI[deb1.sha512sum] = "ea673e503ceba3a1418128673e0d6e5069e3ddf21b9bca0738b10f6ec5e7b6d9ba045666de8ab66350db7732ab8ecd8d2f0992dde142ded853f04b49cd988242"

RDEPENDS = " \
    libc6 \
    libgomp1 \
"

