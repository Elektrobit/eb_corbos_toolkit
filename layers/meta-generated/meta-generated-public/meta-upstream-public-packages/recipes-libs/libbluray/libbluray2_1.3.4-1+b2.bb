# This was autogenerated! Do not modify
SUMMARY = "Blu-ray disc playback support library (shared library)"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libbluray"
HOMEPAGE = "https://www.videolan.org/developers/libbluray.html"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libb/libbluray/libbluray2_1.3.4-1+b2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libb/libbluray/libbluray2_1.3.4-1+b2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "2c37b08cb296d65b214c83f715cab6ad"
SRC_URI[deb0.sha1sum] = "eed1cf7f384e0911dc3de445dc20ded19223d640"
SRC_URI[deb0.sha256sum] = "82f9e58e8dfdfeb57b273111433c335500c26553eb82f2a025e94ed9fdae2c21"
SRC_URI[deb0.sha512sum] = "9360dce0205d32be43b6728478a1bc974a32eda376e067c430ec153d97fc8c91b920afaf0d4e54cb4a0580f38ff2c86c2b2511c7a739ee449ec3708d29c9c9a0"
SRC_URI[deb1.md5sum] = "9dd30469d1854b79e62b4beff03dc66e"
SRC_URI[deb1.sha1sum] = "bb0b2a95170f79aa616fb266c5f5e42afc810483"
SRC_URI[deb1.sha256sum] = "14da09203931bdbff17b129d447850daecc8c72b87b296e3f7d0e0beb56e9f50"
SRC_URI[deb1.sha512sum] = "7ebc4ecf7ba57e30c37b21d908ed2cfe1e11c59f44f25ebfc047e421934b7e292a6a682bce250d290de2da7904c10b2af700173e5d01c146b9fd4674d0dd5ff3"

RDEPENDS = " \
    libc6 \
    libfontconfig1 \
    libfreetype6 \
    libudfread0 \
    libxml2 \
"

