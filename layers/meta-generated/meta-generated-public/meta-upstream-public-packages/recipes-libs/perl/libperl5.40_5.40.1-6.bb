# This was autogenerated! Do not modify
SUMMARY = "shared Perl library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "perl"
HOMEPAGE = "https://dev.perl.org/perl5/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/perl/libperl5.40_5.40.1-6_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/perl/libperl5.40_5.40.1-6_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "149067fb62a43782b50eaf559aa4f68e"
SRC_URI[deb0.sha1sum] = "115f4cbe17c3706c068bab13e8659621c15591f2"
SRC_URI[deb0.sha256sum] = "f20aa427c3f56f430b7b58b73222edcb8cda40fa9c3b25365b20cd53eddd51a9"
SRC_URI[deb0.sha512sum] = "bae0c955fb41033fc1853f4282161bf7b1952637b9eace6ea7a4946746ba90a732da9f03fd465f5e3120439ea6846513fd304e3ad6fab76de5a5ce5795073893"
SRC_URI[deb1.md5sum] = "f556d7fc52e128d25c5e2258950d0a8d"
SRC_URI[deb1.sha1sum] = "589bf2b1fe59e8273cf06d87bccf6f23aa3a02ed"
SRC_URI[deb1.sha256sum] = "3ae323c6210a7844fb96aedec078b11a9d52405d77ef3adc4e5d4b55bce235e2"
SRC_URI[deb1.sha512sum] = "bb2b398119bb19451adbb4d64851545dabd50c5d6accca9e3ebbb92ee347022e14d3a18cd890769f79e419d7dbc220d2687f4fbee4dde769a9951d4d125205b3"

RDEPENDS = " \
    libbz2-1.0 \
    libc6 \
    libcrypt1 \
    libdb5.3t64 \
    libgdbm-compat4t64 \
    libgdbm6t64 \
    perl-modules-5.40 \
    zlib1g \
"

