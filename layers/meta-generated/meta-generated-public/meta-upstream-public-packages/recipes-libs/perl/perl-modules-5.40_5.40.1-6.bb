# This was autogenerated! Do not modify
SUMMARY = "Core Perl modules"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "perl"
HOMEPAGE = "https://dev.perl.org/perl5/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/perl/perl-modules-5.40_5.40.1-6_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "cd9a4bc940cc1923623b206f7c738a84"
SRC_URI[deb0.sha1sum] = "8e8e460fc410a98e6eed5cbc5a5af8f82ae23ed4"
SRC_URI[deb0.sha256sum] = "dfd42c1bf0c45858488ad666b90de17f81b55e6f9c0d8ca530c27b4a66c08b0b"
SRC_URI[deb0.sha512sum] = "5b11523d028b29872afeff429948dbf26ccdaa5ba29820e5af0ff185e8d7f3b06099901d1ea864d0ad65b680d8f5221e28c726226a1ad6b3e9135a6958d46f8d"

RDEPENDS = " \
    perl-base \
"

RPROVIDES = " \
    perl-modules \
"
