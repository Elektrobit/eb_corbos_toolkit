# This was autogenerated! Do not modify
SUMMARY = "Pluggable Authentication Modules library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "pam"
HOMEPAGE = "http://www.linux-pam.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/pam/libpam0g_1.7.0-5_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/pam/libpam0g_1.7.0-5_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "85eb956ec02cc01d4db1534a0c3a6dcd"
SRC_URI[deb0.sha1sum] = "87c6d4233ce6751ce11502e8663e5d8cf75de72f"
SRC_URI[deb0.sha256sum] = "4f5bde27d8df2de6ea8990319b42d9974f56a3ba9907ce7296fd0f8964fc9fb1"
SRC_URI[deb0.sha512sum] = "3abe0ea31a0dacea7cc1783a80e96fe251af493debbc568f992be0d2a881d381da7f9ca0fdc9f6d5bffbd99e796677666d3e9d742725ea6f4b9da24abd4b2f6d"
SRC_URI[deb1.md5sum] = "34f1d982ce27320ba9e5478766f77bd6"
SRC_URI[deb1.sha1sum] = "b6be12ade2eda4442ffed5e1b6fc83e97170ae47"
SRC_URI[deb1.sha256sum] = "2dd0fdc9af8a8a48f0a54581f74005d4d8623baa8aea9ac3d201624c3217b6d3"
SRC_URI[deb1.sha512sum] = "3669ab46e0063afdcf06206fa38098442dd5b6ce3e4220462c84327c55394d9621446cbb1f56617f9ee9db6e8e55c019b0a6a37bba1934a80ecb9a581e0da60b"

RDEPENDS = " \
    debconf \
    libaudit1 \
    libc6 \
"

