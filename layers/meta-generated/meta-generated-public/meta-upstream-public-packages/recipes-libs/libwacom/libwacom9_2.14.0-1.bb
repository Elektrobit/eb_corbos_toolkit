# This was autogenerated! Do not modify
SUMMARY = "Wacom model feature query library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libwacom"
HOMEPAGE = ""

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libw/libwacom/libwacom9_2.14.0-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libw/libwacom/libwacom9_2.14.0-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "36c5f96d1d48e1564797983a11eca55d"
SRC_URI[deb0.sha1sum] = "ecf7d2dd2cc54441e4ff4bccef27128a10996025"
SRC_URI[deb0.sha256sum] = "884cb03fe12ffb871f9a199c13d1a455c5abb30b4619c58babb3940755b7b3c8"
SRC_URI[deb0.sha512sum] = "dee4df9415406c106ce07ee0779be1491f1f2e2870c159f971521088c7bc44d0f8b5bc71d481e0cc123c97e9a9d6b4a726cac4e64de70d0ef9949e27ce8bcce9"
SRC_URI[deb1.md5sum] = "6c44fd57fefd959c12eea3ebc2132b4c"
SRC_URI[deb1.sha1sum] = "0b4567132635257493b0b1b7c44bffc4a9f6f045"
SRC_URI[deb1.sha256sum] = "8fb8419c43fcc166f996c30cc262fcc86457bdd6f82656dad8619c88dc00b013"
SRC_URI[deb1.sha512sum] = "89f1b32a24825082609e2ccec01274169a01ee161b91da6bd4e0586a114fdefb71344f2fce14cb19efb42941abe6368dca629215cf64989e02712c15dd096406"

RDEPENDS = " \
    libc6 \
    libevdev2 \
    libglib2.0-0t64 \
    libgudev-1.0-0 \
    libwacom-common \
"

