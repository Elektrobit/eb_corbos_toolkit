# This was autogenerated! Do not modify
SUMMARY = "Wacom model feature query library (common files)"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libwacom"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libw/libwacom/libwacom-common_2.14.0-1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "b4e82081e5a61574892f8bea2ef9e89f"
SRC_URI[deb0.sha1sum] = "7301088f8d0923829c9b0e5ed87ee7140d98c746"
SRC_URI[deb0.sha256sum] = "214956bd9b26600c4d5ac0d60c1685be6ef650644e36b712620c56fccd4d4f58"
SRC_URI[deb0.sha512sum] = "9987cff63c3037e868f45acda8011805ce7813089e9cae04def934ba4559ab03b55d9e103ee96956b7ad6faf4289f2c93de6ed11fcc16cfc1201008413581c99"


