# This was autogenerated! Do not modify
SUMMARY = "GPGME - GnuPG Made Easy (library)"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "gpgme1.0"
HOMEPAGE = "https://gnupg.org/software/gpgme/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gpgme1.0/libgpgme11t64_1.24.2-3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gpgme1.0/libgpgme11t64_1.24.2-3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "0e26d3e34af7581bda9fd6086fd29cc7"
SRC_URI[deb0.sha1sum] = "217860ae157b927d59b4fc9949b8462a9021e5eb"
SRC_URI[deb0.sha256sum] = "6650203af59ccf73b22cd6904fb179a799cb70d62885b19ae725c0655c04241c"
SRC_URI[deb0.sha512sum] = "6a6e3dad48cefe073d445d1ea462794567bcfe49c7c6b8045140c97893d8816a9b178acea868cdeede0c89864c5118864d8ebd01f7513252063e69a3739e5c11"
SRC_URI[deb1.md5sum] = "90162397014bcf76baaa51925f0ef9c8"
SRC_URI[deb1.sha1sum] = "ff252fe82b1e081d7460e5a78c55c7192a4bea5a"
SRC_URI[deb1.sha256sum] = "af1f36d7c88c0baf4139ba796fad3791cf45ac6c6103bb4194b7b167a94a39d0"
SRC_URI[deb1.sha512sum] = "e8f528b9d326b219e2a7cb09a388c8eb9c540d07bcbe1b8daa6445990a35bb5cf948cd07f186753de1a159f0d0aab2ae377399fe6641111e172d8d167f2cfef4"

RDEPENDS = " \
    gnupg \
    libassuan9 \
    libc6 \
    libgpg-error0 \
"

RPROVIDES = " \
    libgpgme11 \
"
