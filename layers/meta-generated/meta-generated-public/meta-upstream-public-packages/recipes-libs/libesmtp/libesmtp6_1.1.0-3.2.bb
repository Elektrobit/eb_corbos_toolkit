# This was autogenerated! Do not modify
SUMMARY = "LibESMTP SMTP client library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libesmtp"
HOMEPAGE = "https://libesmtp.github.io/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libe/libesmtp/libesmtp6_1.1.0-3.2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libe/libesmtp/libesmtp6_1.1.0-3.2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "b9fc58b90bf146cd866d7868eee8595e"
SRC_URI[deb0.sha1sum] = "a831fbf5f9623b145b9b16df72071e91a684c5b9"
SRC_URI[deb0.sha256sum] = "1b9313bd940c2146f8659f9d5f771d20d888eec92d1ca81e292ba1a2f79b3a1c"
SRC_URI[deb0.sha512sum] = "d82fd2cc24d7785e2db33e81ec6cd86e93693015267f16f048e836c6d64839b291c41d8d6e98f75a40a978c0ccec3a95d5df6ab786aa5c84b9d25b9bf33670d1"
SRC_URI[deb1.md5sum] = "2826d674859e9d8e01e3e737ee4523a9"
SRC_URI[deb1.sha1sum] = "78895bd44f9f892a93590e72479635cbb344fcc4"
SRC_URI[deb1.sha256sum] = "ffb1ad0a59742d5519cabfe7a339a3ddf4b1043d92f744463a643c5e4a18cf3b"
SRC_URI[deb1.sha512sum] = "c9c8cf3f8a435d349229a767e070783322f7c46d538cfdabd57eace2d31645281ddcd447dcf69767ae489f958a1c7fec191cecd9b6fb79548328b7f3e7443a53"

RDEPENDS = " \
    libc6 \
    libssl3t64 \
"

