# This was autogenerated! Do not modify
SUMMARY = "X11 miscellaneous extension library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libxext"
HOMEPAGE = ""

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libx/libxext/libxext6_1.3.4-1+b3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libx/libxext/libxext6_1.3.4-1+b3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "5c21b254e638c96f172728b5fb816ef8"
SRC_URI[deb0.sha1sum] = "376c8d2c6afc249c30d4e24123bda5504294cb6c"
SRC_URI[deb0.sha256sum] = "fc618ec40465e5ce48622606299cb47833efc3fb235ba15543b81f850722f443"
SRC_URI[deb0.sha512sum] = "c6a6ff51eb88dd38e00b1e385fb05a854c24c2f60af2e9e2540e754438902fd72bee6cb23a8b55ad3028c6f3d3b603f7fa82999ef1bb2653235d8aa28ade7cd2"
SRC_URI[deb1.md5sum] = "e40bb47adee49a8617671ce522800f8e"
SRC_URI[deb1.sha1sum] = "50fcb7a2147f0adaef17b4ac06560dafe4db4bf2"
SRC_URI[deb1.sha256sum] = "27cf208c6d2924b22ed3b9ceff304b992e1f07ef7b0ef00239585595581dac99"
SRC_URI[deb1.sha512sum] = "b89e9d7760a74d6b73db3191d23993f6f91bdd2eb15ead609ea490def0abd4528bfa953423fe35b67ea770c9e5f0ce29ab1048a73e249de9a584882ba9160559"

RDEPENDS = " \
    libc6 \
    libx11-6 \
"

