# This was autogenerated! Do not modify
SUMMARY = "general-purpose scalable concurrent malloc(3) implementation"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "jemalloc"
HOMEPAGE = "https://jemalloc.net/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/j/jemalloc/libjemalloc2_5.3.0-3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/j/jemalloc/libjemalloc2_5.3.0-3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "ad0341c496ae6206c0504cec3e0db7d9"
SRC_URI[deb0.sha1sum] = "6bea3e5f2ebd627cda5810b77ff408c9a2e0c08b"
SRC_URI[deb0.sha256sum] = "e7d64919e620e8ea46960104efe1e9c977d751e5b610a5d89b0b51aeae9530d7"
SRC_URI[deb0.sha512sum] = "73ba8e41c05e41e6d6628933938b8325133c8ea56e53f6ddd01ad902d59223be1b6b583db2cd9fc798de5b643e44c69cac4a936aac4c212607164aedcb2efbab"
SRC_URI[deb1.md5sum] = "eebf23af724c8e35f90e8d1149aeea7a"
SRC_URI[deb1.sha1sum] = "34f82efeb54d636accde4d5d3a8a8b8e6d78ba75"
SRC_URI[deb1.sha256sum] = "437c48a6d591579bc812fc583ff0f28ac34a7d5c36b7d4e9f4f8809650430f3e"
SRC_URI[deb1.sha512sum] = "07aa4e52a0472a292c38203b56dddd9b122e1c6d7c52f681c75fa0e4050f15b3cf91a0963f72b115b0d1668c253ffc1e0b33e9518196fbb9371b0bc776ee38fb"

RDEPENDS = " \
    libc6 \
    libgcc-s1 \
    libstdc++6 \
"

