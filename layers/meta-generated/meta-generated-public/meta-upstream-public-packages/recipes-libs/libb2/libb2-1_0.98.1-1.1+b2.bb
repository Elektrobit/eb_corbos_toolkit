# This was autogenerated! Do not modify
SUMMARY = "BLAKE2 family of hash functions"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libb2"
HOMEPAGE = "https://blake2.net/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libb/libb2/libb2-1_0.98.1-1.1+b2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libb/libb2/libb2-1_0.98.1-1.1+b2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "f5b1ed07f0a3ee9b572b68852991d797"
SRC_URI[deb0.sha1sum] = "dfcbef1cda7f610bdd7bbe44b085cf1d1fd27c25"
SRC_URI[deb0.sha256sum] = "66bc1be2bffaa14efd2633d357ebb8672096aab63bcd38fc12e7b37183d956c9"
SRC_URI[deb0.sha512sum] = "09a19ec4ad1a47b1cdf399ea24ba4f8d368aaa9fa77335de529cd5768005a158b6c89f4d3ed2f4d1ecb03a9b3c9e4f72ad2cbc45d6f0209d2ead646ef0573698"
SRC_URI[deb1.md5sum] = "2806d056ca31d4683349ed90db76da18"
SRC_URI[deb1.sha1sum] = "69ee5e099281718513ad7b7718fca1e307ae65fd"
SRC_URI[deb1.sha256sum] = "e6255eb2e49677fb7d127b2b48baa7850adb950cd08b415d57e90a37bca6360e"
SRC_URI[deb1.sha512sum] = "700dc893feeeadf60c543053f0ccfd1392fd030e2290622171391d49169c71cb217352ed46c8114ced488fac4ef68d578de74c019a0a5c291a014f6120fe2ee0"

RDEPENDS = " \
    libc6 \
    libgomp1 \
"

