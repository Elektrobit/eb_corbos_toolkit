# This was autogenerated! Do not modify
SUMMARY = "audio time-stretching and pitch-shifting library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "rubberband"
HOMEPAGE = "https://www.breakfastquay.com/rubberband/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/r/rubberband/librubberband2_3.3.0+dfsg-2+b3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/r/rubberband/librubberband2_3.3.0+dfsg-2+b3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "58fd9be3f549be916f4186c5a21207bc"
SRC_URI[deb0.sha1sum] = "891db7142b79f67369030f1482b2bf0b8555f088"
SRC_URI[deb0.sha256sum] = "4593fde69a6a10f2356d0fd1e7b1cd61faa48cc83a1a0b01b7d021dfe5252a85"
SRC_URI[deb0.sha512sum] = "1d07b4fe4b776e1b7e94a48daf61326890c0cee00c0182c28329a91fb5aa20001b6b8683f2fe2b19c6becf1a26ac81b0d31009f8484af3f03a8ade496d260bd8"
SRC_URI[deb1.md5sum] = "90c1a4d1d682f77579a35e2912ede51e"
SRC_URI[deb1.sha1sum] = "646e8e8c0fcf4ad8399325a063e74abc8f5cc58d"
SRC_URI[deb1.sha256sum] = "ae06e140bb236367c99e9b03fb5ec0ad2cd3fcc491506ba8403197a5e2e4b2de"
SRC_URI[deb1.sha512sum] = "17761d8a1484cd2976efaff9cb8315c76a7773fde7bb4573377663b7cad5e5ce7fb537afaa6d221980f6d43c8d6dd163b82136bf5464c07a26b26262b6f1fbc2"

RDEPENDS = " \
    libc6 \
    libfftw3-double3 \
    libgcc-s1 \
    libsamplerate0 \
    libstdc++6 \
"

