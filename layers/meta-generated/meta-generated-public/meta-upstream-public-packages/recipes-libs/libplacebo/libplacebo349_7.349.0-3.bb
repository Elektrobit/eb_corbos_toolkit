# This was autogenerated! Do not modify
SUMMARY = "GPU-accelerated video/image rendering primitives (shared library)"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libplacebo"
HOMEPAGE = "https://code.videolan.org/videolan/libplacebo"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libp/libplacebo/libplacebo349_7.349.0-3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libp/libplacebo/libplacebo349_7.349.0-3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "b4f05118130371eb0d03cf66f9f65e48"
SRC_URI[deb0.sha1sum] = "bba414c2198645f36ec4bb6b388c90002a6e9461"
SRC_URI[deb0.sha256sum] = "3d2ebdb86ccc35b9d115e8280cfc12c2cdc5ca67d0234af7370259181768dff2"
SRC_URI[deb0.sha512sum] = "0fa81395205148a39a210d98c9408dd4385c03b5151acc9edf0e7b6d0f96dc8d55585edb1bddd830bb4d9aa04add700088720a9be09ce0d8575702293d4dea36"
SRC_URI[deb1.md5sum] = "0937d7651c21860a9913b47723ebd8ac"
SRC_URI[deb1.sha1sum] = "29af4cd38e0a96d6306b8ab2525de35b7c6507e1"
SRC_URI[deb1.sha256sum] = "6ab590a2bd40c7d0c988accc10f794a1733cdc085d45431e3ff9e78da8348245"
SRC_URI[deb1.sha512sum] = "7d2f84cd97103841b13387f87c3c86c0bf72b7fc0eb0f5514db664b2d2e6797f34f14358e0f3088854ae086ebc6ee65f59ec52fd0c7e275c8c385d62ca2c1738"

RDEPENDS = " \
    libc6 \
    libgcc-s1 \
    liblcms2-2 \
    libstdc++6 \
    libvulkan1 \
"

