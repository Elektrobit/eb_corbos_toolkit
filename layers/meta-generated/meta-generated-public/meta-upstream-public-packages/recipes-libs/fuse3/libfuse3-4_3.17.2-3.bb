# This was autogenerated! Do not modify
SUMMARY = "Filesystem in Userspace (library) (3.x version)"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "fuse3"
HOMEPAGE = "https://github.com/libfuse/libfuse/wiki"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/f/fuse3/libfuse3-4_3.17.2-3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/f/fuse3/libfuse3-4_3.17.2-3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "085358638fd8078420a543caf7360322"
SRC_URI[deb0.sha1sum] = "4951354db3ff849f84b2fa25a317449c30f09af2"
SRC_URI[deb0.sha256sum] = "92e2d521ff872755a13aa69dba7b24025a7dc0f0f5aa708c9a86cd3565f570da"
SRC_URI[deb0.sha512sum] = "107b778a39b392b54b1a1dd5ef8ae2e568d5189abd89a3c98fe6a34b646200a39496781b32029fae3238a1fa31b3a4b18e287de708a44b9b2e51f01be73557ca"
SRC_URI[deb1.md5sum] = "29f9ce1bf150a2b285d2cf5da9ec9d99"
SRC_URI[deb1.sha1sum] = "0dd8af849bc7bb0d87672b89dd65c7d046503778"
SRC_URI[deb1.sha256sum] = "66793b6b9a559e95a5ff853cbbff337076ef900c4b0d927f57fd986b3b1bea09"
SRC_URI[deb1.sha512sum] = "85a8a2779a245af2f3dd7020ea4bcd97cbe5e3ea9ec9f875aa04936bbe6e1437a55b9315918fee5c65e93a50d0df535772156f1b1b06d2edc9f00cdc7903a15c"

RDEPENDS = " \
    libc6 \
"

