# This was autogenerated! Do not modify
SUMMARY = "Utility library for managing the device DAX subsystem"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "ndctl"
HOMEPAGE = "https://github.com/pmem/ndctl"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/n/ndctl/libdaxctl1_81-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/n/ndctl/libdaxctl1_81-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "0bb07ecac1d365f617c7234ada89ac94"
SRC_URI[deb0.sha1sum] = "4bdbe8a8f09425023266b758812061a2695d7515"
SRC_URI[deb0.sha256sum] = "6296eb5c976743ba0defb7a061ef081238ca072cf569c6bb96fd3f9095c58a30"
SRC_URI[deb0.sha512sum] = "599b703591c5dea5b8b630d06f9eaa8c67f9e687d357c9f4a5714e56ff6219d7429c4b2d3bfcfcf6cf29b9a91ddb499aafb1bd2f784d0163bd5b5f41032fbd90"
SRC_URI[deb1.md5sum] = "04f45388a094a98df99c8acf307900cb"
SRC_URI[deb1.sha1sum] = "2ed25adff2f12743ab0618a7bff06c293af5bd62"
SRC_URI[deb1.sha256sum] = "9973ae7ade146965a32d131646894d7cdd0eec36449bd18c01b4deb4f2d46afc"
SRC_URI[deb1.sha512sum] = "3df3c6d0a5973b61aef83773410198e84c460c89a5da3738f78d4a10379775ac667679745a7d0906d3b6061ee6f3b0c9eaeaf312e2816a7fabe53fe0315456b6"

RDEPENDS = " \
    libc6 \
    libkmod2 \
    libuuid1 \
"

