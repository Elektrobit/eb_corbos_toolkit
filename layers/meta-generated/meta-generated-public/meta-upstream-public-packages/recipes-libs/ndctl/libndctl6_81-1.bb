# This was autogenerated! Do not modify
SUMMARY = "Utility library for managing the libnvdimm subsystem"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "ndctl"
HOMEPAGE = "https://github.com/pmem/ndctl"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/n/ndctl/libndctl6_81-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/n/ndctl/libndctl6_81-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "45f7abe868af60a190a023336d8dce1b"
SRC_URI[deb0.sha1sum] = "7221c40660b5172af4f423e6251b220c847468a0"
SRC_URI[deb0.sha256sum] = "fe60a05d42e61cb9f49a90b872aa5ca569363b13459ee0d405243c37a7de7c93"
SRC_URI[deb0.sha512sum] = "370a8de3dd041a6268025b38d89e393e0c3541c62123223b34fd330150bce2c2e95b401e3d132a1020ce44f88c0b5644d715bd2e4e6f2ad82f8e5b784b66dea4"
SRC_URI[deb1.md5sum] = "b1b629dcfb644f66b6a0872337e8aa09"
SRC_URI[deb1.sha1sum] = "46988a5f2295b8cac4320723b6d16bfae9859e4a"
SRC_URI[deb1.sha256sum] = "6a265b5b9a440ae5094d147acd1c47387736e24d16492d95b9d727727503c137"
SRC_URI[deb1.sha512sum] = "898bfce234b4d13a290fb153c8d938dfea760ecc583626f04db28c631dc0c3732c6152532f2eecc7c06f8941ca8bfb91c8fa8a43cced296dd364a27d228be147"

RDEPENDS = " \
    libc6 \
    libdaxctl1 \
    libkmod2 \
    libudev1 \
    libuuid1 \
"

