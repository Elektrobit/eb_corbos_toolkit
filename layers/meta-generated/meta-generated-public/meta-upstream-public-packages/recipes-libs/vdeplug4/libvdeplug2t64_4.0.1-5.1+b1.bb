# This was autogenerated! Do not modify
SUMMARY = "Virtual Distributed Ethernet - Plug library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "vdeplug4"
HOMEPAGE = "http://wiki.virtualsquare.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/v/vdeplug4/libvdeplug2t64_4.0.1-5.1+b1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/v/vdeplug4/libvdeplug2t64_4.0.1-5.1+b1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "f6463f533674960d9188df760ee1f4e4"
SRC_URI[deb0.sha1sum] = "ed5797a12c51cbc48d6860853bfd1af191faffc7"
SRC_URI[deb0.sha256sum] = "01291e2c8e28e91eac6b59c983a3a44e29ad0ddb8622699fbb84cbd5f26334a4"
SRC_URI[deb0.sha512sum] = "febd42551c37bf2b66d9cd68cc28dae2050645f5ab63bf91d5f91fa010039c222fdd6fcba4b71dc7a6626155c69bf09d1910e1a28f253a51b8a02d8339961e1c"
SRC_URI[deb1.md5sum] = "d1887398f2c340e80f0291d7669a2a33"
SRC_URI[deb1.sha1sum] = "ea9d20edabd94afd5404bf3f0956b0204750a21f"
SRC_URI[deb1.sha256sum] = "6651077e2156305d3151d57756b6072086a8ee3dbce405b11063ea9f78cf8768"
SRC_URI[deb1.sha512sum] = "2735f2b8892c7878cdb93fc962279ba5793f5f12633a2b8e9d72273d4c36c06933e84d04380f9182a71b4bcc6e1ead350fa091b3d1b28b99f0f0f4a1d5cb33a2"

RDEPENDS = " \
    libc6 \
    libexecs1 \
"

RPROVIDES = " \
    libvdeplug2 \
"
