# This was autogenerated! Do not modify
SUMMARY = "URI parsing library compliant with RFC 3986"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "uriparser"
HOMEPAGE = "https://uriparser.github.io/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/u/uriparser/liburiparser1_0.9.8+dfsg-2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/u/uriparser/liburiparser1_0.9.8+dfsg-2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "235a70c2df22baa76a41c55799f073c6"
SRC_URI[deb0.sha1sum] = "7e05bd3f15e5d82607d62f7ab1d16cbbef37d4c7"
SRC_URI[deb0.sha256sum] = "fd8f461644a9f6016e69ca41820d8789749d6b84b0ae5843bc48bdc5966310cf"
SRC_URI[deb0.sha512sum] = "57ff2f8c8bdb48803a523fb1253fdd3ae777bd5d7e62f5c1b6a38ef13dc645f06f8718bf6e15487d3b360baf122f34fa92d1121ac59594b45cbabd05bf7877cb"
SRC_URI[deb1.md5sum] = "215449855c71a4a9a03e2c46f5abda87"
SRC_URI[deb1.sha1sum] = "143cdf9e9d8a4b0f02d4230581aa89256ad9aab3"
SRC_URI[deb1.sha256sum] = "5159450f4f1d14a4a604d9727e9291474b3bdd36952d32b28b9a6817913704dc"
SRC_URI[deb1.sha512sum] = "72535069de0b7177ac290527d1c45f0dfa964b47558851b51b1f3ea3ebe7e31405b65b8bec2d77f0e388ba1d3fd81f2d73a01889478029a118d30c9c2694d5e8"

RDEPENDS = " \
    libc6 \
"

