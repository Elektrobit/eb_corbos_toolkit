# This was autogenerated! Do not modify
SUMMARY = "Qt 6 Quick QML module"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "qt6-declarative"
HOMEPAGE = "https://www.qt.io/developers/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/q/qt6-declarative/qml6-module-qtquick_6.8.2+dfsg-7_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/q/qt6-declarative/qml6-module-qtquick_6.8.2+dfsg-7_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "c4a6bd1fe59e3a873384ac6b48cf0361"
SRC_URI[deb0.sha1sum] = "ae7aa7016fcb6bc9e2ff0f55bf05f6143eb5bdb9"
SRC_URI[deb0.sha256sum] = "356de12b32ca02f317fa7117a08ca6b6bd78005ff9de3b1c6703dbe8c4e9f24e"
SRC_URI[deb0.sha512sum] = "40afd6ff4731447fcc32ab084b2db234573c316a0937a2f978fdde60aac57f1fd3128b3fa527870281b3b1cfa3ab91d63d06a91d567c8b536972a39c49834d0b"
SRC_URI[deb1.md5sum] = "2c4c788916eda0f55dd004e3b9b58786"
SRC_URI[deb1.sha1sum] = "6017dcf30e38530bdb01dfe6d07c4dee646c420b"
SRC_URI[deb1.sha256sum] = "19a6fa97202aafeeebb1c06e3612b915ab4c5205f9d21e9a64dbfd1093e3d802"
SRC_URI[deb1.sha512sum] = "992a25d132b74fe3dc447c6842bd9706eb00928584afd120be94eefa8980f8dfb682373278a95d91a0794fab3a8522995104d9ab8d84497dc9d60ec37961e237"

RDEPENDS = " \
    libc6 \
    libqt6core6t64 \
    libqt6qml6 \
    libqt6quick6 \
    libstdc++6 \
    qml6-module-qtqml \
"

