# This was autogenerated! Do not modify
SUMMARY = "Qt 6 Quick Shapes QML module"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "qt6-declarative"
HOMEPAGE = "https://www.qt.io/developers/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/q/qt6-declarative/qml6-module-qtquick-shapes_6.8.2+dfsg-7_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/q/qt6-declarative/qml6-module-qtquick-shapes_6.8.2+dfsg-7_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "609af32bc83607e99ea138a1ab4399bc"
SRC_URI[deb0.sha1sum] = "e15ba48fe7352464a6273c3a54d89dd59bffa968"
SRC_URI[deb0.sha256sum] = "4561abcc421c36bf850a99e28b2a910e2d92354ef56a50360f9b0b56640a2273"
SRC_URI[deb0.sha512sum] = "8358fd57bdf28b4453d54894ec27cb6503406382dcd236c106a55a9626ca3287aac493ae077a62f2904a5ecf4ac515fa462ab6704825a49ddde281800970106c"
SRC_URI[deb1.md5sum] = "2cc07d0c99eaa8ffbe274c8681ffd0cd"
SRC_URI[deb1.sha1sum] = "9df12dce685a521408c9e77828382dc65970e86b"
SRC_URI[deb1.sha256sum] = "25f6e4fd45c55504054c7da92acf6dc29b45d5c121d65ebb03d6ce9072f5707b"
SRC_URI[deb1.sha512sum] = "aeda26f477fea6b7d4a363d9f4a2b1f865c23036de7a6bf7248d007125e1d7902bdd98fc70e92cc31892dd7b4d7ff3058ceb1d154238514dff9e02f7681b007a"

RDEPENDS = " \
    libc6 \
    libqt6core6t64 \
    libqt6qml6 \
    libqt6quickshapes6 \
    libstdc++6 \
    qml6-module-qtquick \
"

