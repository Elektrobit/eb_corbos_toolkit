# This was autogenerated! Do not modify
SUMMARY = "Qt 6 Quick Templates 2 library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "qt6-declarative"
HOMEPAGE = "https://www.qt.io/developers/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/q/qt6-declarative/libqt6quicktemplates2-6_6.8.2+dfsg-7_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/q/qt6-declarative/libqt6quicktemplates2-6_6.8.2+dfsg-7_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "7b907a4a2198f003d12996c53dd37dc2"
SRC_URI[deb0.sha1sum] = "8e19ea6299d298ee5fb28fd5e07936da8a7ea78c"
SRC_URI[deb0.sha256sum] = "ae9a22a36d8183946a920990df4b9775e9f1fe51c0fc07a7f8a490642725dc12"
SRC_URI[deb0.sha512sum] = "9482db64965b1dfcc7ecd91a13d51a1d6cb5f838a5a58dbe49e6a70cc018646679bbbe11bf413d6ae89ca8ee38dee07ba227bf88d60e4160d5a47ef7d2842e91"
SRC_URI[deb1.md5sum] = "c242fbb8fa18c101df1628b8a600cc88"
SRC_URI[deb1.sha1sum] = "5b9699f1ce7aff4b8ed59ffe3484ea63e323e1d2"
SRC_URI[deb1.sha256sum] = "6b053cefeb22e8c113c019e7608bbb27cfbe9a1dd21b06ab685237ca547026db"
SRC_URI[deb1.sha512sum] = "88893a6454ddf81af6d48fd5dd59e4af17fb9cbe1b0a30e902e5db7eceee3f37191eaff9fe27d73c6c5b7589d62cd9ced3368ed485eb32802c2e902d3674a94e"

RDEPENDS = " \
    libc6 \
    libqt6core6t64 \
    libqt6gui6 \
    libqt6qml6 \
    libqt6qmlmodels6 \
    libqt6quick6 \
    libstdc++6 \
    qt6-base-private-abi \
    qt6-declarative-private-abi \
"

