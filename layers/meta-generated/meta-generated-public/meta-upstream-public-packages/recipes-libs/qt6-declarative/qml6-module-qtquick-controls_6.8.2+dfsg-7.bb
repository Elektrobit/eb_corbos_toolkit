# This was autogenerated! Do not modify
SUMMARY = "Qt 6 Quick Controls QML module"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "qt6-declarative"
HOMEPAGE = "https://www.qt.io/developers/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/q/qt6-declarative/qml6-module-qtquick-controls_6.8.2+dfsg-7_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/q/qt6-declarative/qml6-module-qtquick-controls_6.8.2+dfsg-7_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "23b9de20db04703cf0aa3e5bdebd77d7"
SRC_URI[deb0.sha1sum] = "f8d84f59fb3cd35b78526287c3e08370209ff5a4"
SRC_URI[deb0.sha256sum] = "e6a2cb6f3354f5442f318cdc5821ac3ac3a529be23a74e072bdfd1ee45fdafe4"
SRC_URI[deb0.sha512sum] = "60bb9849071f48960d7efb28ab63f33eca55bdaab522f9ba52f9bd3a966f33262aa8a385e20bfb4f22e12ce869263d607373dab2eed26ea5869a76eb12fc9c7a"
SRC_URI[deb1.md5sum] = "8d2512e2931b006abe6cff90bc3a7dd0"
SRC_URI[deb1.sha1sum] = "601adc7e138e390a86f85c702eefca424a321909"
SRC_URI[deb1.sha256sum] = "e09bff665fc9cfb59bc58d2591b0302144f23e4720426452cef4c3e128c97132"
SRC_URI[deb1.sha512sum] = "f5f4c912b30b2f44b28ab3b4233ccf795038b94ffcf66fce52c3f4c4109500784a2e2bd1726bc132e802ef3e57f10751691898d0b14be82f318b946db8d5f3c1"

RDEPENDS = " \
    libc6 \
    libqt6core6t64 \
    libqt6qml6 \
    libqt6quickcontrols2-6 \
    libstdc++6 \
    qml6-module-qtquick \
    qml6-module-qtquick-shapes \
    qml6-module-qtquick-templates \
    qml6-module-qtquick-window \
    qt6-base-private-abi \
    qt6-declarative-private-abi \
"

