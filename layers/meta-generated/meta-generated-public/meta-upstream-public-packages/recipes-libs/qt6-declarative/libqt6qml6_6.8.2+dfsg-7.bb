# This was autogenerated! Do not modify
SUMMARY = "Qt 6 QML library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "qt6-declarative"
HOMEPAGE = "https://www.qt.io/developers/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/q/qt6-declarative/libqt6qml6_6.8.2+dfsg-7_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/q/qt6-declarative/libqt6qml6_6.8.2+dfsg-7_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "50a6615160801d4f41790015cfbe2dc5"
SRC_URI[deb0.sha1sum] = "110b14a6853bd062b4887f2a99b713a9de9b7e1f"
SRC_URI[deb0.sha256sum] = "eb6b7563d9718b8e51187dfa89d2ce291aa77fb209762e43488b8415a832e54f"
SRC_URI[deb0.sha512sum] = "fa551180e49f6aaac89023dc7544dc850f5d41823dc1bf4ebd9810f43b4aa1630bba65cf481e75006e4dfe23c9157426ac7b86bb95a17eccef33ff107c4e5cce"
SRC_URI[deb1.md5sum] = "20c5aedf66957e2917f39e5b28ab7595"
SRC_URI[deb1.sha1sum] = "2ab88cde2ba88f2e4b8c9e4ba2471dd01ffa65d0"
SRC_URI[deb1.sha256sum] = "4c3faf0e1548312e67fdf9df8d5c871674fea851ecf65b13c84a517643da3f0f"
SRC_URI[deb1.sha512sum] = "9eb1fbf81c0f45d0976dbc43c4374abcbccc5ac9e7b45ce21d7ceb71745f521139973617addf97cc0f20ab372d4b9e95117acc276ab4cdcfb5304c7518a30fd4"

RDEPENDS = " \
    libc6 \
    libgcc-s1 \
    libqt6core6t64 \
    libqt6network6 \
    libstdc++6 \
    qt6-base-private-abi \
"

RPROVIDES = " \
    qt6-declarative-private-abi \
"
