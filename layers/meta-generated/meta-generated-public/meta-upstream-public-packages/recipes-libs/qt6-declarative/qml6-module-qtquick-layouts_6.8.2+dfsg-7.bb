# This was autogenerated! Do not modify
SUMMARY = "Qt 6 Quick Layouts QML module"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "qt6-declarative"
HOMEPAGE = "https://www.qt.io/developers/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/q/qt6-declarative/qml6-module-qtquick-layouts_6.8.2+dfsg-7_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/q/qt6-declarative/qml6-module-qtquick-layouts_6.8.2+dfsg-7_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "d6bd382a0a4dc291c702a4f835a59b97"
SRC_URI[deb0.sha1sum] = "2cb4589d3965c6c08ccf11e1160fd1046c108fe6"
SRC_URI[deb0.sha256sum] = "9e6e04deb39c379886586ffd02d442627f9743e619b453501d29f69fda3c59a6"
SRC_URI[deb0.sha512sum] = "ed02a7e330aad796ed5a8207e33db4d8697bd6f275c5fad5e137584ed6e9a6287a0683f4fd8a0c7662415d552bf061ae5d69abfb663e1a6e8d6c0e4df49a8a9e"
SRC_URI[deb1.md5sum] = "624dce76fb65578f6694fe91b3ba2b22"
SRC_URI[deb1.sha1sum] = "53aa875ddc9efeb04f887e182d1a5577a8b7ec21"
SRC_URI[deb1.sha256sum] = "bd6e30c5e6e1b5ab1ff5ca8f3378e42eccb385c1892c1e68222a2a056c014a0f"
SRC_URI[deb1.sha512sum] = "fe9e54780ddb5329f437d4b98e594d2b16d0a1debd3baa877378636b8dfe1a30e60128f002906c87114587a15f22bef1cd07e7ec5a77a67445ec07d03ac4c032"

RDEPENDS = " \
    libc6 \
    libqt6core6t64 \
    libqt6gui6 \
    libqt6qml6 \
    libqt6quick6 \
    libstdc++6 \
    qml6-module-qtquick \
    qt6-base-private-abi \
    qt6-declarative-private-abi \
"

