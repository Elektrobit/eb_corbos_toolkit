# This was autogenerated! Do not modify
SUMMARY = "Qt 6 Quick Templates QML module"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "qt6-declarative"
HOMEPAGE = "https://www.qt.io/developers/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/q/qt6-declarative/qml6-module-qtquick-templates_6.8.2+dfsg-7_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/q/qt6-declarative/qml6-module-qtquick-templates_6.8.2+dfsg-7_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "9ee3d44b17432f8a0019409a45830736"
SRC_URI[deb0.sha1sum] = "5060059215608b441710909144934718dc6f1549"
SRC_URI[deb0.sha256sum] = "93e12d44f28733db6e48df85accd87f1ad968582e3918f63c82290283fce0e66"
SRC_URI[deb0.sha512sum] = "de4e0f8628aeed5a376aee1e682d92ecee19c380b1553acdf24d5c10670d9f04246c69d4f040c087e1a55906511b86ea93b4aef5fa37e591b8f8e4d161dad73a"
SRC_URI[deb1.md5sum] = "0ed847d6414362f20965d044a4f99da4"
SRC_URI[deb1.sha1sum] = "93a175daf9b5749178204689b43f67a3a66ef580"
SRC_URI[deb1.sha256sum] = "ffc6ce7a85489b938b6f9425f88ed7da1787d6b6ba5b6968a8ba7c022e4dbf7c"
SRC_URI[deb1.sha512sum] = "a012d5c4323481843cbe0f3da5c8f79ab30e8c715220c9e153fb2576c8bac8b8710b84e82b32c204bdf1834c12387898da3705ad13556f8fe491ff84ac27acdd"

RDEPENDS = " \
    libc6 \
    libqt6core6t64 \
    libqt6qml6 \
    libqt6quick6 \
    libqt6quicktemplates2-6 \
    libstdc++6 \
    qml6-module-qtquick \
    qt6-declarative-private-abi \
"

