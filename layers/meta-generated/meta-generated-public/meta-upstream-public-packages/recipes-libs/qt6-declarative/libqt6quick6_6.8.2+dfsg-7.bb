# This was autogenerated! Do not modify
SUMMARY = "Qt 6 Quick library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "qt6-declarative"
HOMEPAGE = "https://www.qt.io/developers/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/q/qt6-declarative/libqt6quick6_6.8.2+dfsg-7_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/q/qt6-declarative/libqt6quick6_6.8.2+dfsg-7_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "8d9865397345665e238a2aced5e1197f"
SRC_URI[deb0.sha1sum] = "a085d793b954eb1fe81e4ac42cdf001536d45705"
SRC_URI[deb0.sha256sum] = "a8be231bf934418bfd608ca26843e352d3f989cf4c169efd9fb0a27b0a6026e2"
SRC_URI[deb0.sha512sum] = "86b2946f2367c23412ec127f062d5b446edfd561c4adbbc96e973c4da4cae36e79ddf27334b5222e74df030f4055cecea715fff497332e489592c6787cae5eaa"
SRC_URI[deb1.md5sum] = "ba781c08d9b3f438af6e67bd5dbe1fb4"
SRC_URI[deb1.sha1sum] = "a42976b32c377704c5e1586b22114b708e48c99b"
SRC_URI[deb1.sha256sum] = "364c5b773152a2baeb467f40ed86ef8ba1c792d4a78b7d261bf716b367862211"
SRC_URI[deb1.sha512sum] = "151ff354270c6c69ebc54f8ec253da60dbce5ce3c7099e72205ce486263b6dc1915576addbacf3d3d50208845f545043a7ef044e4c0f32b9bf22f4496587d698"

RDEPENDS = " \
    libc6 \
    libqt6core6t64 \
    libqt6gui6 \
    libqt6network6 \
    libqt6opengl6 \
    libqt6qml6 \
    libqt6qmlmeta6 \
    libqt6qmlmodels6 \
    libstdc++6 \
    qt6-base-private-abi \
    qt6-declarative-private-abi \
"

