# This was autogenerated! Do not modify
SUMMARY = "Qt 6 QML WorkerScript library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "qt6-declarative"
HOMEPAGE = "https://www.qt.io/developers/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/q/qt6-declarative/libqt6qmlworkerscript6_6.8.2+dfsg-7_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/q/qt6-declarative/libqt6qmlworkerscript6_6.8.2+dfsg-7_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "6398674a9625ca8bf5ce9f6ac459881f"
SRC_URI[deb0.sha1sum] = "349112f25d5bc7a89f9a3e728f314303f101c934"
SRC_URI[deb0.sha256sum] = "f9a83618fbb64ddeb996d91500cd025e03cc1345893d3134ff8d2b96eb244b36"
SRC_URI[deb0.sha512sum] = "cd756ee8ce5d8e032cb0e0ddc88fca54d8748e4cf5559210386f7980d7ed5a9b635104d6519dcdad33fcfa120fc14a5dba8625a42036174047c921cd34cf12fa"
SRC_URI[deb1.md5sum] = "5ecddf8bb548ae1b922c6bec749472ea"
SRC_URI[deb1.sha1sum] = "10d97c41d3bcf05167ddc76ffd66f14623c044f6"
SRC_URI[deb1.sha256sum] = "cdba1936fe5a9d516fdbe060e6968876f941feb4d562e601cb87477d35d8b97d"
SRC_URI[deb1.sha512sum] = "0e8549edcbdecc1cdf3c3f24d0e831149fba12ab8dee77ad4cc87dc62d42970c8deab237d22cb1a9f0706319b6df7816d9ff3d38bceab2bea34b780251c48f2f"

RDEPENDS = " \
    libc6 \
    libqt6core6t64 \
    libqt6network6 \
    libqt6qml6 \
    libstdc++6 \
    qt6-declarative-private-abi \
"

