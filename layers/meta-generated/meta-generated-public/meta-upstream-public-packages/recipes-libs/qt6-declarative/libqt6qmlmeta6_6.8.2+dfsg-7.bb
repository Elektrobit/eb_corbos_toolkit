# This was autogenerated! Do not modify
SUMMARY = "Qt 6 QML Meta library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "qt6-declarative"
HOMEPAGE = "https://www.qt.io/developers/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/q/qt6-declarative/libqt6qmlmeta6_6.8.2+dfsg-7_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/q/qt6-declarative/libqt6qmlmeta6_6.8.2+dfsg-7_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "afe3fb27118c3b5012e641e89511458c"
SRC_URI[deb0.sha1sum] = "a8327ab9c4bab1455ead3cb40b7a5577d1840141"
SRC_URI[deb0.sha256sum] = "913e34e3fdbde1b1774c68c858be62fc3065ff4914fb3e1c3eb144be8f199e3f"
SRC_URI[deb0.sha512sum] = "665339e833d8770127359aa0e61392d0e8b2c16248f3259ebdc4c45aa2a20eef52897d237a89aba1c5faafd768a91bc695ab68fde965bea936abc548a696bdde"
SRC_URI[deb1.md5sum] = "66f6e3ebfa2f1aeeef0a10b4ec78e638"
SRC_URI[deb1.sha1sum] = "6323af431d4344a5ad88154ca654ad9d509b5394"
SRC_URI[deb1.sha256sum] = "a8bca5d8bc34e9631491ab49fc7a4b1bbb46215a77dd3bd52f2a7ea8637b6b35"
SRC_URI[deb1.sha512sum] = "756e0526d8758b1b12049b4db67625cb9c57e867622e82b4eb62bb3c6eaca2022194ff970f95c6526a5e311e528389de64d70c340c9969161cde2e9581232156"

RDEPENDS = " \
    libc6 \
    libqt6core6t64 \
    libqt6qml6 \
    libqt6qmlmodels6 \
    libqt6qmlworkerscript6 \
    libstdc++6 \
    qt6-base-private-abi \
    qt6-declarative-private-abi \
"

