# This was autogenerated! Do not modify
SUMMARY = "Qt 6 Quick Controls 2 library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "qt6-declarative"
HOMEPAGE = "https://www.qt.io/developers/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/q/qt6-declarative/libqt6quickcontrols2-6_6.8.2+dfsg-7_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/q/qt6-declarative/libqt6quickcontrols2-6_6.8.2+dfsg-7_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "885c103d013bf2ae5d740fa2c66ba71a"
SRC_URI[deb0.sha1sum] = "d42cbf316a034abe550d8cf72b2614cde58da782"
SRC_URI[deb0.sha256sum] = "7b45104aa7b8a25072d1ec8496eb27546b98877b9b90d7d64f57ac39a4a01751"
SRC_URI[deb0.sha512sum] = "141e98dfd640133fd6bd532dc4925a8b9f9fe0196821a30f1f254c0ecd917e5ad5615ca3e1be1a8e1848e18581a42d1880c5b409a602f926fc02dcbae5115c09"
SRC_URI[deb1.md5sum] = "7c9423afd9945f821c009ee2ac204d6a"
SRC_URI[deb1.sha1sum] = "751706cd675afb1d65226387cb8c9475bf81531c"
SRC_URI[deb1.sha256sum] = "79338d8eb8605930a9c75fc015d6da5a12d8c584af7fb396fef15736690d8fc6"
SRC_URI[deb1.sha512sum] = "5165b4102893aa9e5a83d228ed2fc69c17faa688843c4908b3965cd41a1b47fbe665cc2c62498376aaefb783aeafec3f8da6e4c72b271707864a1904c5333df6"

RDEPENDS = " \
    libc6 \
    libqt6core6t64 \
    libqt6gui6 \
    libqt6qml6 \
    libqt6quick6 \
    libqt6quicktemplates2-6 \
    libstdc++6 \
    qt6-base-private-abi \
    qt6-declarative-private-abi \
"

