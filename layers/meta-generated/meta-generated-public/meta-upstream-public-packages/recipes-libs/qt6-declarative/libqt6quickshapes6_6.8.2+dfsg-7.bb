# This was autogenerated! Do not modify
SUMMARY = "Qt 6 Quick Shapes library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "qt6-declarative"
HOMEPAGE = "https://www.qt.io/developers/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/q/qt6-declarative/libqt6quickshapes6_6.8.2+dfsg-7_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/q/qt6-declarative/libqt6quickshapes6_6.8.2+dfsg-7_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "251441d53c7c325ad4c4526623fa487b"
SRC_URI[deb0.sha1sum] = "325eb044391af04a3254b870caa2eb7b6744659d"
SRC_URI[deb0.sha256sum] = "0040813d70aa86d0f2fccf44053ee108a694b23d6008d53660e14f30b9f65c64"
SRC_URI[deb0.sha512sum] = "a90e1e7c05c4bd3d15388650c23705c2ac553e487aef0440f43663176b2620b0cc0f12b17fabdac4a75cc1bcbdf509f1eb4df6dd5a84d174daab8442578aaad8"
SRC_URI[deb1.md5sum] = "8e365d46ce09c9e8e91060d2584334c0"
SRC_URI[deb1.sha1sum] = "8cb80b4949a086d85d9394e3c8256d13ac95ad4f"
SRC_URI[deb1.sha256sum] = "22cecae670af79c2b79b7902c0b525c1ac8056d9c7dbce93e1cbee069db0d82a"
SRC_URI[deb1.sha512sum] = "1f4f1db05cc8a24192400d108b96ad0979688c6aa5bb75fb485c7497b7da019541c69bff6eb1168c9ee1f2d9a256f343828929b76a0155d57a02a004a8ee2903"

RDEPENDS = " \
    libc6 \
    libqt6core6t64 \
    libqt6gui6 \
    libqt6qml6 \
    libqt6quick6 \
    libstdc++6 \
    qt6-base-private-abi \
    qt6-declarative-private-abi \
"

