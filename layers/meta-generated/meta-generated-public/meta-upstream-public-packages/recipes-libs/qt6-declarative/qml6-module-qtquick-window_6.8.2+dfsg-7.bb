# This was autogenerated! Do not modify
SUMMARY = "Qt 6 Quick Window QML module"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "qt6-declarative"
HOMEPAGE = "https://www.qt.io/developers/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/q/qt6-declarative/qml6-module-qtquick-window_6.8.2+dfsg-7_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/q/qt6-declarative/qml6-module-qtquick-window_6.8.2+dfsg-7_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "bffc22f6fae1da48e5f64e1136250eed"
SRC_URI[deb0.sha1sum] = "ffebf0f974c11168c2b974d93d2a60afcbcffc0f"
SRC_URI[deb0.sha256sum] = "1dc40b972c99bb09b014b0c39b2253154e82fd1c797ca883c0b7b65b91ad0c44"
SRC_URI[deb0.sha512sum] = "37f038f3927a3c41053fb7d28e45a82e4597611f60e8ce6c3149678c163b0c6b3c586d7bf3bcd9b53619b92445d86a6bf8e04bd5b51b8f85a44da9b3bccc1981"
SRC_URI[deb1.md5sum] = "2f745509cb2c31ba4edbb5235849b8b2"
SRC_URI[deb1.sha1sum] = "3bddcb3da216f451c3f1d8f4e818290f3bc014aa"
SRC_URI[deb1.sha256sum] = "ecd1cc14d727f78137823f84016448ff92e606b4ecb5209cad26e211281f904c"
SRC_URI[deb1.sha512sum] = "2dbab529b22090b85ee0212e94461fb3a61f131fcafc133e40f0072c2ddc9a05919665760ed72f9f374dd3d08cade6e41460d8b9c905c1bc18a9a200fbe52fe0"

RDEPENDS = " \
    libc6 \
    libqt6core6t64 \
    libqt6qml6 \
    libstdc++6 \
    qml6-module-qtquick \
"

