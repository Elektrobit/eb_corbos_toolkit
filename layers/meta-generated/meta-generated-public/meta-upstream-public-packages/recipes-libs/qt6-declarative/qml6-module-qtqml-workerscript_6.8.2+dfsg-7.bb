# This was autogenerated! Do not modify
SUMMARY = "Qt 6 QtQml Workerscript QML module"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "qt6-declarative"
HOMEPAGE = "https://www.qt.io/developers/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/q/qt6-declarative/qml6-module-qtqml-workerscript_6.8.2+dfsg-7_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/q/qt6-declarative/qml6-module-qtqml-workerscript_6.8.2+dfsg-7_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "b2850e3cc9a9e2749c2b2fa206a667be"
SRC_URI[deb0.sha1sum] = "4afaf653b9aa73334fb83edc3416645f58f70357"
SRC_URI[deb0.sha256sum] = "b823947c35ed7b722cd31cb6020cae7d05b4e97fd33be57848affb4907b4bfe9"
SRC_URI[deb0.sha512sum] = "cebf99c3d80f03e46a3ef0ea80de16c73085e482599454a824c3d2d1bce30d222d4eb81cdb026fc9f7b748b42dd767d71415bb464560e8d0b1972f50286011e5"
SRC_URI[deb1.md5sum] = "10ff0b7f156ece4f707ac2e5a4a5dd7e"
SRC_URI[deb1.sha1sum] = "3825f10512dbf58e7f6516c863c2e8abe922c2b3"
SRC_URI[deb1.sha256sum] = "0d18ad1be01b23da8611e9becbb0bf5510c56b7725ee0b107a94b6af96f1d9de"
SRC_URI[deb1.sha512sum] = "ae5645ff2a00b10cbbfcd80cbe2525aea00b22481485a1f881818e6d95c9823ae5a6c2e1984109cc1389d3cc842e796202e1e06cc42d67e0be94180af4a6957e"

RDEPENDS = " \
    libc6 \
    libqt6core6t64 \
    libqt6qml6 \
    libqt6qmlworkerscript6 \
    libstdc++6 \
"

