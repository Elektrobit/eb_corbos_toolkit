# This was autogenerated! Do not modify
SUMMARY = "C interface to the Clang library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "llvm-toolchain-19"
HOMEPAGE = "https://www.llvm.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/l/llvm-toolchain-19/libclang1-19_19.1.7-3+b1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/l/llvm-toolchain-19/libclang1-19_19.1.7-3+b1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "cd40861f9c2f5bd6115ecd3af0ee84be"
SRC_URI[deb0.sha1sum] = "9b1ebf0f4247d0e37b3b4eaf18c2308adc49b8f2"
SRC_URI[deb0.sha256sum] = "4e7e2a5fe236e280d32fb529350b3c1cfd9410a964629a57ea079a314c45d7a3"
SRC_URI[deb0.sha512sum] = "5a29a3eaf4434c658154aa0aacf9f0030dfd64c40b251676577494df628c58eb1abea9a9873e85a0f368d8b3e5aa83bb812991ca3abb429963aefb3d7d63f3f7"
SRC_URI[deb1.md5sum] = "edd8e78067cdb4d7cc3002abeed6a84c"
SRC_URI[deb1.sha1sum] = "3ace2dfdc820d0a40cfe7110d8c7ac0dc90a886e"
SRC_URI[deb1.sha256sum] = "e0719cbb2bd6bb3b91f471d1fa41b364eae0604774db56a7b3dd8d24738a5f20"
SRC_URI[deb1.sha512sum] = "e5dbe9b388772ec9cb5ecb7e3254dc07e8e6626d4cde7897462bd8cd09c1b04502e147e82207ce1bedc04345001fd2b9a4f25029d6b260a5ba8cd5fb91998921"

RDEPENDS = " \
    libc6 \
    libgcc-s1 \
    libllvm19 \
    libstdc++6 \
"

