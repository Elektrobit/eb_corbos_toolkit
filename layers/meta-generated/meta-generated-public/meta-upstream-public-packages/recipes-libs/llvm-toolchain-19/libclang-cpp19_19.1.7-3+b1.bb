# This was autogenerated! Do not modify
SUMMARY = "C++ interface to the Clang library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "llvm-toolchain-19"
HOMEPAGE = "https://www.llvm.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/l/llvm-toolchain-19/libclang-cpp19_19.1.7-3+b1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/l/llvm-toolchain-19/libclang-cpp19_19.1.7-3+b1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "65fb898fa55d239c507672f56c9402f3"
SRC_URI[deb0.sha1sum] = "436e341b9f66dc5fd1af6fdfa643133bf2938701"
SRC_URI[deb0.sha256sum] = "a7d2b6df51050834f6ea5c0d5e34869c2298b0bcdaa91eff17ba3db2cd545c47"
SRC_URI[deb0.sha512sum] = "8b2f580246537d0236b8886fc785be51e99e54a76961910099e3da4336d612fe9bd5515856b5d2ecca9521e2273cbc46e418a127534c4c7e2b1d589928fcce18"
SRC_URI[deb1.md5sum] = "5fb6fc4f0b12f6775e951c64673f9c1a"
SRC_URI[deb1.sha1sum] = "6fb7a082ac9793fdee9413af97f33f5c18a3751f"
SRC_URI[deb1.sha256sum] = "9c0465b890bc962467043fa47dd0fc4dbb278422c3fdf7f7f0e1c3e6e8a13620"
SRC_URI[deb1.sha512sum] = "1e6176db05b40b83d5e0127f3d013ce9d7f336f6dcbb25906916171d6372910337b5811b0391c7237955c7fc4ff45a79b3f8aab64fef407506229936a5d4b94c"

RDEPENDS = " \
    libc6 \
    libgcc-s1 \
    libllvm19 \
    libstdc++6 \
"

