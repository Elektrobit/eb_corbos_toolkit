# This was autogenerated! Do not modify
SUMMARY = "libcrypt shared library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libxcrypt"
HOMEPAGE = ""

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libx/libxcrypt/libcrypt1_4.4.38-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libx/libxcrypt/libcrypt1_4.4.38-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "37526873776d5dc3c39768419fe62192"
SRC_URI[deb0.sha1sum] = "3680d84faa85fa090a565693365712680b9e5be6"
SRC_URI[deb0.sha256sum] = "0ebc144d662e3197982d1bf3a7b8b35ca845e54c68811de0328b1f0d7c67585c"
SRC_URI[deb0.sha512sum] = "a677a97a7e5079f0ffc6c82af1905999f6806bcef00301d803a5418f75f717fd823c6f86738ccce8355972ade3bf300d8c85c6bd10b8c46081f2f08ecf544fa1"
SRC_URI[deb1.md5sum] = "9c8657cea389511f36165ba800722eeb"
SRC_URI[deb1.sha1sum] = "263e71df2fcf7d57f84544b741204352643562f2"
SRC_URI[deb1.sha256sum] = "b9aaa808aa3812b3de3e54eb5dfb16762c1779db032604abef2354c02fdc29b8"
SRC_URI[deb1.sha512sum] = "c18471c2e62ad69c2bd0b9ffe4a3ce698da5154cd9f42765df537c30cbae1fc1e77595e8e3f8b69dbe06c6220189b38af4c7886a5fdecbd1e35c56c51986b14d"

RDEPENDS = " \
    libc6 \
"

