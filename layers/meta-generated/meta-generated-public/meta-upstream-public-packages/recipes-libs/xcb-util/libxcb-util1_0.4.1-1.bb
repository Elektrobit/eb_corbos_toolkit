# This was autogenerated! Do not modify
SUMMARY = "utility libraries for X C Binding -- atom, aux and event"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "xcb-util"
HOMEPAGE = "http://xcb.freedesktop.org"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/x/xcb-util/libxcb-util1_0.4.1-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/x/xcb-util/libxcb-util1_0.4.1-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "edee1fbb3b245366bd467b629fbc9d4f"
SRC_URI[deb0.sha1sum] = "4cbc14f510c6ebf03bc1cec99e93f966c4be33c2"
SRC_URI[deb0.sha256sum] = "c242371fdfc806aa5599290150c6008a723c9b0fdb34ac6688f1a4083682172a"
SRC_URI[deb0.sha512sum] = "eb64d4ea51174fbdbee592c907e0b4db4df3009e203d3fa4be1a08d63c067db7cf8fdd5530e45d3f4e05d124bd70fba4b507f53bd2c560e3035b803b2ea644fe"
SRC_URI[deb1.md5sum] = "df268c996dc6f1f76b6a8910974b8026"
SRC_URI[deb1.sha1sum] = "129f3ffaf0f6d0f671995c90f59ace8fa485771f"
SRC_URI[deb1.sha256sum] = "a82432686fcb65dbbf5319b79cc68ab9c8a0102e969163219c6f0e0b657e393e"
SRC_URI[deb1.sha512sum] = "13f67df66e2cdb23e09ff80e9201a564625d260ea20a6389b14341c1ab0f2bd2f4a2bd830a7181c4c83ac8ea476b65f8ae2f2d455ed4010909cc7a62bda7e158"

RDEPENDS = " \
    libc6 \
    libxcb1 \
"

