# This was autogenerated! Do not modify
SUMMARY = "Libraries for controlling NUMA policy"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "numactl"
HOMEPAGE = "https://github.com/numactl/numactl"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/n/numactl/libnuma1_2.0.19-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/n/numactl/libnuma1_2.0.19-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "4af0b725a3d4b56dd041469efb53447e"
SRC_URI[deb0.sha1sum] = "d6313a16cf2abfe78bbc49cd6889c4766cf5f968"
SRC_URI[deb0.sha256sum] = "e578583f73f8208564e5035b18aa729c441fc7ecb389c666923552e123f4d655"
SRC_URI[deb0.sha512sum] = "fc093a0fa124ba539a9498f9694f1bc7103542541a9c5a7893a2ba0de9e5be8ac621a7808ca54bc638c4a4ee378a96883cd6226a09289919de9c52d1bca20362"
SRC_URI[deb1.md5sum] = "e3d363b6233b31f4e55cb5897f3f3f06"
SRC_URI[deb1.sha1sum] = "7dbd3f22d035491b4512c40a2e8f04ffa51b405a"
SRC_URI[deb1.sha256sum] = "23bd0d4ecdc8cb44438791c10aab969bc9eb11a4b635aae573376c4e23994ff5"
SRC_URI[deb1.sha512sum] = "3cebc2cc6b80930173730e964271c8a5658d755a4cdf122167375940435343f1ab5f12aa2d0d7ff2a1f10072bf87d29d6a6310b64ba2eed4393c4c0f410b9cdf"

RDEPENDS = " \
    libc6 \
"

