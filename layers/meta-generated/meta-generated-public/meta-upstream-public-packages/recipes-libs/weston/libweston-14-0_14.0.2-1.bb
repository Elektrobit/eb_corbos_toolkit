# This was autogenerated! Do not modify
SUMMARY = "reference implementation of a wayland compositor (shared libs)"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "weston"
HOMEPAGE = "https://wayland.pages.freedesktop.org/weston/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/w/weston/libweston-14-0_14.0.2-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/w/weston/libweston-14-0_14.0.2-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "eb316a7cad1a476909b41840e5ecb7c2"
SRC_URI[deb0.sha1sum] = "3a40326fb847af7c4bd7b5b8dd308fe36618785a"
SRC_URI[deb0.sha256sum] = "882469912622c4ef2b0cf85d9cba56906250a6da7e935580feca868bb7dfe942"
SRC_URI[deb0.sha512sum] = "9871def65ec06cdea82ecda20cd9d31f481cbd199302fd957a225acc8195f2e2f39ac0fb2dd0efeddbaa0885e945d54de9785b8983ddf6d5f921ca757bb22e4a"
SRC_URI[deb1.md5sum] = "c20c64aba0f213d4fe12e6037099e545"
SRC_URI[deb1.sha1sum] = "3d101f37b5720f1fcbb6649b1565ab3bc291039d"
SRC_URI[deb1.sha256sum] = "ba8447c7bfdb2be32300709164a86be95fcfc669287390263b5febf09e460cf0"
SRC_URI[deb1.sha512sum] = "200e41e657b215608a977b862ed313b5efb7b35cf6b307611cc44d5d622e37f2df3d54b3fc86a4c4c03754ba37ba7ecb6a42fbcecb9ac0cc32c697729f54d0ad"

RDEPENDS = " \
    libaml0t64 \
    libc6 \
    libcairo2 \
    libdisplay-info2 \
    libdrm2 \
    libegl1 \
    libfontconfig1 \
    libfreerdp-server3-3 \
    libfreerdp3-3 \
    libgbm1 \
    libgles2 \
    libglib2.0-0t64 \
    libgstreamer-plugins-base1.0-0 \
    libgstreamer1.0-0 \
    libinput10 \
    libjpeg62-turbo \
    liblcms2-2 \
    libneatvnc0 \
    libpam0g \
    libpango-1.0-0 \
    libpangocairo-1.0-0 \
    libpipewire-0.3-0t64 \
    libpixman-1-0 \
    libpng16-16t64 \
    libseat1 \
    libudev1 \
    libva-drm2 \
    libva2 \
    libwayland-client0 \
    libwayland-cursor0 \
    libwayland-egl1 \
    libwayland-server0 \
    libwebp7 \
    libwinpr3-3 \
    libx11-6 \
    libx11-xcb1 \
    libxcb-composite0 \
    libxcb-render0 \
    libxcb-shm0 \
    libxcb-xfixes0 \
    libxcb-xkb1 \
    libxcb1 \
    libxcursor1 \
    libxkbcommon0 \
"

