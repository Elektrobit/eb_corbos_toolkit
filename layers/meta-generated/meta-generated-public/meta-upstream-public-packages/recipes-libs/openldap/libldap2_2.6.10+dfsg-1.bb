# This was autogenerated! Do not modify
SUMMARY = "OpenLDAP libraries"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "openldap"
HOMEPAGE = "https://www.openldap.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/o/openldap/libldap2_2.6.10+dfsg-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/o/openldap/libldap2_2.6.10+dfsg-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "fdbf173c3f3056406044b3dedc2c1617"
SRC_URI[deb0.sha1sum] = "156554a5a8064d450c2103819c5e1901f2482ef9"
SRC_URI[deb0.sha256sum] = "60069e4a550ca890113fa89d3001417781b18e146ec5d637d31e368dec9909bd"
SRC_URI[deb0.sha512sum] = "f5e4a5429015271685ba7494fa8fee2fcc3690fd5d7d301324bc0a6408811d50128230d2d4aa27cceb2b7f1c64f4c8a0242f7958ac50323a56021644e9ca71cc"
SRC_URI[deb1.md5sum] = "8fcb960d6a5b1ac19a6c27417f814a47"
SRC_URI[deb1.sha1sum] = "429adcc30fcd80af242e094a7c35387fe9dfea94"
SRC_URI[deb1.sha256sum] = "38fae6af20d41e4b0a8ea1b96d0b81a7a5551a61595bc866c9af870eadfdf1bd"
SRC_URI[deb1.sha512sum] = "4ff7fea2f2bde00fc2c12034f7ffbb4b5bb9e61cd5daf7961a172e77a118962bb9c19d6536931fcb9a9cadf8895234362aa50242fc8b35f770873ed2fa8f720b"

RDEPENDS = " \
    libc6 \
    libsasl2-2 \
    libssl3t64 \
"

