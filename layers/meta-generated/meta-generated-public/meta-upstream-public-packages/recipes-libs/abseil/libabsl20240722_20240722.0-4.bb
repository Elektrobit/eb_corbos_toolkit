# This was autogenerated! Do not modify
SUMMARY = "extensions to the C++ standard library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "abseil"
HOMEPAGE = "https://abseil.io/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/a/abseil/libabsl20240722_20240722.0-4_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/a/abseil/libabsl20240722_20240722.0-4_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "5407414647aace5e70314f16ff0aeb99"
SRC_URI[deb0.sha1sum] = "ae1afaad597e84f87f29641315d8f646b14663f3"
SRC_URI[deb0.sha256sum] = "78c6d7692890990a27cb1d5bbd95b7bfe47a4183ffafec5b30f689f9b58ec6f7"
SRC_URI[deb0.sha512sum] = "7905116fe3f9d2251ab931233539e818a653f883b6af4126266aeb8204ece4766cfe7b20658234abfd40d1e5a227de4a878d8463b9cfabfe4959c592dd5f8591"
SRC_URI[deb1.md5sum] = "73c23a1338a2f25092a76031ad232fdc"
SRC_URI[deb1.sha1sum] = "5d2479b3bcedb7edb2ae86964c2c4627b1f8148f"
SRC_URI[deb1.sha256sum] = "eb6648c73cd69c577a2bc18c8d66d44de897c0207a734ffdb55f91945404d0ac"
SRC_URI[deb1.sha512sum] = "fad5f502919a38e75ece76ee962a45e4a8c23ccd16db5dbe933c3cac3b0baf07e5e5472655a9cb36935635da315915b9fcc95d59fc2bda2760f38a9dbc86772c"

RDEPENDS = " \
    libc6 \
    libgcc-s1 \
    libstdc++6 \
"

