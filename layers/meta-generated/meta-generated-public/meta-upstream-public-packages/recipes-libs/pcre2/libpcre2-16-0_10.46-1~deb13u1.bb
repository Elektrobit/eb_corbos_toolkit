# This was autogenerated! Do not modify
SUMMARY = "New Perl Compatible Regular Expression Library - 16 bit runtime files"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "pcre2"
HOMEPAGE = "https://github.com/PCRE2Project/pcre2"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/pcre2/libpcre2-16-0_10.46-1~deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/pcre2/libpcre2-16-0_10.46-1~deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "5639dcf8bd65bd666bae950bab5f777a"
SRC_URI[deb0.sha1sum] = "f149233a595001e5016d57bbe3ce8b9d93bc3b68"
SRC_URI[deb0.sha256sum] = "9244175a8b0f82e568f17b5b5153fa02f4d8869683e241c0d3ab45872ab1a7d2"
SRC_URI[deb0.sha512sum] = "afb44515da0546f5b745ecb2b5f2f08f6ee1c9b9a684ac2fa9141bc40e0bfd5e064c3c5b00ba988c34872cdbc33d7fb3da82501d2b8f12da2277835cc8d83211"
SRC_URI[deb1.md5sum] = "257d4e9174e33bfe963ab14525e8c3aa"
SRC_URI[deb1.sha1sum] = "6f29bcf9ecdca3c786bb8514ae70ab4239f093e4"
SRC_URI[deb1.sha256sum] = "c1935859e4fdac3306ee577f98dbcee8aec50b8e2ff0892ca2f0fa05ee5f9008"
SRC_URI[deb1.sha512sum] = "55250b04c3d3ff970e617e5e6a6eb8c9707fb886aff346e0fd02c60fe16be3b857f004c7b20c02fdb6dd5b60ca00eaf4227f56cb19ecab172df2bc91ff2d1de3"

RDEPENDS = " \
    libc6 \
"

