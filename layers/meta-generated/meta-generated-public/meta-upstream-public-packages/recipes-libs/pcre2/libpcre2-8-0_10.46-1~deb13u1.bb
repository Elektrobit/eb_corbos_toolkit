# This was autogenerated! Do not modify
SUMMARY = "New Perl Compatible Regular Expression Library- 8 bit runtime files"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "pcre2"
HOMEPAGE = "https://github.com/PCRE2Project/pcre2"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/pcre2/libpcre2-8-0_10.46-1~deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/pcre2/libpcre2-8-0_10.46-1~deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "9e63b5d51cbde99cee8aa2f33a5cba88"
SRC_URI[deb0.sha1sum] = "1594986c3db12e53c6d738df0926766b852e8e9d"
SRC_URI[deb0.sha256sum] = "6aa452af6a07e34498bf8e734e8789c9dd602fb34f12572e62dc1bba4889a60e"
SRC_URI[deb0.sha512sum] = "04287ae81eb915dcf15dc2fa7fc97d4c6fb4a99603969ae09619d9458eaa2a0fbfc4daccd6f8c58d6bb0be23f1e59f8d9c54de89d2108f547a1ffcb9caf5626f"
SRC_URI[deb1.md5sum] = "a8f98115813c7f27048a6b90b4bfb6e0"
SRC_URI[deb1.sha1sum] = "1e8265876139ba7163f53a2295ba6f53a45f944b"
SRC_URI[deb1.sha256sum] = "f74d3e1082c2d6d2f7b4d47e41070de4a7e2f7f9d0e6e0c901ebfe0e82cdd3ee"
SRC_URI[deb1.sha512sum] = "9bd83ec980d3533900120d017fb878d7681ab19ee1b1502cdaf322ef9d0ef1b12df8edf330fd23897de2f644c36c036995aed120cbda56831b2c508d49ab2deb"

RDEPENDS = " \
    libc6 \
"

