# This was autogenerated! Do not modify
SUMMARY = "audio fingerprint library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "chromaprint"
HOMEPAGE = "https://acoustid.org/chromaprint"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/c/chromaprint/libchromaprint1_1.5.1-7_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/c/chromaprint/libchromaprint1_1.5.1-7_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "33279e0a5f183f164de57a42f800edf4"
SRC_URI[deb0.sha1sum] = "3bec2eb2bbadb3c644d44a2904b838338b4b4546"
SRC_URI[deb0.sha256sum] = "ed8decea8352ae56e80862c4630c83f4f863d4eea653382ed8ae43ffacda60b5"
SRC_URI[deb0.sha512sum] = "0b9f1314b7457c0c997321c7b7ffbe13c93ffad2267a8b5bf2bd20a7fbb3ec38076a871bbbff3335492cdde45d56513711a03a42b8e6848da976bc8f469f8646"
SRC_URI[deb1.md5sum] = "75035bb903dd06debc0bb7ceaec20a5c"
SRC_URI[deb1.sha1sum] = "e7a6e1061a6a114147f4045612e2427d250bf3a1"
SRC_URI[deb1.sha256sum] = "4ad44ffa6d4c2af857e3bc4fba69d55373126ab23ba1e841dc69fe937246929c"
SRC_URI[deb1.sha512sum] = "be829a8a89a5ec2b28ff7c2e11691cbea4ffd927d2f41cfbfb74a94832eecb0108f2f8dad4e6c409c37cd813042511263553eb78095acb359d0dab5e54601261"

RDEPENDS = " \
    libc6 \
    libgcc-s1 \
    libstdc++6 \
"

