# This was autogenerated! Do not modify
SUMMARY = "Vulkan loader library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "vulkan-loader"
HOMEPAGE = "https://github.com/KhronosGroup/Vulkan-Loader"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/v/vulkan-loader/libvulkan1_1.4.309.0-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/v/vulkan-loader/libvulkan1_1.4.309.0-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "9e06e13d05fb085333282be777ffbc33"
SRC_URI[deb0.sha1sum] = "0a87d5ca25a9f001af0ec83d4fcc580cb41f1466"
SRC_URI[deb0.sha256sum] = "f47da79cd140264fe21cceb08bc87a71bc7fec05819e4a421f3f518d21101a37"
SRC_URI[deb0.sha512sum] = "e1807adeb9bcbfec79e64ae95955b383d45cb9400f30d8d39463c2921e418fddc339bfec3280995bf14aa81ec63658f1872ea4298f6b5f2c18dc99ba7f7291d3"
SRC_URI[deb1.md5sum] = "84a69b1e16f87268da91ae130fcacd4a"
SRC_URI[deb1.sha1sum] = "f0ea3605f43135591d4084fc5961541c3105f027"
SRC_URI[deb1.sha256sum] = "f5f576d8b9e5703702a9f3254c8c5d130bef17da9db4aecd46ba86cec7a08930"
SRC_URI[deb1.sha512sum] = "e26505b59675a2aaaa6759e1b81d04bc0b0fb0e3da7ea349fd2c45463cb942944e036b95f4479d1e9633ae2f41475d6816d1c2e6629e985bab3dab97f1cdb756"

RDEPENDS = " \
    libc6 \
"

