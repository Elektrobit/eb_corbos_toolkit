# This was autogenerated! Do not modify
SUMMARY = "Video Decode and Presentation API for Unix (libraries)"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libvdpau"
HOMEPAGE = "https://www.freedesktop.org/wiki/Software/VDPAU/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libv/libvdpau/libvdpau1_1.5-3+b1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libv/libvdpau/libvdpau1_1.5-3+b1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "e71f1648d133d49101eb044c85760885"
SRC_URI[deb0.sha1sum] = "ad0aca61f3fd02b46abfdb6c6622cd8d9a7c30fc"
SRC_URI[deb0.sha256sum] = "7c872493296cc8ce829ab38a68b5e51c351466a5fd0daf485984c829282a94e3"
SRC_URI[deb0.sha512sum] = "f21e0ab5c3957f3f4f682a5040536b53348f0faf0b3204c3c5e6ed5b3a9e273ecaf96a82aca9ead080aa7b8397d29ed45cee72fb45ec1a4bf50d21fabed60025"
SRC_URI[deb1.md5sum] = "6dd4a390c88312a11c93496a1605fa68"
SRC_URI[deb1.sha1sum] = "9ca705767d4cf0b14579570cbe8aeb8fa5e6456b"
SRC_URI[deb1.sha256sum] = "2ec2bf9930e402330e6b165645cdcb1e5b8528ac9782651d0217e4f827bf1451"
SRC_URI[deb1.sha512sum] = "869babf9e5a2b51e917908efa5fd4959b344a8d4c5dbdbd16d9aee83eb14343854517edd8b0dd5d9242160dd0ecf6337b4bb5a933c5676e998d1ade7e9200c7c"

RDEPENDS = " \
    libc6 \
    libx11-6 \
    libxext6 \
"

