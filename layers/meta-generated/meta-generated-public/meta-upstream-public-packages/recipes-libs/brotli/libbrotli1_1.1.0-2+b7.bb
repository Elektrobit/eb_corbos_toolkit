# This was autogenerated! Do not modify
SUMMARY = "library implementing brotli encoder and decoder (shared libraries)"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "brotli"
HOMEPAGE = "https://github.com/google/brotli"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/b/brotli/libbrotli1_1.1.0-2+b7_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/b/brotli/libbrotli1_1.1.0-2+b7_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "e268acc326140ae9f1731f335335fc8d"
SRC_URI[deb0.sha1sum] = "e5e9327d88edff7e03a5d9f9ab0c46c1d8c06536"
SRC_URI[deb0.sha256sum] = "0fb79f88db210afbd69282ab9649e525f393ec6950ca34da1a6b359250b8d7db"
SRC_URI[deb0.sha512sum] = "946c246c0951c046ea423d4ee514437236140e805c3013215a4411effa66236c17baddf23b55426e91b7731cd32e01f39875ca65fbb18472a8470e21c4a6641f"
SRC_URI[deb1.md5sum] = "16c149a03261d5b1f57ec70e952e6cd1"
SRC_URI[deb1.sha1sum] = "f69489c8e806e77920c1cdd98ca8c2c52257d237"
SRC_URI[deb1.sha256sum] = "10270398c4842e71c72b4081fa1761728b3225d6c8dce7c58d5baafe58a5e18f"
SRC_URI[deb1.sha512sum] = "2863f6676aeaa701e6902d9e35b3bcf3e28d585db7b6b4f0e22c8372d470ae9f7f6239860d7c50c53001744627d6de6d436f7ae7d72c328df1b08ec4bc33d381"

RDEPENDS = " \
    libc6 \
"

