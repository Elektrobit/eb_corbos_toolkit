# This was autogenerated! Do not modify
SUMMARY = "input device management and event handling library - shared library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libinput"
HOMEPAGE = "https://www.freedesktop.org/wiki/Software/libinput/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libi/libinput/libinput10_1.28.1-1+deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libi/libinput/libinput10_1.28.1-1+deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "238e03ff1cff3788f1f80ba308c70a11"
SRC_URI[deb0.sha1sum] = "3ed9791c40910d019f8ebfd5e26d6eb42fabcb82"
SRC_URI[deb0.sha256sum] = "fa967b1a25d8e5c0314459f6abd9e0e7518de7d8e02a8d4e69f51642a88569d4"
SRC_URI[deb0.sha512sum] = "840a15aa5aa7c82ba8edfac654fc1475bf419d80c28b6b3c30320c2d29c92149cedb8a002361ed6d11cb5081d77231bea3b13738343bb834b9754cc741fbdf38"
SRC_URI[deb1.md5sum] = "8574cfb13eb4315227c8593868ac2abd"
SRC_URI[deb1.sha1sum] = "8b01dc2e2ca115872068c5eb43d70811e9bba923"
SRC_URI[deb1.sha256sum] = "a2acd04f3b1e9e91d22a26b63650087a179b6b3dbaddadc92d89edfbb2075ae1"
SRC_URI[deb1.sha512sum] = "2656c5a794811a6ea9b48118b0ea824bf137c06c98de2c189ff771d7e31ef779e1b1801330aba186de6b6925cc94fd0cc1db311e1c7088fd721f0f312800731b"

RDEPENDS = " \
    libc6 \
    libevdev2 \
    libinput-bin \
    libmtdev1t64 \
    libudev1 \
    libwacom9 \
"

