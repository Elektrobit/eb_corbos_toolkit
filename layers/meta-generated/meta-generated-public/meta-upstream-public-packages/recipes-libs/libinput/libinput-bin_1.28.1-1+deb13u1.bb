# This was autogenerated! Do not modify
SUMMARY = "input device management and event handling library - udev quirks"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libinput"
HOMEPAGE = "https://www.freedesktop.org/wiki/Software/libinput/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libi/libinput/libinput-bin_1.28.1-1+deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libi/libinput/libinput-bin_1.28.1-1+deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "1932f3eec7a3c316a407763dd730ecb4"
SRC_URI[deb0.sha1sum] = "0d74bde073bd08172255aa40424ef031cf8537d8"
SRC_URI[deb0.sha256sum] = "0ef9fc75d9fb4d8aa478baa3e2165c8f3b5e7310c13d9dddbb18029e6cad9143"
SRC_URI[deb0.sha512sum] = "57073d981ec23f60512fc21a325635a060fa8aca61752d1af7052a611e21be140c5f47b3392d50db91ca2e279876499ed4f4ce9fb9a6012bc67789eedd0ced0b"
SRC_URI[deb1.md5sum] = "110adbd0bbabe20595cb5abcea1d7133"
SRC_URI[deb1.sha1sum] = "5d242a4b1e0023f03cbc8bfa6d41e9668becf5a6"
SRC_URI[deb1.sha256sum] = "9da373d042dd8e0c45e34a5a0dc361cb386fd5ff4f066b7b3e64e1ea66de0835"
SRC_URI[deb1.sha512sum] = "4ef48b775fb4cb61b093c3e9ff0751a0ae0093e75c09096cff8de574f7505e52d23196a75bb7fe4876658c3f48e82e6579f4be5cfe4a5e430c67a8207082f839"

RDEPENDS = " \
    libc6 \
    libevdev2 \
    libudev1 \
    libwacom9 \
"

