# This was autogenerated! Do not modify
SUMMARY = "X11 font encoding library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libfontenc"
HOMEPAGE = ""

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libf/libfontenc/libfontenc1_1.1.8-1+b2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libf/libfontenc/libfontenc1_1.1.8-1+b2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "e899d163f43c485b0cb23665dc1b521a"
SRC_URI[deb0.sha1sum] = "4e705f3c7cfd4b8e9ab863def3f543c67bac4c5d"
SRC_URI[deb0.sha256sum] = "49f7330e1bbe3f48946fee5c07870df660374f9f77b378840d6edf1a3b3444cd"
SRC_URI[deb0.sha512sum] = "040b458aa3e52bb4076e81b3aad199c2be146298dfaa0dc0215182df14ba4e24ca5795954247991636e1cb071dce8d4f9549e5d18547dfe6733270806d5fc5ab"
SRC_URI[deb1.md5sum] = "ef55cfb8292db4b7afc304b9e610310a"
SRC_URI[deb1.sha1sum] = "4acc89c4eec03f1010406f3f6cda66b1a681170b"
SRC_URI[deb1.sha256sum] = "f78823e2d6f77708ed8adf72b5af721a46adabbc282243368063d77f2fd7ca4b"
SRC_URI[deb1.sha512sum] = "8a0b7738a4b66cabbc27e566b2ad9ddbfb917a733ef05f68af275360075d6152856af5d84bb3b02e383e412c7ab1253bc3fd4b71f74df1c0fd4412c0de846929"

RDEPENDS = " \
    libc6 \
    zlib1g \
"

