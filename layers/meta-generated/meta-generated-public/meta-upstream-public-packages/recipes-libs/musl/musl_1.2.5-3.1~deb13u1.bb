# This was autogenerated! Do not modify
SUMMARY = "standard C library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "musl"
HOMEPAGE = "https://musl.libc.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/m/musl/musl_1.2.5-3.1~deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/m/musl/musl_1.2.5-3.1~deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "fcf24b7733220e1fd9ca7f655a7056d3"
SRC_URI[deb0.sha1sum] = "d69cb80320535f4bcf59a1e7595c95ef0ce5ef99"
SRC_URI[deb0.sha256sum] = "fd4231e1c189c0ebe01182747f83817593fefa7f6b690c484410646288b60058"
SRC_URI[deb0.sha512sum] = "c892a55a758448cf96e9681443ac22f11e62e1903a67f0116de6816577d7d124a1682d31f981c94b554275eabc5849d8a8a74a8b78d4352e0f783ec35ca698d7"
SRC_URI[deb1.md5sum] = "287d7daf6e75a7839ad892af6a04686f"
SRC_URI[deb1.sha1sum] = "24f09fea241708663978f69254151dc58a33696a"
SRC_URI[deb1.sha256sum] = "46cf1fcaa2d49d1573ef0ceabdb36e04a359a9a37d8e4304024f9018682e3f35"
SRC_URI[deb1.sha512sum] = "6d52abbeb57c06702d5668dbb2aa1e56e42b152ac1160dcdbcf409bc17bf6ab27560cdb396e0fedca73db780b2b48fe1586595e97576fa002a93c635fada0e94"


