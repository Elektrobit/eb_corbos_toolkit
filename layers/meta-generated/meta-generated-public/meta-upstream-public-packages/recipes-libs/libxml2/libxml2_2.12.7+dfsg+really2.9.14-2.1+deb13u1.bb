# This was autogenerated! Do not modify
SUMMARY = "GNOME XML library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libxml2"
HOMEPAGE = "http://xmlsoft.org"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libx/libxml2/libxml2_2.12.7+dfsg+really2.9.14-2.1+deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libx/libxml2/libxml2_2.12.7+dfsg+really2.9.14-2.1+deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "b60f50633c8c325f37184913046a938a"
SRC_URI[deb0.sha1sum] = "c132d2a2f4d804158ef75c9905de00e2f4a9d8c0"
SRC_URI[deb0.sha256sum] = "b4743a0fd8e86379ec2bdfb6b97b99fb1c92a925e538920052316814470e99f8"
SRC_URI[deb0.sha512sum] = "d4c087a72d9652bac129a096c61bb5eccb27d20d870f6538efb4625c84473316c0980417e865f8241dc4cd6193f6aadfbf10b1a1d5106ef64853394c3d10ad21"
SRC_URI[deb1.md5sum] = "74613a97eb9dcca1a0ee89aa35169208"
SRC_URI[deb1.sha1sum] = "0e19b12ad8685aabdd6c26baff8bed0cc5b5580a"
SRC_URI[deb1.sha256sum] = "32baac0386190ff9d0a3994dcb6c18048dff90b69fb0c10861add5efc6c7c8f5"
SRC_URI[deb1.sha512sum] = "96944bc5a1659fe5bc518532911fafb7e9e104d3cccd4074cc79fa95d26e4577a8a5525da5133fb825adad710ef1be034d1bfd06c11c6e4403a3c78cc659bded"

RDEPENDS = " \
    libc6 \
    liblzma5 \
    zlib1g \
"

