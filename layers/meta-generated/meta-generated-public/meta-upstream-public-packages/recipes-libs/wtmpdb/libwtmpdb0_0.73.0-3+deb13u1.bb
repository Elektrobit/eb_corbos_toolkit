# This was autogenerated! Do not modify
SUMMARY = "wtmp database shared library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "wtmpdb"
HOMEPAGE = "https://github.com/thkukuk/wtmpdb/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/w/wtmpdb/libwtmpdb0_0.73.0-3+deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/w/wtmpdb/libwtmpdb0_0.73.0-3+deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "a085775aafdcae3eff357ddbaac1a1ca"
SRC_URI[deb0.sha1sum] = "8a54277f1e4e6f3f102cba5565f3e05d244ea8c6"
SRC_URI[deb0.sha256sum] = "8d6bc1c961d734da58b2d4c35b0a3cd6ad2fe81655bd982c655a97c2255b1c9b"
SRC_URI[deb0.sha512sum] = "6ae873fdecf4d5f8170ce10f1f815bbd0b4e220c3f62bc36c83e0ab5603a03847f6d2ded1a783850122cb806f1c3d73f6cfcf1476cc7cdf08c71e296efe2b76b"
SRC_URI[deb1.md5sum] = "3360f652981339081ca219c4f5d2f978"
SRC_URI[deb1.sha1sum] = "5a5ab755a7dd8ed81a16f2b7a6ee23403e59fdfa"
SRC_URI[deb1.sha256sum] = "6c1e8bcf1192048b0c4d4fcff83debda41b609a0917017aa3faeb47401b1a62e"
SRC_URI[deb1.sha512sum] = "f56a50c421f0b06057cdde162712e5b5acc0f589579eed7f1c875de14fae0df2efb334cac3ae48fb35500debed79ccf682ef9ea4efa6e505446f93d78e1fde05"

RDEPENDS = " \
    libc6 \
    libsqlite3-0 \
"

