# This was autogenerated! Do not modify
SUMMARY = "Library for reading/writing audio files"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libsndfile"
HOMEPAGE = "https://libsndfile.github.io/libsndfile/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libs/libsndfile/libsndfile1_1.2.2-2+deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libs/libsndfile/libsndfile1_1.2.2-2+deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "e2588b28bc4004bdf820bd84c1281981"
SRC_URI[deb0.sha1sum] = "3ddcc8e2802fac219c939657efc878c89e1bc822"
SRC_URI[deb0.sha256sum] = "d92263a045554e6f39c6b1c2ee4cca44a3248d9b9339301ff195969bf84b75eb"
SRC_URI[deb0.sha512sum] = "c7c7ad6691a2a6d95f4c81d4f81697f339548d73fbffbef64d3678fb81671a3484be005aa54ee5188a7ab8c0907d5ba22f6bd893800f8a6c2efb579633eaa0da"
SRC_URI[deb1.md5sum] = "80580cd1586afe07862e8efc0d3ceb79"
SRC_URI[deb1.sha1sum] = "f638a6fc20021964585af5ad8e0ee439d6b35f8b"
SRC_URI[deb1.sha256sum] = "6c94f17e1f02778f98b96bb9ae19ff30085662e96685898a018c26bfd4bfc3f2"
SRC_URI[deb1.sha512sum] = "15bc2b6110727ee2dd9b00e92e52c374278ac8edaf9e47fa0357d966564bd9e3ff08bbaa0d53b0abe83e0338655d73962471552e788ce025e08a0b982ed82326"

RDEPENDS = " \
    libc6 \
    libflac14 \
    libmp3lame0 \
    libmpg123-0t64 \
    libogg0 \
    libopus0 \
    libvorbis0a \
    libvorbisenc2 \
"

