# This was autogenerated! Do not modify
SUMMARY = "shared library for hash functions computing"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "rhash"
HOMEPAGE = "http://rhash.sourceforge.net"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/r/rhash/librhash1_1.4.5-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/r/rhash/librhash1_1.4.5-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "f1b9c1c0daee98643cc71c6f7009ffec"
SRC_URI[deb0.sha1sum] = "972a71fb56f614c7c38ef38415e21b823045a831"
SRC_URI[deb0.sha256sum] = "9bf56d7d8ce3e7680a0dd8e3cfe8acdf50e0aa3b98b0a907cf744a4d1711af72"
SRC_URI[deb0.sha512sum] = "005c8841a939bfac290142aa049cec285412ac233e75b693121a7c02780e3a455c5bf77d10206ef8dc4c881b6cfe419a3a86c9c8bbcfef1972e18bcb3f57e74c"
SRC_URI[deb1.md5sum] = "c0d92646c02b96830cd6e8dd5997b551"
SRC_URI[deb1.sha1sum] = "ab13e98ac3320c9fed6454551ef6166879a1710a"
SRC_URI[deb1.sha256sum] = "3bee5b995ee3219779d0f50b2622b0fbc05bb89c69fa833c83d685a3c88aa73d"
SRC_URI[deb1.sha512sum] = "44d16aae7f2f7527261b2e698a07abcce5cb13ecdbd3da8375cf6a48fc1d36c69e4e04dc17fd5df5b4bb2667d7c2e8dc8e632388e2fd01e449622826c76b1431"

RDEPENDS = " \
    libc6 \
"

