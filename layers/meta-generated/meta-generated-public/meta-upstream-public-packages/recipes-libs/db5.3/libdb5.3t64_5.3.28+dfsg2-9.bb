# This was autogenerated! Do not modify
SUMMARY = "Berkeley v5.3 Database Libraries [runtime]"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "db5.3"
HOMEPAGE = "http://www.oracle.com/technetwork/database/database-technologies/berkeleydb/overview/index.html"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/d/db5.3/libdb5.3t64_5.3.28+dfsg2-9_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/d/db5.3/libdb5.3t64_5.3.28+dfsg2-9_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "e1e13d06a827146d302556533c22d9af"
SRC_URI[deb0.sha1sum] = "a596798c43b00a507bd26b2f5ef5af509c41cf93"
SRC_URI[deb0.sha256sum] = "18d02510ee78b67e4504ba050176797a200ff24214a7cd318082ab60ad7bf3fc"
SRC_URI[deb0.sha512sum] = "86b9e0da75a7f3cd20f74b12a12a566146ad87d10c1a1a4df85f939777cb36cf557f649efb45aaaa662c76b821ff33651e32bca3bbed4c633b76d8f70408c28f"
SRC_URI[deb1.md5sum] = "4c79814db6ccb0d94f83060154a085e9"
SRC_URI[deb1.sha1sum] = "dcab162926a038775628a00674f3ac7eb700a20e"
SRC_URI[deb1.sha256sum] = "bfef56508d69fd3f940668f6abd0a466a362cabf63c4cc1c787cc58d28f6e92f"
SRC_URI[deb1.sha512sum] = "bcff3713437f4a2e0975cd1db43a4de6f6d776061f416feec63c6b0b86f106351007cd8b8bc82389c2bfb352d2a5bf71862690386986648cfe286d27d2966602"

RDEPENDS = " \
    libc6 \
"

RPROVIDES = " \
    libdb5.3 \
"
