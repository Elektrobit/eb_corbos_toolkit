# This was autogenerated! Do not modify
SUMMARY = "module music library based on OpenMPT -- shared library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libopenmpt"
HOMEPAGE = "https://lib.openmpt.org/libopenmpt/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libo/libopenmpt/libopenmpt0t64_0.7.13-1+b1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libo/libopenmpt/libopenmpt0t64_0.7.13-1+b1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "bb28c8ec7d377f8eef722e05983ee39b"
SRC_URI[deb0.sha1sum] = "d345a865c9df63274d6a9f3ed7add10a5e3e8e57"
SRC_URI[deb0.sha256sum] = "37537d1b0dc3798d9157aa453427609a3e7f52c0c89b36563764c193194aaa6a"
SRC_URI[deb0.sha512sum] = "4a5034f089cd3e7b75d918c59f4ca582e4ba6baeec5f563c7217ae147900a75d3478370ed4db8f5b252b65829965d4fbd6baa5154e451ec13b735e2ce6b17384"
SRC_URI[deb1.md5sum] = "efbd25cbe00ea56b77609bd07880f862"
SRC_URI[deb1.sha1sum] = "467b9aef121e8e71f85a38ec4d3db0c096d0738c"
SRC_URI[deb1.sha256sum] = "29e78a3abedd46155a241d64eba0baae5a7a4ba836faac412da94954cc56be7e"
SRC_URI[deb1.sha512sum] = "2856fef1c3a69f76fb27232195a2bdf8a5e88752dd52780390b59bcde9700751357b0df5ea835ef4e741dcc97683136f6c2a63764a180a5887dd2da56a5e1857"

RDEPENDS = " \
    libc6 \
    libgcc-s1 \
    libmpg123-0t64 \
    libstdc++6 \
    libvorbis0a \
    libvorbisfile3 \
    zlib1g \
"

RPROVIDES = " \
    libopenmpt0 \
"
