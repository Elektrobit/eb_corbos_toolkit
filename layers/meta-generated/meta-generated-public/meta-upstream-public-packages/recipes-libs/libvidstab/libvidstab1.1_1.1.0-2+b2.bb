# This was autogenerated! Do not modify
SUMMARY = "video stabilization library (shared library)"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libvidstab"
HOMEPAGE = "http://public.hronopik.de/vid.stab/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libv/libvidstab/libvidstab1.1_1.1.0-2+b2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libv/libvidstab/libvidstab1.1_1.1.0-2+b2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "1917f97bb5018342f491241fa3edf362"
SRC_URI[deb0.sha1sum] = "7aa9e4a1b95421a5555c3a0b0b187fff069ac892"
SRC_URI[deb0.sha256sum] = "248da59fbb0d161666ee40846471f066cef65960735c9a39cc0fa9134db4323f"
SRC_URI[deb0.sha512sum] = "d5f09529bb36d6e075020f106172b52c3ffdf43a6e99178e7b7a3e7e226d0592b339a30f9097b45311374414ef06cfe87022fd227adad58cd516a807830a547d"
SRC_URI[deb1.md5sum] = "d215e764650506e2212467b51ef81747"
SRC_URI[deb1.sha1sum] = "a0f760227c6086479c920efb91a68fc49d582e5a"
SRC_URI[deb1.sha256sum] = "2089ffc9e6f69a0ae0abac293428120cf64b62550dd6ad2a43c1ccea5c93498d"
SRC_URI[deb1.sha512sum] = "57074cf29af470ade8015230f4abe2c42a312c74cc9f2af2d39fc93645231285d5b9fbb1d9c627229dba0d03b6f7f23a43a40f45943c4727de2e34455d1d2ba7"

RDEPENDS = " \
    libc6 \
    libgomp1 \
"

