# This was autogenerated! Do not modify
SUMMARY = "LGPL Crypto library - runtime library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libgcrypt20"
HOMEPAGE = "https://gnupg.org/software/libgcrypt/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libg/libgcrypt20/libgcrypt20_1.11.0-7+deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libg/libgcrypt20/libgcrypt20_1.11.0-7+deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "a6c779cfdca3327232966a8d9bdad748"
SRC_URI[deb0.sha1sum] = "3db7bbd3a4b5752e0a285a6d92c5fa2ed68d644b"
SRC_URI[deb0.sha256sum] = "f0eb41f8cb40896e0822e9ab65611e8383c12b721c76c54764f744abb4a8c247"
SRC_URI[deb0.sha512sum] = "8d1fba59020d26b5c10afaa9ea7c896030a3950f99e645ad3759d24b072f1dc83ae52152a3b6515b08802720316a51550c52262c8f5b65f29f01198c1041e61e"
SRC_URI[deb1.md5sum] = "e504c34699b1f723f5a517d77b178fc9"
SRC_URI[deb1.sha1sum] = "f5012f4a719bed6887f57d133758be7805428c25"
SRC_URI[deb1.sha256sum] = "243a42b879c6675348279a3f9a40e535d57185af00dbfd51b7481e777f163da6"
SRC_URI[deb1.sha512sum] = "2c89f663ea26f35c32f5e095fa1b5c538fc256f3b1fcfca7af481baaf74f8bfd375ca108ab0f3c035e6183ddd4d419349ea7900054e9b43d2150b70b8e139e2b"

RDEPENDS = " \
    libc6 \
    libgpg-error0 \
"

