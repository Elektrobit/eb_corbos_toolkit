# This was autogenerated! Do not modify
SUMMARY = "SSH2 client-side library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libssh2"
HOMEPAGE = "https://libssh2.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libs/libssh2/libssh2-1t64_1.11.1-1+deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libs/libssh2/libssh2-1t64_1.11.1-1+deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "ebbc03c2f321467d2e0ea0097c14f7fd"
SRC_URI[deb0.sha1sum] = "06d870a39f89af810dc74cc6c54947ee57c91374"
SRC_URI[deb0.sha256sum] = "915c4ec450a369d430e0151f9e10e25044ea2f0d6e41901e00a9317e232e5683"
SRC_URI[deb0.sha512sum] = "9985ab784eb7df30ed3a6d96ce9057d411ec6aa6bf253f1564a074dde1013f37d2db9aa4ccc34dd87b6024e8eb51203bf16d8c0e6e9edfb90f5c6aecf34dab51"
SRC_URI[deb1.md5sum] = "e0cc02896d82952930bdf98892e4e1ab"
SRC_URI[deb1.sha1sum] = "e3d64fe84074e2480a852544a3da90ec6599cdca"
SRC_URI[deb1.sha256sum] = "600c2a845d6d14d292c765382bc7e644898762e1634a4aecf5b85329622dbbfe"
SRC_URI[deb1.sha512sum] = "e26f5c97fd3fb5341f675a81497ee2470d83d411cd1aa7c7ad21d827640327c1621eec48431d82387f411f6d36ec7fafe204e7261a551716f20ad0377f3a0ce5"

RDEPENDS = " \
    libc6 \
    libssl3t64 \
    zlib1g \
"

RPROVIDES = " \
    libssh2-1 \
"
