# This was autogenerated! Do not modify
SUMMARY = "Layout and rendering of internationalized text"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "pango1.0"
HOMEPAGE = "https://www.pango.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/pango1.0/libpango-1.0-0_1.56.3-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/pango1.0/libpango-1.0-0_1.56.3-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "eccf5128c85bb458dcf7b2066ccea70e"
SRC_URI[deb0.sha1sum] = "6767b0db3a8873143b0db385102415f960318f77"
SRC_URI[deb0.sha256sum] = "4fa38472696d2ddb10bfc9a4692a9446e8478fdb1f48c769a609fc9fec3adfc5"
SRC_URI[deb0.sha512sum] = "8d054f86d7f016191ad7d1d96384c74d9e2bfa8391686b1966f53684e8ef7c9ad7abcae39b5272fa8954b50574e62cfd5abe2a2c7f6938b93fa759098332c2da"
SRC_URI[deb1.md5sum] = "4d39207955dd04dd2a3a4f28323b142f"
SRC_URI[deb1.sha1sum] = "26548692f07ae5fa7c5ae1d33e61110e919668fe"
SRC_URI[deb1.sha256sum] = "5c5c6061afdff84a76418c9c2cf8bd4f3b6174aa7bf39ddf58bfa7702a59d3f2"
SRC_URI[deb1.sha512sum] = "fd6736ba7514f04b8981665eeaf85bf3d24452e9725e423ff04c9775c5358d5ab6860f3cb142e073a796f9a40ce44635af6420c425eb902a28031868b1a796de"

RDEPENDS = " \
    fontconfig \
    libc6 \
    libfribidi0 \
    libglib2.0-0t64 \
    libharfbuzz0b \
    libthai0 \
"

