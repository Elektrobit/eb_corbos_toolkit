# This was autogenerated! Do not modify
SUMMARY = "Layout and rendering of internationalized text"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "pango1.0"
HOMEPAGE = "https://www.pango.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/pango1.0/libpangocairo-1.0-0_1.56.3-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/pango1.0/libpangocairo-1.0-0_1.56.3-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "0f688eab8250ca56fc7a5249acc12acd"
SRC_URI[deb0.sha1sum] = "9acf73287584b4e492c3e57f43dcf191e4ec960c"
SRC_URI[deb0.sha256sum] = "6994729c5b7a9649661ec078cf039991f22eff44600543aa917894f83c89cd05"
SRC_URI[deb0.sha512sum] = "326ef296e6f102dafecb8ac32af0855498f3ea0d61df42e56ed4296087c1502f68294f1b74fce059ed2c8e9e8a081c40ab0b471d852dcc78596da6a04ce3f63d"
SRC_URI[deb1.md5sum] = "391f87e685b379e858dcf189a1479bba"
SRC_URI[deb1.sha1sum] = "50bdd7eba1bdcbff2836a9e71f18d24d69b2d834"
SRC_URI[deb1.sha256sum] = "1bb68c8dfa0f829cf9834a2dec4af49f82a8dd211e3a9c1fa0446b3f32fa6991"
SRC_URI[deb1.sha512sum] = "86e1dec890ad968e961008dc9babc51dae2ad9bc540ac7072134b5136f8dac3b2afa15cb34e275b9d7e982e67d150a4abf175ed4621a5a97aa0166301594f4fc"

RDEPENDS = " \
    libc6 \
    libcairo2 \
    libfontconfig1 \
    libglib2.0-0t64 \
    libharfbuzz0b \
    libpango-1.0-0 \
    libpangoft2-1.0-0 \
"

