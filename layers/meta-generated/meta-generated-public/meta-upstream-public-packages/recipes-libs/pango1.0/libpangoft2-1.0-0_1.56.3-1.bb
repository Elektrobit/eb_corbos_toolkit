# This was autogenerated! Do not modify
SUMMARY = "Layout and rendering of internationalized text"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "pango1.0"
HOMEPAGE = "https://www.pango.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/pango1.0/libpangoft2-1.0-0_1.56.3-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/pango1.0/libpangoft2-1.0-0_1.56.3-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "f5fa1850c216771c9d9a591787222f41"
SRC_URI[deb0.sha1sum] = "5d08aecad44b86d892ea77f39125d4e28706e8df"
SRC_URI[deb0.sha256sum] = "b506cf66f78ddf542ddb4bb4a68b3d748d41caa6e190e4480430a6630c1e5105"
SRC_URI[deb0.sha512sum] = "b5de14399a4d4467bdb18683380aa8208c6f1eb3f4aa6c2010cc8a3a7c4041f3c43c653d52021eea624259a4f0b883f7907ece2d24a8e72708b87be18bda8e84"
SRC_URI[deb1.md5sum] = "ff5ab37ddb23c21310a3deab28397530"
SRC_URI[deb1.sha1sum] = "968afdd0724d684ee99c014db39ecf7312706a99"
SRC_URI[deb1.sha256sum] = "f0e32d579c7b40dee0ed43355dd832857cf5d477cfb50b0bda56097eca8a81c0"
SRC_URI[deb1.sha512sum] = "8b364a0d9a789233e77d35b8202d5b7f592fb99654be42b7b7446d90855dbe04349cb51cc10f78ea2fa96a7792aaae02bf130e7fae72bbe12ac24490a4b90a31"

RDEPENDS = " \
    libc6 \
    libfontconfig1 \
    libfreetype6 \
    libglib2.0-0t64 \
    libharfbuzz0b \
    libpango-1.0-0 \
"

