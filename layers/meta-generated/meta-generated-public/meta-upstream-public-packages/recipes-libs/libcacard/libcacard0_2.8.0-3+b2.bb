# This was autogenerated! Do not modify
SUMMARY = "Virtual Common Access Card (CAC) Emulator (runtime library)"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libcacard"
HOMEPAGE = "https://cgit.freedesktop.org/spice/libcacard/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libc/libcacard/libcacard0_2.8.0-3+b2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libc/libcacard/libcacard0_2.8.0-3+b2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "df682af5b2f61526e38b8fb7f2219d8f"
SRC_URI[deb0.sha1sum] = "94cf52a84fd1136e67ecc6c9af87bab55e107969"
SRC_URI[deb0.sha256sum] = "1d6a8d17b893e54dfea8fe78df16c9a8ab4a6e626f9312881784592d480d9317"
SRC_URI[deb0.sha512sum] = "b113a47403ba234b6d39460167f1f14d8050e1fae72a6c99b8dcd2526a5342bf3809de0ba9ff087cc920f5b86aac61415e1d41a1466c449de632cfdd460e53a5"
SRC_URI[deb1.md5sum] = "4e29c5f1860863828cf3b1863e4f03b1"
SRC_URI[deb1.sha1sum] = "e669d80716c5375fecb133b2634db8aca04382db"
SRC_URI[deb1.sha256sum] = "54f87ddff1f4ea2dd0b9d14faf7283ce9af1ae02e3a7567af17842251c5266b8"
SRC_URI[deb1.sha512sum] = "880de19ad423d3541ab6d4d916ed982be0418efd8ee8aa2082346566b335bd3ee522aa6e70f62fcc77380c5dee31eb77d00f603c6889dec0ece8b773f83624b8"

RDEPENDS = " \
    libc6 \
    libglib2.0-0t64 \
    libnspr4 \
    libnss3 \
    libpcsclite1 \
"

