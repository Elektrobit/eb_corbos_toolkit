# This was autogenerated! Do not modify
SUMMARY = "Library for sharp RGB to YUV conversion"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libwebp"
HOMEPAGE = "https://developers.google.com/speed/webp/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libw/libwebp/libsharpyuv0_1.5.0-0.1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libw/libwebp/libsharpyuv0_1.5.0-0.1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "438d9fd296a1102dfa7f001641d8857a"
SRC_URI[deb0.sha1sum] = "56e21dcef138ba28b011f05a10d04c2589b8fe28"
SRC_URI[deb0.sha256sum] = "51934833d909588f7761fd84362114e90d8d2d38af57edf5df5c4a705e037547"
SRC_URI[deb0.sha512sum] = "32e76d79c8f166ce899eb4d390b8521e3aa43fede5a49467d3c5d1cb96738162e9d056087023451f8f49dcf6b1dd84bc27f3f834512814a6b8797dd96ae67078"
SRC_URI[deb1.md5sum] = "6143a93112b52815db2656b6ca9548f3"
SRC_URI[deb1.sha1sum] = "07d6d6a041b734251cedf017131bd89b7c73c468"
SRC_URI[deb1.sha256sum] = "5a37f40f806df4b67a2bdaa750add7a9ff29abd3119a8ceac773b886cbf3d9f9"
SRC_URI[deb1.sha512sum] = "01ff055901fc8a038a5b4839f1255b878b0d63c1a9672dc6038be43b6461ac3b390200bc68b586f088b1cd2b95d753866763636b1f230c4028a295da8b8f8b01"

RDEPENDS = " \
    libc6 \
"

