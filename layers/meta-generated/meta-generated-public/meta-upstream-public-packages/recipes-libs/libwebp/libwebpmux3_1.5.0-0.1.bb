# This was autogenerated! Do not modify
SUMMARY = "Lossy compression of digital photographic images (libwebpmux library)"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libwebp"
HOMEPAGE = "https://developers.google.com/speed/webp/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libw/libwebp/libwebpmux3_1.5.0-0.1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libw/libwebp/libwebpmux3_1.5.0-0.1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "ce411829b540c56881f7cb6cfff1d558"
SRC_URI[deb0.sha1sum] = "366bf18b2fc5dbdca483ab8dfabc2384da1fbe36"
SRC_URI[deb0.sha256sum] = "8bc86d509406ad496b6414c7068b3dadc0f8c502027973cbf1765c7bb54fabdf"
SRC_URI[deb0.sha512sum] = "df217382f394d8c55b86a2d17517d49b158fb6124ea890783673a85917ba7b3fef715e300114095b4bca703365e29e4fe761d20c58e792f3fa272a5b8bf6ec27"
SRC_URI[deb1.md5sum] = "bc4d9f1b82fd406e2f66c175cd38252f"
SRC_URI[deb1.sha1sum] = "54127f2cdf7899ff6d414ed0412ad74a4fcdb945"
SRC_URI[deb1.sha256sum] = "84a98af076003c5a502afb95b2a1412e14dbe029e10272ddcdf2ac6f75d8c0d1"
SRC_URI[deb1.sha512sum] = "34d0974fa22b9ef3f15d3768e6964221dcd65b26d837044d0e34b9270d88a1f24bd6c5362e1ba7e76c54c5c0c82d8847b1f091055286b0ff96cc29bc4536ec90"

RDEPENDS = " \
    libc6 \
    libwebp7 \
"

