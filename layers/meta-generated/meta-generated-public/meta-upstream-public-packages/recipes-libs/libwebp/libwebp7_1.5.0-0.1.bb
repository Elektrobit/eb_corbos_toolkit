# This was autogenerated! Do not modify
SUMMARY = "Lossy compression of digital photographic images (shared library)"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libwebp"
HOMEPAGE = "https://developers.google.com/speed/webp/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libw/libwebp/libwebp7_1.5.0-0.1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libw/libwebp/libwebp7_1.5.0-0.1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "bf682e1e438b4927c3807cad4ca6c1a9"
SRC_URI[deb0.sha1sum] = "7be5c58d2594133d0fa1dd5c9f7b8a7d2cd087c8"
SRC_URI[deb0.sha256sum] = "c749744b04abdd1426b0c7718e516362c03a557c5151662092d6d4f2cef6e7c1"
SRC_URI[deb0.sha512sum] = "180ca001612b0fe5e835f57cb038e0b43f6107ea5e8b01311ec3a3fc9fc07e04b338c2d637e474d1a796062981fabba0cdb426802197b5a35e5d4c0656c23870"
SRC_URI[deb1.md5sum] = "0bdff7bdf9375f77808b4cb20515ced6"
SRC_URI[deb1.sha1sum] = "77d229cc2065a218bc9860ff1cac67f9bb1ba993"
SRC_URI[deb1.sha256sum] = "d5ebdb920770ee135c4e319babb2bcef61e9f37283a37a8cb4e673769dd0d676"
SRC_URI[deb1.sha512sum] = "19ec55dd51b6c9c883c2b9cd323d1c06db06403532e81d55da7bc6db916615d32c3cb7fcd1141027ef793fb29119d8dd4c1118fb9930d8eb08a262c92895c9dd"

RDEPENDS = " \
    libc6 \
    libsharpyuv0 \
"

