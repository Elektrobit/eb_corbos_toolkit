# This was autogenerated! Do not modify
SUMMARY = "Free Remote Desktop Protocol library (server library)"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "freerdp3"
HOMEPAGE = "https://www.freerdp.com/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/f/freerdp3/libfreerdp-server3-3_3.15.0+dfsg-2.1+deb13u3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/f/freerdp3/libfreerdp-server3-3_3.15.0+dfsg-2.1+deb13u3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "f391e954174142a50dc4c85ca13739ae"
SRC_URI[deb0.sha1sum] = "f08f9c9ea6e41035d92cd0c952d5496f0d9ab04b"
SRC_URI[deb0.sha256sum] = "8a13d5483af10050b7f4f704ed5f40e4a43cd8722023c0bc359f8fc6731b23de"
SRC_URI[deb0.sha512sum] = "3bf09c06f0aabe1225cee88d0f176a0633556f1de6744e2007479c91c217e29fb134f1b96c9caa1c1de3cb76ed6e0d4649e9f08dfcac8e49a884690aea4912bb"
SRC_URI[deb1.md5sum] = "1991e9a363e692448db413bf9fc26f8b"
SRC_URI[deb1.sha1sum] = "596d3bbff8db0eff98392d81c4ecc7e3e402ad9e"
SRC_URI[deb1.sha256sum] = "fc122a69c6c1c91cb2b75f7d6db427bb467ac74c86ea364b3130274dc48a3d71"
SRC_URI[deb1.sha512sum] = "390424b51500ef21d9967bb75a698e1cb92b9b15d9bcf38e5f99a99db9ffb6dc91afbb41dca62f801f4bb60bbe9ae34ba0664ae415e7d0dc9cc89e34fd4d4b54"

RDEPENDS = " \
    libc6 \
    libfreerdp3-3 \
    libwinpr3-3 \
    libwinpr3-partial-api-3-17 \
"

