# This was autogenerated! Do not modify
SUMMARY = "Windows Portable Runtime library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "freerdp3"
HOMEPAGE = "https://www.freerdp.com/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/f/freerdp3/libwinpr3-3_3.15.0+dfsg-2.1+deb13u3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/f/freerdp3/libwinpr3-3_3.15.0+dfsg-2.1+deb13u3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "d7222ad4ff215cd7f4005336bbdd3d3a"
SRC_URI[deb0.sha1sum] = "88260db78896ca72e13dcec25e9b37e4d7e021c2"
SRC_URI[deb0.sha256sum] = "21d58d1d06452001c049d56804cb005e02c09b73b76a2f4a533d7745928c5957"
SRC_URI[deb0.sha512sum] = "9e7fce1f23786b7049db31ba446fbba45a2e3af795fe7cd095918cac30bed78fd75b3c6702f5955b37217b4cb9c226da9d378f5c4433340a2c71476e19adac24"
SRC_URI[deb1.md5sum] = "85f4fd154bc41383440e1ba4857a3186"
SRC_URI[deb1.sha1sum] = "83d982a0012c3b0a0bebd7af23e8b2710a559b0d"
SRC_URI[deb1.sha256sum] = "c97d4bf5d4aaf7474424688b9a2192b87b9a45f7d8f47595719b540659765f64"
SRC_URI[deb1.sha512sum] = "dc0fff36a99ee60027a1c961f9f1e13ffe3d5b78f3f2873c8d5dcce36602b5d090f2e3797bb2803573f5de9a2299ab22f8657e4362ffe9360ee56c98bb64df9d"

RDEPENDS = " \
    libc6 \
    libgcc-s1 \
    libicu76 \
    libjson-c5 \
    libk5crypto3 \
    libkrb5-3 \
    libssl3t64 \
    liburiparser1 \
"

RPROVIDES = " \
    libwinpr3-partial-api-3-17 \
"
