# This was autogenerated! Do not modify
SUMMARY = "library to read temperature/voltage/fan sensors"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "lm-sensors"
HOMEPAGE = "https://github.com/hramrach/lm-sensors"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/l/lm-sensors/libsensors5_3.6.2-2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/l/lm-sensors/libsensors5_3.6.2-2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "641055c30e7159c6504b7b945d7c01e7"
SRC_URI[deb0.sha1sum] = "06a8cfb169c0875099467e370bb40206ddce55e3"
SRC_URI[deb0.sha256sum] = "f0a994a6d7cfa695dea5343d0d1ba7eed796c0ad920c7282998b95f60049c4f6"
SRC_URI[deb0.sha512sum] = "aa6c2cf3cc50051004f9dd75db92f327ae6301b0b26af8d17d53fe898526631abe0420188d69aa8cac4f7bbd80a15bb83b3c2a18bc8fa5b50f0f5b6b9e464985"
SRC_URI[deb1.md5sum] = "555d2f6e9dd9240483bd7af12ea3ab9b"
SRC_URI[deb1.sha1sum] = "ee5c6983562bb8a2fb1b90dc8bd0ec15e3460dc2"
SRC_URI[deb1.sha256sum] = "7469f1ccce8afdba33d3b11847d0ecdf2221805a0694dee21ee4d622e8f72145"
SRC_URI[deb1.sha512sum] = "216429199f5a2388a2d5a197ec2126cdb1a00daa898dfce27728dec8b81aa1c3c52566c923af1bab5dec7796e1f1c13a7da4079b005ee3f3ea2797195ebfc644"

RDEPENDS = " \
    libc6 \
    libsensors-config \
"

