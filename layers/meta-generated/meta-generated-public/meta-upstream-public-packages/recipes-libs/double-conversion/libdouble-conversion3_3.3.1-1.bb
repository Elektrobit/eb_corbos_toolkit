# This was autogenerated! Do not modify
SUMMARY = "routines to convert IEEE floats to and from strings"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "double-conversion"
HOMEPAGE = "https://github.com/google/double-conversion"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/d/double-conversion/libdouble-conversion3_3.3.1-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/d/double-conversion/libdouble-conversion3_3.3.1-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "808d59f29468ecdfc8a6804b3c94cb11"
SRC_URI[deb0.sha1sum] = "18a6e4f395a4e864f6731a9a4d154f14ca0105fb"
SRC_URI[deb0.sha256sum] = "bd43b8c185a78d108548b30da6a695aabb6644ce0dd266892da2d10cfe471067"
SRC_URI[deb0.sha512sum] = "ac09cce6933b2fe4496f97f403476325ca76c0fa3efa5240b68fc38df654fddda4591b38da65488eafe5a716f0c36bdf3078a71fbf8e38a2bd67d58dd7382630"
SRC_URI[deb1.md5sum] = "3dfbb56d0cf00ef1edb3405c52fcee05"
SRC_URI[deb1.sha1sum] = "5b952f3f3511ae3d0024e4df1d767b6ca201e9cc"
SRC_URI[deb1.sha256sum] = "ea827a47ddffeaa8e95dc8d0c3b8aa9c79b33b2be77109450c2b06a2b89644d8"
SRC_URI[deb1.sha512sum] = "e37ffd373e6b8fc73b32e21e993f6529f6319ef406a84ac72baa0c0ba6c13929a7620bc0bb247dfe6806f39d673f50accf7579fe1661fb3b4e70306e3dda8cdb"

RDEPENDS = " \
    libc6 \
    libgcc-s1 \
    libstdc++6 \
"

