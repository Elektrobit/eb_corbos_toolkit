# This was autogenerated! Do not modify
SUMMARY = "Linux kernel AIO access library - shared library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libaio"
HOMEPAGE = "https://pagure.io/libaio"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/liba/libaio/libaio1t64_0.3.113-8+b1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/liba/libaio/libaio1t64_0.3.113-8+b1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "553dc1c2ae5c86bdd4454fee9693543b"
SRC_URI[deb0.sha1sum] = "6f53647f1517d5a8a88f8bc709a6b5cd16dfb6c0"
SRC_URI[deb0.sha256sum] = "490c8a2d116001a5f3b0a6d7a7aabf6a7b629366590dc5c3f75b078e931dd129"
SRC_URI[deb0.sha512sum] = "d45546c6d8ce1bd09d548ff2882e6e3feba226144844bd9fcd649c40ba0b7cdd742f63e34a2d717bfa2b5cabedb549826de36e95b71285049c6b51dfd3ae7688"
SRC_URI[deb1.md5sum] = "e471238eccacecb21c63d9548e8a8a62"
SRC_URI[deb1.sha1sum] = "3d172fedd15faff3ce9f6858b446923dc85e7f27"
SRC_URI[deb1.sha256sum] = "733b961bd2b6f1b644f14681ee57ce353e2854e21e49e445e3ae250e585c7301"
SRC_URI[deb1.sha512sum] = "c150d9b7a5c05a81828746f7f96c2d15dfd4d38d48ca6e32c4b84e65e503547f7115d38610c12903fc1a117cf69248839e22176f312e37d7497d36da3cb72f01"

RDEPENDS = " \
    libc6 \
"

