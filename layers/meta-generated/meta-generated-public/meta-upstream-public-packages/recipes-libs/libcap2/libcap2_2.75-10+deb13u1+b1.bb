# This was autogenerated! Do not modify
SUMMARY = "POSIX 1003.1e capabilities (library)"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libcap2"
HOMEPAGE = "https://sites.google.com/site/fullycapable/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libc/libcap2/libcap2_2.75-10+deb13u1+b1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libc/libcap2/libcap2_2.75-10+deb13u1+b1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "7a626ed1a2e81b5854c1c1a979dfdb86"
SRC_URI[deb0.sha1sum] = "77160c41dc0382574d5b0ff69ceeacabf85a6191"
SRC_URI[deb0.sha256sum] = "860db6f80d400239744eee2b454f1d8e66b064e18dd0527535824887691e9cb7"
SRC_URI[deb0.sha512sum] = "8e187abdf4d3411033044fd0d7aae0f380c1af7e0e64e25f92078e80cda6722b5b27e25f494935a28da6c7b68a41c7f7805a2e194ec8b0b1f2e36aea5efbe188"
SRC_URI[deb1.md5sum] = "50309905f8b68c2a78bb54640b600313"
SRC_URI[deb1.sha1sum] = "3b476868803473418506dd2078a48bcd258a57b9"
SRC_URI[deb1.sha256sum] = "c9a77aa670c9ca163c624a00e55c4419df40b770fe516010dc495c04a16c80b0"
SRC_URI[deb1.sha512sum] = "7efb54de58b82cb0d9ed6b668b6f54fdc9367bad3ea0b1df4b29d3f1ed1b7bf94f11600cfe3fc8fee51cde5fb262e3e7b8380ed030eab3680ff4e74f6a9f6fef"

RDEPENDS = " \
    libc6 \
"

