# This was autogenerated! Do not modify
SUMMARY = "OpenType text shaping engine (shared library)"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "harfbuzz"
HOMEPAGE = "https://harfbuzz.github.io/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/h/harfbuzz/libharfbuzz0b_10.2.0-1+deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/h/harfbuzz/libharfbuzz0b_10.2.0-1+deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "322bb1f99d1f8c25a0a5e1092d10ad85"
SRC_URI[deb0.sha1sum] = "6c3e44c73e446966c6ef55f6bb3fb6fe34632cd3"
SRC_URI[deb0.sha256sum] = "932165b933e5eb633293afe984a983ebe89cb27c923ce7208626f1da6c0c7941"
SRC_URI[deb0.sha512sum] = "6a2b7a69c28dbe9f8c42ed215f35c74c1378edd2431955e71f4c48b3968e5ef0ac9addd7f968c8c39ad49d6b95a760edcd2fa449f1067741e14c368f57f595e9"
SRC_URI[deb1.md5sum] = "7398220187b4459a34f2e894c0e75fa6"
SRC_URI[deb1.sha1sum] = "ff64e910d0a569088c9b8f817c9772f216923e77"
SRC_URI[deb1.sha256sum] = "3ff928f981b54b491ee12e4cf68558cc5d61c652bdab276cd4c4c3fbbcee16ca"
SRC_URI[deb1.sha512sum] = "9aec8c552790728d085cfe33dd46d544fa95a0f46f4f336e8a78fc31f84ef6cb75e6cb7fc327f217e152e2999d70fc63531fe1f9701642553e2325aebf1d4274"

RDEPENDS = " \
    libc6 \
    libfreetype6 \
    libglib2.0-0t64 \
    libgraphite2-3 \
"

