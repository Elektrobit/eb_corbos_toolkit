# This was autogenerated! Do not modify
SUMMARY = "Speech recognition tool - shared library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "sphinxbase"
HOMEPAGE = "https://cmusphinx.sourceforge.net/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/sphinxbase/libsphinxbase3t64_0.8+5prealpha+1-21+b1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/sphinxbase/libsphinxbase3t64_0.8+5prealpha+1-21+b1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "da4483a397f2f041b32b408c8dcd80ab"
SRC_URI[deb0.sha1sum] = "0115376265336976f62caad93a23f1b34cd9fdf0"
SRC_URI[deb0.sha256sum] = "97edf4f50ed24364795e53abecd6e100d1f24278968b2eb01a688c78255eb80b"
SRC_URI[deb0.sha512sum] = "af2dcde2640953bb9cd9407234bf481c0770623543c1f1c945d403f5acf198f4772051de00506cd3921add9d1cecd9e95dd57c563436698570f17ba30657a546"
SRC_URI[deb1.md5sum] = "3aee321d13f5152ddb70e184089b7421"
SRC_URI[deb1.sha1sum] = "022c7af6b43d40677d28b84985f7b5e56fb783b2"
SRC_URI[deb1.sha256sum] = "408f2ac2ad4550e646b29741580ff5398e0b717d5b59a4d5d96116a07e6f7b18"
SRC_URI[deb1.sha512sum] = "0c926af0f7bef2ba6fe9573be7d60e3c5ad1d0e505d75608db8942358f7f1e6f05e59fe0e6433e0b7e1f145ef59827bc151933bb885a76912e88a24e453c3aa2"

RDEPENDS = " \
    libblas3 \
    libc6 \
    liblapack3 \
    libpulse0 \
"

RPROVIDES = " \
    libsphinxbase3 \
"
