# This was autogenerated! Do not modify
SUMMARY = "library for storing RDF data in memory"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "sord"
HOMEPAGE = "https://drobilla.net/software/sord.html"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/sord/libsord-0-0_0.16.18-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/sord/libsord-0-0_0.16.18-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "ef87d4e8a083cc367c737bb3d6099781"
SRC_URI[deb0.sha1sum] = "cbc85b825f16ca916f8d96e034116a9c799d1442"
SRC_URI[deb0.sha256sum] = "cbb4167b1a85cfec94faa9f85666ee382a8bc79ce93f5d7457514e8334299e52"
SRC_URI[deb0.sha512sum] = "c1c2cda79bfb5c4a9bc845c34470b74aa472a167cac95bf094b51748d900d3dd1f91eb8caab979d699b894a392d7f0fa0e28e578ae6742c72aef0b1356e580ed"
SRC_URI[deb1.md5sum] = "30483bd2dc7b66bc8736e9dc2794660d"
SRC_URI[deb1.sha1sum] = "18d457244f66899bdeb04e8868dd29a57e378761"
SRC_URI[deb1.sha256sum] = "d2a648495869e680c7ecd107dad0c716590fec427817db703f3bebf719b37f59"
SRC_URI[deb1.sha512sum] = "5348568225fee7ff91bacdcff327bf5f177a0a8f432c4d97b4e4e828dd361a1763c0237fc706d81e3b307158e218e6cc9a1421522e9e6e6d4ba6456c19447ff0"

RDEPENDS = " \
    libc6 \
    libserd-0-0 \
    libzix-0-0 \
"

