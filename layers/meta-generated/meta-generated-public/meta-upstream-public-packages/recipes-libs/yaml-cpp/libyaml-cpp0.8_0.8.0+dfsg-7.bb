# This was autogenerated! Do not modify
SUMMARY = "YAML parser and emitter for C++"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "yaml-cpp"
HOMEPAGE = "https://github.com/jbeder/yaml-cpp"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/y/yaml-cpp/libyaml-cpp0.8_0.8.0+dfsg-7_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/y/yaml-cpp/libyaml-cpp0.8_0.8.0+dfsg-7_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "5735eb3d1e54ef592a67443114c3783a"
SRC_URI[deb0.sha1sum] = "16e49132713b586cad40d6192b88d7aac0af8522"
SRC_URI[deb0.sha256sum] = "120ef7f4d076f3307d374133154e34106817be874323e8bc2814130d3dccbb8a"
SRC_URI[deb0.sha512sum] = "4349f5393313dcd34a28adc92f9a48c1efb7f54f523d1dcba64c402a14c21988343235afe001f490474e14dd3663dd8fb5c2c22fb5c83fa236363a8c8db92225"
SRC_URI[deb1.md5sum] = "32f9dcc21eccfd032d63d83adfdfd6c5"
SRC_URI[deb1.sha1sum] = "cc9b28346af1600766d9b52cc84d38828a6c85d0"
SRC_URI[deb1.sha256sum] = "a20127bae21c819ad03ac364740b6354992143702dc4735cf77910b9df847348"
SRC_URI[deb1.sha512sum] = "7f5af6c893176aaf1e4a0f06180fd7b7d35853fc60d32546a3bcbc7ac44de5af9f6823910f9f4cbc007e7920a03c7cd7db7fd1a8853aeaee73acfdfba2c57a9a"

RDEPENDS = " \
    libc6 \
    libgcc-s1 \
    libstdc++6 \
"

