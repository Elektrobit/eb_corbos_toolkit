# This was autogenerated! Do not modify
SUMMARY = "Library to program the performance monitoring events"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libpfm4"
HOMEPAGE = "https://perfmon2.sourceforge.net/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libp/libpfm4/libpfm4_4.13.0+git99-gc5587f9-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libp/libpfm4/libpfm4_4.13.0+git99-gc5587f9-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "ba496559efcfb361dc4262052a5d8693"
SRC_URI[deb0.sha1sum] = "5d00ae7cee610aa41f44a0031a50c2f692b3d00b"
SRC_URI[deb0.sha256sum] = "55f0d470f5bdd63061593180c5b34bcb9cefdb09b4cfc9c67b3cb170b0162525"
SRC_URI[deb0.sha512sum] = "5e5c3c7be3ad44a470f2950c6ab35ef1b23bd950eb86585930b5a8c116eeb2e8265e98da390c5f0506204acc0284556b3e986552d56b6ccb3d2819af673e2994"
SRC_URI[deb1.md5sum] = "98caa8ac7cdb438d3d1c1df2091ddfd7"
SRC_URI[deb1.sha1sum] = "a03e06925bb95a390066edfc9f666e1f34481d6c"
SRC_URI[deb1.sha256sum] = "5041567ffd6bdb2f46756ee4249d0d21576ac95b059429dc1250a8d24b614e6d"
SRC_URI[deb1.sha512sum] = "f9faa586d8e8ea81c945865509459d305f8ffaf74062689ebc495c399317de98258a87f0df98c3b828828aa3a845260d0f6df8b864373bdc8f58cc6c7735f171"

RDEPENDS = " \
    libc6 \
"

