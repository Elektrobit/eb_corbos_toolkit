# This was autogenerated! Do not modify
SUMMARY = "changehat AppArmor library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "apparmor"
HOMEPAGE = "https://apparmor.net/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/a/apparmor/libapparmor1_4.1.0-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/a/apparmor/libapparmor1_4.1.0-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "46a61489f86360de91fe23bb4c0be4df"
SRC_URI[deb0.sha1sum] = "1b97eac07c01f27647376cf8adbce30a0879b7da"
SRC_URI[deb0.sha256sum] = "4158976c77038b93021967f425b4cc505df18c4f5e3f444732399e7ed4af4419"
SRC_URI[deb0.sha512sum] = "ab97751e3691a8f03337cc12007bc8273eb3211e8033650a8596f3be211dece0fdf05cce7b29e156db616816c5e85483c2b6980cc64f5fa10255e5fe30138442"
SRC_URI[deb1.md5sum] = "143363ee2ffe7ce78c2183a286f7ea50"
SRC_URI[deb1.sha1sum] = "9f1cb183118887449d34766f510ccf9548c3b2bf"
SRC_URI[deb1.sha256sum] = "6e5ec85de21bd5f489327e6d2c85c2825e82ff6f4581dc936704d022a1f164af"
SRC_URI[deb1.sha512sum] = "674e6e07a09b7fb881f27cafa8199b6cd0b060f7f4915a4a7b6aae8c16ef91de8f7f5148c19795ce262863820fcd222c486c09b65482b0624f4fb7864f334316"

RDEPENDS = " \
    libc6 \
"

