# This was autogenerated! Do not modify
SUMMARY = "TPM2 Software stack library - TSS and TCTI libraries"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "tpm2-tss"
HOMEPAGE = "https://github.com/tpm2-software/tpm2-tss"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/t/tpm2-tss/libtss2-tcti-device0t64_4.1.3-1.2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/t/tpm2-tss/libtss2-tcti-device0t64_4.1.3-1.2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "088a3be8e03d854e8d5f5c09c61bd267"
SRC_URI[deb0.sha1sum] = "9130ff0b2b22f87328443d9ef9df22059e1f9d1f"
SRC_URI[deb0.sha256sum] = "e2c07f7258f52b611edb96945049dfc5dd0f066b9464cd2338716d73f78fc495"
SRC_URI[deb0.sha512sum] = "b78d0715f8ff78812421715d74df12e7fae9cda09d0e85b50203324527e45b4acbfff0815d990353e94e135e347215b975e64abd380436d1d0960b28e4747036"
SRC_URI[deb1.md5sum] = "7b656ebd85ac07d751ae8e95c0970b04"
SRC_URI[deb1.sha1sum] = "6d33ca4f733d5976183ff55db3bbb2ee7ca7ee7d"
SRC_URI[deb1.sha256sum] = "c48c75de0b1d7ebcd31b63160dcdc7ef87664615860bb141d170676e5d293331"
SRC_URI[deb1.sha512sum] = "0ab11691f719019dac71f8d7229255ace7f986505a28dd91d3123827cdc14c7c3bf9acd3475ffe2f4f279bcffb8a49b22c615e5bbd0a94101cb91cbe785b95b0"

RDEPENDS = " \
    libc6 \
    libtss2-mu-4.0.1-0t64 \
    tpm-udev \
"

RPROVIDES = " \
    libtss2-tcti-device0 \
"
