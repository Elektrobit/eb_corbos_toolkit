# This was autogenerated! Do not modify
SUMMARY = "TPM2 Software stack library - TSS and TCTI libraries"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "tpm2-tss"
HOMEPAGE = "https://github.com/tpm2-software/tpm2-tss"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/t/tpm2-tss/libtss2-tcti-swtpm0t64_4.1.3-1.2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/t/tpm2-tss/libtss2-tcti-swtpm0t64_4.1.3-1.2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "dc96721508746ccbad0ff24c2be8bc09"
SRC_URI[deb0.sha1sum] = "0f1499831a6c3da8ece4fc24a1140162963d9cfe"
SRC_URI[deb0.sha256sum] = "b0727b044be2280449fd86aabadea75dd85044632a2e44deaa3534ca59a394e3"
SRC_URI[deb0.sha512sum] = "d47f43c5d393098ef048f47c9fe51e3deb71e746873865c8a4ba717d67668b4ba89c696f5ea2366152d8d56b05933ddcb9d70e89413489042ab5c038f6a5faa9"
SRC_URI[deb1.md5sum] = "665e1889ce115d873b73493aab77a731"
SRC_URI[deb1.sha1sum] = "f1207060f9cdce88d6bbaccfaad0a9ccbe669dae"
SRC_URI[deb1.sha256sum] = "16d7ab88c51a000fc9ea84c6a578cb67389bfbc24bc18ef32f821eaaf8b97bfd"
SRC_URI[deb1.sha512sum] = "25757ceda1104453b352bfb12f564a3595854ae61ccc4c8195bf3039038affc8db8a4827312d6a9fa2a3fda521d911b5b40b793d754f70455e0061a7acd432f0"

RDEPENDS = " \
    libc6 \
    libtss2-mu-4.0.1-0t64 \
    tpm-udev \
"

RPROVIDES = " \
    libtss2-tcti-swtpm0 \
"
