# This was autogenerated! Do not modify
SUMMARY = "TPM2 Software stack library - TSS and TCTI libraries"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "tpm2-tss"
HOMEPAGE = "https://github.com/tpm2-software/tpm2-tss"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/t/tpm2-tss/libtss2-esys-3.0.2-0t64_4.1.3-1.2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/t/tpm2-tss/libtss2-esys-3.0.2-0t64_4.1.3-1.2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "17b7d3400e66c6ee660606a78e4c7662"
SRC_URI[deb0.sha1sum] = "3e7c6d411bc88328d51cce0d0273eeb851d196ce"
SRC_URI[deb0.sha256sum] = "87c0747c54e12be29c149145830385f5c6816b0fd962391858d63d70c921859e"
SRC_URI[deb0.sha512sum] = "e9ef04750ce49eff5da0eb5c453e690099d851ec83e53b1453b4d166715d99719511ba919ea923f43b4ba90d2a8a7b1c3c3d29ca757ea72036306d1c53dd28c5"
SRC_URI[deb1.md5sum] = "42fdaf45b3017e12ac09955f7e4f66bf"
SRC_URI[deb1.sha1sum] = "c358c5e1d615dff85a28b02fb5f20ba82ec74088"
SRC_URI[deb1.sha256sum] = "80d442295d7ac09b5550a947e9f040fe242cf41489147c4d02487b516e1d2de8"
SRC_URI[deb1.sha512sum] = "b49d5481ad6b7e20e9f689dee5aa15bc670d626efce9df42db13750bb8976e509c99ac0d5662c5c85444a650f8efaf61228784550959ba958f849c41fb996f29"

RDEPENDS = " \
    libc6 \
    libssl3t64 \
    libtss2-mu-4.0.1-0t64 \
    libtss2-sys1t64 \
    libtss2-tcti-cmd0t64 \
    libtss2-tcti-device0t64 \
    libtss2-tcti-mssim0t64 \
    libtss2-tcti-swtpm0t64 \
    tpm-udev \
"

RPROVIDES = " \
    libtss2-esys-3.0.2-0 \
"
