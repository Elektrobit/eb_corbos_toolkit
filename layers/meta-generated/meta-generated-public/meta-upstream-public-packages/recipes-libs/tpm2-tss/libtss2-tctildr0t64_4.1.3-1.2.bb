# This was autogenerated! Do not modify
SUMMARY = "TPM2 Software stack library - TSS and TCTI libraries"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "tpm2-tss"
HOMEPAGE = "https://github.com/tpm2-software/tpm2-tss"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/t/tpm2-tss/libtss2-tctildr0t64_4.1.3-1.2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/t/tpm2-tss/libtss2-tctildr0t64_4.1.3-1.2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "db6da105f4a075526dc790d45a53d002"
SRC_URI[deb0.sha1sum] = "94947a5658fae83653368fab268d88e2ce8bf995"
SRC_URI[deb0.sha256sum] = "90a301083c38ae92c16fab7d5bfc2d1f3874a09a33f500d289308bdbb12e135d"
SRC_URI[deb0.sha512sum] = "11d56f454cde325c6df23616a3ef7c8c0ea933e6dbffcbf27630c7bc5159276de6832ec810366a126d61bb97111910718a7ad31f9c863ce8f4a1ebf4d9d2c73d"
SRC_URI[deb1.md5sum] = "2e14363da2543e39778a88ca583e0da5"
SRC_URI[deb1.sha1sum] = "5581fc17ae11588c7d910c8cb042c31d74d45865"
SRC_URI[deb1.sha256sum] = "0672d6c462839a5f92cf8e78e5499552b614cc82ef76d1e2f407e2cdf7cba2ae"
SRC_URI[deb1.sha512sum] = "9fdc3ef193cf0fbe48e09b5a9c7795f0754c4cbb09bd4bbfcbd923f79822e92c2c3739ca3ef2867c472c773969cf51d4a9a7b01deebaf8623725c500928d945a"

RDEPENDS = " \
    libc6 \
    libtss2-tcti-cmd0t64 \
    libtss2-tcti-device0t64 \
    libtss2-tcti-libtpms0t64 \
    libtss2-tcti-mssim0t64 \
    libtss2-tcti-spi-helper0t64 \
    libtss2-tcti-swtpm0t64 \
    tpm-udev \
"

RPROVIDES = " \
    libtss2-tctildr0 \
"
