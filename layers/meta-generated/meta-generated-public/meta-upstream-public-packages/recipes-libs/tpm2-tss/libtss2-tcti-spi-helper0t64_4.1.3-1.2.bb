# This was autogenerated! Do not modify
SUMMARY = "TPM2 Software stack library - TSS and TCTI libraries"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "tpm2-tss"
HOMEPAGE = "https://github.com/tpm2-software/tpm2-tss"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/t/tpm2-tss/libtss2-tcti-spi-helper0t64_4.1.3-1.2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/t/tpm2-tss/libtss2-tcti-spi-helper0t64_4.1.3-1.2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "d2f60a5de6280c2f245274a82a23fd08"
SRC_URI[deb0.sha1sum] = "38538d9ce842df314996328c62fb9ae48bd01051"
SRC_URI[deb0.sha256sum] = "d558847e9299d75378056c438a7315409bccfb26229d54a2dfb0994dbaa39298"
SRC_URI[deb0.sha512sum] = "a53dc509c9e195f4ef62998d1695eb40b3e214a98cb786a50556ea90eb4c6e5ab5390f368ecd2760f37bb1aa882c69d96bc78e901ace022d3244ce4c7dcbf398"
SRC_URI[deb1.md5sum] = "e1dc3c252d2f6570b53031b9e7cf7f1d"
SRC_URI[deb1.sha1sum] = "14ba7d7dc9cee6c42fd892165cdb328a2f06f024"
SRC_URI[deb1.sha256sum] = "a243c2d5e8e544bd0e6c6fc5a9d934370bccba84ad8bf2dbd1252170d0f95092"
SRC_URI[deb1.sha512sum] = "3da63837027361d4adea19272eba4c6cd54c5c9c10f4d301cf487ad189113db0153288271a0b00e83f9d453b1314747f030635f6742e098e10d23b7b87bd6963"

RDEPENDS = " \
    libc6 \
    libtss2-mu-4.0.1-0t64 \
"

RPROVIDES = " \
    libtss2-tcti-spi-helper0 \
"
