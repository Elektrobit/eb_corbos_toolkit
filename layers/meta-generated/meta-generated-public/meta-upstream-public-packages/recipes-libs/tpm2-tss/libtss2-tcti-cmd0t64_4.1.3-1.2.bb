# This was autogenerated! Do not modify
SUMMARY = "TPM2 Software stack library - TSS and TCTI libraries"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "tpm2-tss"
HOMEPAGE = "https://github.com/tpm2-software/tpm2-tss"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/t/tpm2-tss/libtss2-tcti-cmd0t64_4.1.3-1.2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/t/tpm2-tss/libtss2-tcti-cmd0t64_4.1.3-1.2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "71caff2466954a81fad76167d605c8d5"
SRC_URI[deb0.sha1sum] = "e1201768949faad733cce96f09c6d24f5440d37f"
SRC_URI[deb0.sha256sum] = "8249c54706df9ae1a94140126a2b69b2a2f6795ae84abe55795e485f24f7915e"
SRC_URI[deb0.sha512sum] = "63de705b79a4746ca8f2d08c32b8c72e96baecc329da22e3a2d40fbd0de9706b78bd3a9ac53c8a9fa5eeb8f4dec38c90037a9a05991dc7e189ae2e0d774ec86a"
SRC_URI[deb1.md5sum] = "619e5353b7ff0589f97279fe703f1921"
SRC_URI[deb1.sha1sum] = "99e3c02040d0dc247f83de628250f4659c4d8389"
SRC_URI[deb1.sha256sum] = "390c36ba954242dffa52f28438fe11311ab1ad5957b40fb498dcccd5659947d3"
SRC_URI[deb1.sha512sum] = "0ef08bc318c04493ec48f40335548b5e5f6e251a5ad13d570df8f9e1b88710f2f2c84dc057a77e74b29dfbb522cd91f8b49a88eda127ac0d92b9c163e2edcdd0"

RDEPENDS = " \
    libc6 \
    libtss2-mu-4.0.1-0t64 \
    tpm-udev \
"

RPROVIDES = " \
    libtss2-tcti-cmd0 \
"
