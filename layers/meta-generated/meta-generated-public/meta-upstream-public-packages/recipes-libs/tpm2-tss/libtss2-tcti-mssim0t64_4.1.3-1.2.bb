# This was autogenerated! Do not modify
SUMMARY = "TPM2 Software stack library - TSS and TCTI libraries"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "tpm2-tss"
HOMEPAGE = "https://github.com/tpm2-software/tpm2-tss"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/t/tpm2-tss/libtss2-tcti-mssim0t64_4.1.3-1.2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/t/tpm2-tss/libtss2-tcti-mssim0t64_4.1.3-1.2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "f0760f2fc95b34c9d022c595e19544c6"
SRC_URI[deb0.sha1sum] = "45e8c1dc842610bee9a3e11255515b3e0902b0d7"
SRC_URI[deb0.sha256sum] = "c188d0b78feb285be5e6d4acc741642026b5ec4f3ca6ad4070fdf4fbe142fd6c"
SRC_URI[deb0.sha512sum] = "f0969880fafe60d70da9815905dda2d56c0002b43e57013d4e57be803232e7dff186ad14c3a465d0c5085d646be189a258450dd6d8556348f0c02eb3c59252ca"
SRC_URI[deb1.md5sum] = "8862bac15c0d3aa93b48c2873ac39e9f"
SRC_URI[deb1.sha1sum] = "562015d1ac08f78ce3f3a8130757da27c4d1824f"
SRC_URI[deb1.sha256sum] = "66a08e9e34b8dd07aee7feaaa66113d71811fb3e5abb3cccbe6ec5fd0d520b62"
SRC_URI[deb1.sha512sum] = "36c5bb16377d0a63cac323caf0c5eb1dd6d63e4e0db43fc210df027cdfe753df619dd8cc6e6ca80910e0035db08611bb22ef9207d82d756872a1ef915bdc392c"

RDEPENDS = " \
    libc6 \
    libtss2-mu-4.0.1-0t64 \
    tpm-udev \
"

RPROVIDES = " \
    libtss2-tcti-mssim0 \
"
