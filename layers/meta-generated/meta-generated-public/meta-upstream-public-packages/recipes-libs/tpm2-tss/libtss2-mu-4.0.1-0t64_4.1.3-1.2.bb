# This was autogenerated! Do not modify
SUMMARY = "TPM2 Software stack library - TSS and TCTI libraries"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "tpm2-tss"
HOMEPAGE = "https://github.com/tpm2-software/tpm2-tss"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/t/tpm2-tss/libtss2-mu-4.0.1-0t64_4.1.3-1.2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/t/tpm2-tss/libtss2-mu-4.0.1-0t64_4.1.3-1.2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "540b9e4971a3046fa9e888838cab960d"
SRC_URI[deb0.sha1sum] = "d01ac96889787f3f06b753f94ce82d1ad3487580"
SRC_URI[deb0.sha256sum] = "b7e1b9a05623f304aa82b4a577f8948e967f9212e5871c76bd88dd8e96b3e4ea"
SRC_URI[deb0.sha512sum] = "6224eeb0f2265d280b81e01a7a0943b5cd8f07a1bdd167d952f054208a7ee134d269d1ee5ac4ecb6efcedf7f1891baed995da009d5c6ebecb81e8534954552c3"
SRC_URI[deb1.md5sum] = "4240678333543b97d693f3f90f12b289"
SRC_URI[deb1.sha1sum] = "917d22f27fdd2f45efadd03a933a7e05d282f8fa"
SRC_URI[deb1.sha256sum] = "698134f2dd54a966f22e6b6ca56e98bdd32d05b8d667c916c8d04c50918e6644"
SRC_URI[deb1.sha512sum] = "86154d72e57890fef690c48f5889f6725fafb7d8caad08a744e6b12351ff4b04d0c627607b060b6a4fe78165c65b4e4e4f6aa83b0d56ca3776797f3000fc3702"

RDEPENDS = " \
    libc6 \
    tpm-udev \
"

RPROVIDES = " \
    libtss2-mu-4.0.1-0 \
"
