# This was autogenerated! Do not modify
SUMMARY = "Intel Processor Trace Decoder Library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "intel-processor-trace"
HOMEPAGE = "https://github.com/intel/libipt"

inherit dpkg-prebuilt

DPKG_ARCH = "amd64"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/i/intel-processor-trace/libipt2_2.1.2-1_amd64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "59594b6738ba971e18716e3363e6d0dd"
SRC_URI[deb0.sha1sum] = "cc69e754a665a593b6b6ff3460de8c24574eef0c"
SRC_URI[deb0.sha256sum] = "33cfc9090194a993bfab1da4a70a03b4a2d2863894c1d4b506dd4ac093a0073e"
SRC_URI[deb0.sha512sum] = "cb71652d4c1324acc74facaa660dba9f0af0cac26d9924aeec04d1dc6b48bc43309f8675fff03eb05dae6aa9564431dccdfa66265fdd026027cb43b5b845b6cb"

RDEPENDS = " \
    libc6 \
"

