# This was autogenerated! Do not modify
SUMMARY = "Secure Sockets Layer toolkit - shared libraries"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "openssl"
HOMEPAGE = "https://openssl-library.org"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/o/openssl/libssl3t64_3.5.6-1~deb13u2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/o/openssl/libssl3t64_3.5.6-1~deb13u2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "88cfa9ea5cef21ed2c8a5976649d1900"
SRC_URI[deb0.sha1sum] = "fa81f709727b16de2a82710bbe0556b58f2b3f50"
SRC_URI[deb0.sha256sum] = "b2dab3fe29c1fcb82ef58c2db0ff4bd830a442cf37b9a8b730b7b6ce87181349"
SRC_URI[deb0.sha512sum] = "00ac7443e85fea4f49fc70e144b73973d237d7a57d95a689073a2ef5328d94aedf0f349e93861961befa4d5b7e6f6fe5d785b1763b30d32a04699b31a17039e1"
SRC_URI[deb1.md5sum] = "0f47eb2bb5c575033bd86d153b6e91c6"
SRC_URI[deb1.sha1sum] = "6e3fe344496850bb946e702685bacc5df1332dab"
SRC_URI[deb1.sha256sum] = "f7e09a12ccb2d6bd28bcc87a6e2462a0558dcb3cc34d56f90ee86fbd3402d8ba"
SRC_URI[deb1.sha512sum] = "11fe2477cd49f1e13dc0e3de1bdd8950208a9f5fee97aabd86369bb64799be91f2c90c9ba6f373dc375ffc775a3da2c8c69b12ceb49b0497a5d23118621530c3"

RDEPENDS = " \
    libc6 \
    libzstd1 \
    openssl-provider-legacy \
    zlib1g \
"

RPROVIDES = " \
    libssl3 \
"
