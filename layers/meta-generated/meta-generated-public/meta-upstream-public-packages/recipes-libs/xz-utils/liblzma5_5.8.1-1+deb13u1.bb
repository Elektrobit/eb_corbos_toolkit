# This was autogenerated! Do not modify
SUMMARY = "XZ-format compression library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "xz-utils"
HOMEPAGE = "https://tukaani.org/xz/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/x/xz-utils/liblzma5_5.8.1-1+deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/x/xz-utils/liblzma5_5.8.1-1+deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "9060e24182fb79f353c1e2175da7fe94"
SRC_URI[deb0.sha1sum] = "5d0e0ef32b670ea1783583ea18c75eb1b4f71071"
SRC_URI[deb0.sha256sum] = "1cfcc6e0dc36f438a79b6e2189facdb9d150b08f57d190a60e01c98075c7f896"
SRC_URI[deb0.sha512sum] = "19b38351b05afc01ba80a4e6471f97129846e85adf2b3eee8463f362336eb1ffd33aeb7acb0cce91194d67ff3583c309451eccc41e1ea5dad971097e88b4f7c9"
SRC_URI[deb1.md5sum] = "442ae1a890e7c5eb5d63a82bed5bff98"
SRC_URI[deb1.sha1sum] = "4398f62fa153a6db623b0ce60b0c6bb3b8179dde"
SRC_URI[deb1.sha256sum] = "6a7b98005f84fc26d66a45e432f70d0793646a734f8c44cd1626b3ffa8edd7c6"
SRC_URI[deb1.sha512sum] = "4bb29bd19a77768187e8907509da8e22761879b977cb41388e06912e2d2739e280432031e633b5e91e7723ada580fbdd13fd83a15c874fa5b21cbb899b194d53"

RDEPENDS = " \
    libc6 \
"

