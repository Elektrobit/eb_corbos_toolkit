# This was autogenerated! Do not modify
SUMMARY = "X11 miscellaneous 'fixes' extension library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libxfixes"
HOMEPAGE = ""

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libx/libxfixes/libxfixes3_6.0.0-2+b4_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libx/libxfixes/libxfixes3_6.0.0-2+b4_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "c6365019eca68a1f1da0583e8dd2c916"
SRC_URI[deb0.sha1sum] = "c43f95758e758e6c71a9687c677eccfa13d26cb4"
SRC_URI[deb0.sha256sum] = "3fdd95d86d8e9d63e11f52070935c8f9f912c36aa3b17338d969f7685f3ed4fb"
SRC_URI[deb0.sha512sum] = "b352ba37f0010253e8ae2c5378e569239e30297e7be82075ec3a26812a2d68aeecf691a15e764338a04bc77663e2b370d4a410c564775cf5b785e102fdfe679c"
SRC_URI[deb1.md5sum] = "85b1fa718f4c7f915983e8f87dd94a4c"
SRC_URI[deb1.sha1sum] = "97aa74ecacee2c04895b4a54a58776e050f82190"
SRC_URI[deb1.sha256sum] = "d29134cbb9230a50ba1d097743d4d4fcf7826c6b48a2d8a303a0e3fc20b837e6"
SRC_URI[deb1.sha512sum] = "6e064a57ea74aec932d48d49266672a9c997a6697925f7d1ca9a44017c9ce9594958c6cff4c0a4662d7b83d9200f59c19cbd55acf87c122a9f6d85da3412f98c"

RDEPENDS = " \
    libc6 \
    libx11-6 \
"

