# This was autogenerated! Do not modify
SUMMARY = "GNU readline and history libraries, run-time libraries"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "readline"
HOMEPAGE = "https://tiswww.case.edu/php/chet/readline/rltop.html"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/r/readline/libreadline8t64_8.2-6_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/r/readline/libreadline8t64_8.2-6_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "24c1a54df91ac48e0fb79b953bffe460"
SRC_URI[deb0.sha1sum] = "b094813d4ea39997a3a798b356961ab080b31428"
SRC_URI[deb0.sha256sum] = "eeadf2b5e755c9f183883feea2d9b5b28560284275d5f54d3e55d0923b1d0967"
SRC_URI[deb0.sha512sum] = "fc8746069ac084d215c1e8fafafbbf090ccbf19906b42d4ce45559c5b98de4594db513730c228f6748c11989f275666a5e822c43c1eaa871359f0813accfb17c"
SRC_URI[deb1.md5sum] = "df1d10d47539255b80a222110f6f0bca"
SRC_URI[deb1.sha1sum] = "33bb3cc6d630dca9f10e36849a48162de23ae963"
SRC_URI[deb1.sha256sum] = "f78ff432b2a627bc04f7eef0e6e2696501c9e06feca748a5b741d5e594429033"
SRC_URI[deb1.sha512sum] = "267eeee631cb232216780eaa579d908ae6af75403ecca94d430d08c777f477faaeab8d535ed5c093b8cff5296d2e0436f5b309e2249b2cf1a3d012a8d076a902"

RDEPENDS = " \
    libc6 \
    libtinfo6 \
    readline-common \
"

RPROVIDES = " \
    libreadline8 \
"
