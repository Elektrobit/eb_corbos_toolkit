# This was autogenerated! Do not modify
SUMMARY = "Qt 6 SVG library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "qt6-svg"
HOMEPAGE = "https://www.qt.io/developers/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/q/qt6-svg/libqt6svg6_6.8.2-3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/q/qt6-svg/libqt6svg6_6.8.2-3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "cc5abd5e5386e81ab75d9b17b913a25e"
SRC_URI[deb0.sha1sum] = "51a77674cef80950e9db1671a8b3418bf3f87679"
SRC_URI[deb0.sha256sum] = "4fc94aee5785437477f0aa379e90e1a87eb994da6029eb55f968e34094e389ac"
SRC_URI[deb0.sha512sum] = "ee5ae5fe41526f5b79122e85b7770b1752efcb1e2a29440572390701469e5ca9268f1300a8136c519325e4a84b472ab1fbd5f3dc8584225a5e60edc66b752d8f"
SRC_URI[deb1.md5sum] = "67b8d13a6888fe7f7025446e36ee65c4"
SRC_URI[deb1.sha1sum] = "99ea785e8655a74dc6bbe3e9da01b951c6ba7fce"
SRC_URI[deb1.sha256sum] = "efe251f7947cd6fea1dfce19fad7abd5b1e5a5083f7b414cff10bcf3ffc79f8c"
SRC_URI[deb1.sha512sum] = "2dd42daf0a59acc455b5f9d3680dc8b720a7c5e5da1f6426ebd170a121429fa579eb1ec16350fcefffe78efd8cfb7159ed72c3dd9d75156075c89db55a8ec74c"

RDEPENDS = " \
    libc6 \
    libqt6core6t64 \
    libqt6gui6 \
    libstdc++6 \
    qt6-base-private-abi \
    zlib1g \
"

RPROVIDES = " \
    qt6-svg-private-abi \
"
