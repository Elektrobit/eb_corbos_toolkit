# This was autogenerated! Do not modify
SUMMARY = "FFmpeg library with functions for simplifying programming - runtime files"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "ffmpeg"
HOMEPAGE = "https://ffmpeg.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/f/ffmpeg/libavutil59_7.1.5-0+deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/f/ffmpeg/libavutil59_7.1.5-0+deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "c8df1e2a213fa674bc753203f0e0d6ca"
SRC_URI[deb0.sha1sum] = "83fea47f1318feac023a61e66f67eb1283abdfca"
SRC_URI[deb0.sha256sum] = "bb5fe4ea1eef338c8346bf67cc728dac20b94451ad31db391d03d1f2b3fa37c1"
SRC_URI[deb0.sha512sum] = "bcfe9e685befc9b96f07163e28da3635502bf9b1d9be11d6d976f1a2126aab46202f38a7e820c5a8558da56cc3d66a54f9d5188f1460b07a7ae3fb6cffc78924"
SRC_URI[deb1.md5sum] = "95acbda914b824671a5a562fb216c761"
SRC_URI[deb1.sha1sum] = "690c7ab29a583617c50af58c572335b60867e772"
SRC_URI[deb1.sha256sum] = "74c613a9c4674a251aa1808927f1b3b7dcd07f92b1724974e81ffabda81d0760"
SRC_URI[deb1.sha512sum] = "cd083c4f92fa20e5a31182dbaae6e85bd3b7f8c1b4e7cad5efccb3e1e81e3149ba188ee024e822fdc9a6e8c18711ed2b20a3b24e0eef5d1dd64944b371da2036"

RDEPENDS = " \
    libc6 \
    libdrm2 \
    libva-drm2 \
    libva-x11-2 \
    libva2 \
    libvdpau1 \
    libx11-6 \
    ocl-icd-libopencl1 \
"
RDEPENDS:append:amd64 = " \
    libvpl2 \
"

