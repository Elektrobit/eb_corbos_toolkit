# This was autogenerated! Do not modify
SUMMARY = "FFmpeg library with (de)muxers for multimedia containers - runtime files"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "ffmpeg"
HOMEPAGE = "https://ffmpeg.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/f/ffmpeg/libavformat61_7.1.5-0+deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/f/ffmpeg/libavformat61_7.1.5-0+deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "71d9ecf1a075e40cad159db1f5db2253"
SRC_URI[deb0.sha1sum] = "5fba7bc4e85697e496fe4e0dfcd164cd02d2de4d"
SRC_URI[deb0.sha256sum] = "4b580060cebbd33a25589ba71074e3106caf2826bcdb82cf8936b52960f34fb2"
SRC_URI[deb0.sha512sum] = "c33b81f27a9e95206d724a6f83ccb0cfbb890447bd40b9e773e7e289b25fdc4cceb2852c154babf74e6ee0ab72432f25b82ee82b6c5d287416b3ddc87b4f9bb9"
SRC_URI[deb1.md5sum] = "67545cb8934fd87cfe77d02903299d42"
SRC_URI[deb1.sha1sum] = "bf846e8de0e335b106295296ebb5ac3f4b36110b"
SRC_URI[deb1.sha256sum] = "c14f4cfbb3d377108ff7d28000c3f99feed936dd2348f7a253947ea87ad2cfb6"
SRC_URI[deb1.sha512sum] = "113ac70fb04befa1c3ad75cc5bbb8b7c52363bcb1e101dac337f142d374a799ebdca75cb115ddfb79587be8ee86d135c2ccf9a0ee53cc1c7ac3bc1f804dbb75c"

RDEPENDS = " \
    libavcodec61 \
    libavutil59 \
    libbluray2 \
    libbz2-1.0 \
    libc6 \
    libchromaprint1 \
    libdvdnav4 \
    libdvdread8t64 \
    libgme0 \
    libgnutls30t64 \
    libopenmpt0t64 \
    librabbitmq4 \
    librist4 \
    libsrt1.5-gnutls \
    libssh-4 \
    libxml2 \
    libzmq5 \
    zlib1g \
"

