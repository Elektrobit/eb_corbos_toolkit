# This was autogenerated! Do not modify
SUMMARY = "FFmpeg library for post processing - runtime files"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "ffmpeg"
HOMEPAGE = "https://ffmpeg.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/f/ffmpeg/libpostproc58_7.1.5-0+deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/f/ffmpeg/libpostproc58_7.1.5-0+deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "ec6dd1ab6432abd5d19eeffb363aedff"
SRC_URI[deb0.sha1sum] = "b3e230c0cb0a3403e4d0e49ad82bca4f05d53a77"
SRC_URI[deb0.sha256sum] = "4a19b79dac4353419018509568f554df3ce937d2283c859f6454c3fe543135b6"
SRC_URI[deb0.sha512sum] = "53f3b54e0fd65a2bd7dfd7af2c5203b7c224975ad5f91b0241c010f933df1ac4e5bafac1bd3ae5114bce232356ade76ad00ea3eaaef8c3533572c301aefb9e0b"
SRC_URI[deb1.md5sum] = "ecde5038b3cc3c83cf15e0ac15d26d7c"
SRC_URI[deb1.sha1sum] = "4b6785c1c287e7b60b73c2565e5060ddedb3b58c"
SRC_URI[deb1.sha256sum] = "ea17487d3003cd99a8dbdb7988e2b8f5b60cd73c750b135e86d75eb0bfe2f67d"
SRC_URI[deb1.sha512sum] = "071dec303d0e299538a476f90af818766ce972767c7393333151cce21a0908fa3b436f859fe7447a0dcb12a525b29209ca1c443513b5037119b4fe657ed4a43b"

RDEPENDS = " \
    libavutil59 \
    libc6 \
"

