# This was autogenerated! Do not modify
SUMMARY = "FFmpeg library for image scaling and various conversions - runtime files"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "ffmpeg"
HOMEPAGE = "https://ffmpeg.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/f/ffmpeg/libswscale8_7.1.5-0+deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/f/ffmpeg/libswscale8_7.1.5-0+deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "c643dc0e1e4520cbeaba9325204aa4c4"
SRC_URI[deb0.sha1sum] = "d03f56462a9ea13965f14c61bcfb2aa7891fc7c2"
SRC_URI[deb0.sha256sum] = "cf43cf4fe02a02cd36b25a86a2fcdeeaca9cc22bb1c81239302514db701d4e6d"
SRC_URI[deb0.sha512sum] = "be962302e32e719430b8184ec386bb97e0e90692bc6b1ab440b1a7fba3d8610b76fc8f82885a4805a83aefe3c8e49461b17d7b7e0b6b0c6f9667eed6e097a37b"
SRC_URI[deb1.md5sum] = "281f09966cf5612157409ecbbb502629"
SRC_URI[deb1.sha1sum] = "daf16780d08e0bdcc7bbd12b56f0e7a814142081"
SRC_URI[deb1.sha256sum] = "c091c8c7d7c4519280a33464eadf9280eaf9287486a5339e237ad39faa8c337c"
SRC_URI[deb1.sha512sum] = "84ae64000427f79ae7d2d65620257eeecd1ad60d3b274721db5f77fa8f1c02afdc4997e13c8ff7a742038237c36dcec1a153916f4b020c90cedb5f0932e0610f"

RDEPENDS = " \
    libavutil59 \
    libc6 \
"

