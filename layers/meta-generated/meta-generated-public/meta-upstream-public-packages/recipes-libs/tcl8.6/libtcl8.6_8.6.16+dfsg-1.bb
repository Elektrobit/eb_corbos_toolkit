# This was autogenerated! Do not modify
SUMMARY = "Tcl (the Tool Command Language) v8.6 - run-time library files"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "tcl8.6"
HOMEPAGE = "http://www.tcl.tk/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/t/tcl8.6/libtcl8.6_8.6.16+dfsg-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/t/tcl8.6/libtcl8.6_8.6.16+dfsg-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "5195be00d2cbfdcb87d38ba3a36e96a3"
SRC_URI[deb0.sha1sum] = "36425f4bebbc340e75958cfd12b5f56c34173b46"
SRC_URI[deb0.sha256sum] = "7cfa070ca822e572a91bf1719f6ac7d9b464dc8da4142ea68cbd31aeac2fc52a"
SRC_URI[deb0.sha512sum] = "0d1adc1ab8b1207ab8e289f246647eb930625be3aeedc5a151eb566d3dd87f92d536f342f2755a95ddd65ef9e5e92ada324404c4b3b8653435cf9d264cab4c48"
SRC_URI[deb1.md5sum] = "dc1aa016681192311f71132b90dd6bf0"
SRC_URI[deb1.sha1sum] = "32232af18bb17a855bbb000a78ed492b8d34681c"
SRC_URI[deb1.sha256sum] = "7a9f7eda696d505657a6cf54550fe50d4684bd79dc888d6b72f486f8066a14f5"
SRC_URI[deb1.sha512sum] = "8b5838bd8e20245af4fdc6ba1e2c16b7486692dd4f2fb14186214e9be8f7249b610336c3a21784f3983022f862132af7292003820da21f05f3349f551b2ee50c"

RDEPENDS = " \
    libc6 \
    tzdata \
    zlib1g \
"

RPROVIDES = " \
    libtcl \
"
