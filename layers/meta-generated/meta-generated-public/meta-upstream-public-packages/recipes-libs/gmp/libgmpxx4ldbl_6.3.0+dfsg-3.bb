# This was autogenerated! Do not modify
SUMMARY = "Multiprecision arithmetic library (C++ bindings)"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "gmp"
HOMEPAGE = "https://gmplib.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gmp/libgmpxx4ldbl_6.3.0+dfsg-3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gmp/libgmpxx4ldbl_6.3.0+dfsg-3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "0eb52296a1673c00ff182a65ca9dda52"
SRC_URI[deb0.sha1sum] = "32bf040e33e8ade38d0f4dcab64ee2eb5d64e22e"
SRC_URI[deb0.sha256sum] = "344c4cc65d955ac1b0f0a390d8bf5ad288fb1fda9e9f31f86d43ea6098eae603"
SRC_URI[deb0.sha512sum] = "3e049227e5e6ffed525f3e23d36626f319bc83f320803afd517e0fd6f05d9e3971c452c24a3acb317a54585b349712a572fe37ae4b496497eec6131d40c6f79c"
SRC_URI[deb1.md5sum] = "d5dad02b6b0b195f8f392f5b9fbeb472"
SRC_URI[deb1.sha1sum] = "68a6f41132df541d12aceff2172ab7fe2064a22d"
SRC_URI[deb1.sha256sum] = "485ab0e3fcf5b5e7f65dff510640b10c666d0ed4e695edb19eb1d64646367e7b"
SRC_URI[deb1.sha512sum] = "a0d1bddd82c1f43ae4970cba05bd81d3666943db6d5b886d723888df1930f792d69c9c94a3652c181ed71bd528b330ac8d847fe339d7312c025ce35277d8d6f6"

RDEPENDS = " \
    libc6 \
    libgcc-s1 \
    libgmp10 \
    libstdc++6 \
"

