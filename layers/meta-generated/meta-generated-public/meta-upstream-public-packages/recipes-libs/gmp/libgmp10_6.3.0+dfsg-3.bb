# This was autogenerated! Do not modify
SUMMARY = "Multiprecision arithmetic library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "gmp"
HOMEPAGE = "https://gmplib.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gmp/libgmp10_6.3.0+dfsg-3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gmp/libgmp10_6.3.0+dfsg-3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "3f1bfa704b2effe9fe6d7ea1f8776c26"
SRC_URI[deb0.sha1sum] = "63366c7a4935ec3db46d67fbe6d4c073b0c9fafb"
SRC_URI[deb0.sha256sum] = "d0d0265eb01770f17afd0f7c8c0622f80479dcfbbe13653a0debeec61464e622"
SRC_URI[deb0.sha512sum] = "dbe5c8a464a794d869b852500a109085a35488f93ce7c141a3d8143c86ef898db7f1488c7f773043e05f995e7413be18050e24a715758019b47331c4c1aa68aa"
SRC_URI[deb1.md5sum] = "fba7666457b0d37eb83eb693fdcf8562"
SRC_URI[deb1.sha1sum] = "a83ac683df04ef61869b581222c88731009d2028"
SRC_URI[deb1.sha256sum] = "a27bbc27f119161ea9702c8dd66f54131cdf0d2ca73000f50ea91ef2fdfef0fb"
SRC_URI[deb1.sha512sum] = "3f052fef3e533db2f99615ec1efe3ffedf27c92d94fd5478d65738b35ac54e9dbd550813947c246190fa1d849aa4a3d501de09b85ce165d18438c810520fe6ea"

RDEPENDS = " \
    libc6 \
"

