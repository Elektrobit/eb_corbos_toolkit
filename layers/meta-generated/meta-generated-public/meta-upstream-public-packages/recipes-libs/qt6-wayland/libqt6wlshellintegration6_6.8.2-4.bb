# This was autogenerated! Do not modify
SUMMARY = "Qt 6 Wayland ShellIntegration library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "qt6-wayland"
HOMEPAGE = "https://www.qt.io/developers/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/q/qt6-wayland/libqt6wlshellintegration6_6.8.2-4_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/q/qt6-wayland/libqt6wlshellintegration6_6.8.2-4_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "d873360f4d006b5b971cee6be38ed37b"
SRC_URI[deb0.sha1sum] = "13ac6286120e37bf2197d2ba2eb195563e73fbd6"
SRC_URI[deb0.sha256sum] = "f891a8e28de7efc4ca3443decb5d87ba16156db061c4a1f1c1fd9cc519f72aa8"
SRC_URI[deb0.sha512sum] = "5c92e0225db2fb05a39b8a46a19cf726a0fc3ffa75964144797125949bfeae7f2606e2c51bab70c373212f777328f379f3c704971eed978d652d9b68e1103b67"
SRC_URI[deb1.md5sum] = "6022249b70c40227a64f72f0519e8f97"
SRC_URI[deb1.sha1sum] = "52138331ae8863209940ed865d517c35a591336f"
SRC_URI[deb1.sha256sum] = "f9ffc202273312a6ab26fa941028a16ee04571905ce5bdac48910203cca8ef4f"
SRC_URI[deb1.sha512sum] = "d40eb03fb166302dced6fd7e33386c329eeafcabdd8efa4316bda716f40c86bff7ef6ae1d1156d0129991d2b39d9c6183080a6f84020f9282eb2648f46a5f109"

RDEPENDS = " \
    libc6 \
    libqt6core6t64 \
    libqt6gui6 \
    libqt6waylandclient6 \
    libstdc++6 \
    libwayland-client0 \
    qt6-base-private-abi \
    qt6-waylandclient-private-abi \
"

