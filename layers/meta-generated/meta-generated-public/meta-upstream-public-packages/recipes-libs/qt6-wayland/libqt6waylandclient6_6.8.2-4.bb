# This was autogenerated! Do not modify
SUMMARY = "Qt 6 Wayland Client library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "qt6-wayland"
HOMEPAGE = "https://www.qt.io/developers/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/q/qt6-wayland/libqt6waylandclient6_6.8.2-4_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/q/qt6-wayland/libqt6waylandclient6_6.8.2-4_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "41031ca7cc84e62eb88d0f7fda648715"
SRC_URI[deb0.sha1sum] = "3c2c97c9aa710e3521b7bd8b7bf84c2aaa2b2f5f"
SRC_URI[deb0.sha256sum] = "5b78f1caf65532ce52c6d4c51e043a223390cfe6376c1b9af1a5fd99ea1e7a9d"
SRC_URI[deb0.sha512sum] = "0a2327c9b34c4047f980c739acd1d6b670667343f7de10e51d766338ba67c3d7a830897d15cc259c33af1304d0397aec7b66bee49e5dadd7c637725fdd52a4f6"
SRC_URI[deb1.md5sum] = "489fcf61c5d2f69ff7af4b85fd7c4b80"
SRC_URI[deb1.sha1sum] = "6889b03703cadfba3bf48225c244f2b533e2e2ae"
SRC_URI[deb1.sha256sum] = "d30206c47292c63d40f2ce00c913a97a2dd0a4a428c5333fd6294e9f3de72439"
SRC_URI[deb1.sha512sum] = "011e257864f4a4ad7391a2a10423f00cdd0bc27e0b9e2b3c8dc10b414174f4ba8c8caf7b178ad52453ae841006494de5ad1909376cac7fbdeb0431e77cef642e"

RDEPENDS = " \
    libc6 \
    libqt6core6t64 \
    libqt6gui6 \
    libstdc++6 \
    libwayland-client0 \
    libwayland-cursor0 \
    libxkbcommon0 \
    qt6-base-private-abi \
"

RPROVIDES = " \
    qt6-waylandclient-private-abi \
"
