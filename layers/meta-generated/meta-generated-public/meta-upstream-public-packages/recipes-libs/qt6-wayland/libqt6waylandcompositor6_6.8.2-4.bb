# This was autogenerated! Do not modify
SUMMARY = "Qt 6 Wayland Compositor library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "qt6-wayland"
HOMEPAGE = "https://www.qt.io/developers/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/q/qt6-wayland/libqt6waylandcompositor6_6.8.2-4_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/q/qt6-wayland/libqt6waylandcompositor6_6.8.2-4_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "0b4b43183eae3d57fe9d8f29fbe069be"
SRC_URI[deb0.sha1sum] = "933d324d65ffc3a4b895a82b056ba63061c815ac"
SRC_URI[deb0.sha256sum] = "80060abee6eaf6e2a918fbb01e70a0e56950e7526e68d0cf5ce9677ec45ae535"
SRC_URI[deb0.sha512sum] = "9d9633699425a9d00d8fb39ea835389349f7ea810b37afee8dd2d8c93b1a8ef4baf9df2281000d676c0535479d1c08f86c1ef85e5ca0cbd6d888a1781157a35c"
SRC_URI[deb1.md5sum] = "090493bb2fb7887dcd88b5b245435403"
SRC_URI[deb1.sha1sum] = "10ea9a002c9023d774edde5cc3b37504762f4cf9"
SRC_URI[deb1.sha256sum] = "7634f19dd81f412e75e23ca62c0ca26216ff2723628d5d550c54ee9fd70b5759"
SRC_URI[deb1.sha512sum] = "d55b89ae6e9a6e68caafc1bd4e9c9532da808d3a31b6d5dad56ec5ffb2381892f4f211a12a0c8d3a28b3bd6620459a18c535a7489934d26af2390708e4aed792"

RDEPENDS = " \
    libc6 \
    libopengl0 \
    libqt6core6t64 \
    libqt6gui6 \
    libqt6opengl6 \
    libqt6qml6 \
    libqt6quick6 \
    libstdc++6 \
    libwayland-server0 \
    libxkbcommon0 \
    qt6-base-private-abi \
    qt6-declarative-private-abi \
"

RPROVIDES = " \
    qt6-waylandcompositor-private-abi \
"
