# This was autogenerated! Do not modify
SUMMARY = "rich set of graph drawing tools - gvpr library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "graphviz"
HOMEPAGE = "https://www.graphviz.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/graphviz/libgvpr2_2.42.4-3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/graphviz/libgvpr2_2.42.4-3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "e00716097d168203b97f39b942fdd6de"
SRC_URI[deb0.sha1sum] = "511e4b0016edb9a1697b34eaba2a6d57dc0d28e6"
SRC_URI[deb0.sha256sum] = "d54d3ab4edd75458264230829e8a0c6fd01c7d5b0dd487037512d5fa75af5248"
SRC_URI[deb0.sha512sum] = "bb37c671abfaf8dcfbf62e60b325a224bbfa383cac7d2414f28d6b9d146dd647102705699d0dd31dc7ef63dafc9c683df0cd6dc48ae9814000f12f5da8762bda"
SRC_URI[deb1.md5sum] = "2146e6f5279e12a3ccbf84267e9c0413"
SRC_URI[deb1.sha1sum] = "5bdcad4b4dae0836427d0c4ba24aad8421e8e407"
SRC_URI[deb1.sha256sum] = "518a67de503576d1c648271bc997729cb7fcad24f31f621a6aca998b1eb0040e"
SRC_URI[deb1.sha512sum] = "11e32bc216fb22f569608aceb2c5d362071cf64626977eb83dc113615f6dde99cd2ab039cf883bf3292a6bd125e60398d809dc0614d993ef0cc457eef83c39cf"

RDEPENDS = " \
    libc6 \
    libcdt5 \
    libcgraph6 \
"

