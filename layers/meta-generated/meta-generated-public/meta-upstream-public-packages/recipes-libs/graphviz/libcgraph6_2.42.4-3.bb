# This was autogenerated! Do not modify
SUMMARY = "rich set of graph drawing tools - cgraph library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "graphviz"
HOMEPAGE = "https://www.graphviz.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/graphviz/libcgraph6_2.42.4-3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/graphviz/libcgraph6_2.42.4-3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "5d6816eb84dc3d893388c3e0d6a51545"
SRC_URI[deb0.sha1sum] = "6072d74280bd0089e0cbba2d63918a873d3e4903"
SRC_URI[deb0.sha256sum] = "11cd202b7988fddfde8b7a93ac5309d468e79eaa4e666d19636551ff845dae69"
SRC_URI[deb0.sha512sum] = "60f24969f78cc576602c9597424de828a56fd2583390dd3624c52aaf56343b306783bedeb1889b377912ce782799a0d17914089d0aa8a01432f2bb242597e41e"
SRC_URI[deb1.md5sum] = "f5c6e645fc6cad62be87558cfd87c02c"
SRC_URI[deb1.sha1sum] = "95113916f268c3af71dfb709c24bd3f666a4c82a"
SRC_URI[deb1.sha256sum] = "a1cf3f8d2a2a6c8d707277fec4dcbe96c19d39c4ab22431fda4c01fae0c804f9"
SRC_URI[deb1.sha512sum] = "92322a2167a33f616f82f08c90ee91f1a3655c178109b8125f025b2d1fcd26a4e699e123c2c7f89efe65968e5bab7116dac1ee6df0ad9afa50b8f72caa4a3ab3"

RDEPENDS = " \
    libc6 \
    libcdt5 \
"

