# This was autogenerated! Do not modify
SUMMARY = "rich set of graph drawing tools - liblab_gamut library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "graphviz"
HOMEPAGE = "https://www.graphviz.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/graphviz/liblab-gamut1_2.42.4-3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/graphviz/liblab-gamut1_2.42.4-3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "d1f93835e7b26567eecda692a0b79847"
SRC_URI[deb0.sha1sum] = "f925e6f90a47d40056628e2154c84e03074184df"
SRC_URI[deb0.sha256sum] = "f90f37e249c50108307b760e016a7d2e0a6eee934852959e5ce2199d91ecb245"
SRC_URI[deb0.sha512sum] = "781ab8730d64e0f2954a36ff6ce1f85b9e148c894d6f89f9919dcca540cc43b5820e92f29965af30b875063796ca7c50027564d49cd3c87589da0ab12ae060e0"
SRC_URI[deb1.md5sum] = "6ebaa0b25301c16d46a35a2db32333fe"
SRC_URI[deb1.sha1sum] = "267e384dc7cfcdaef6efb0806e5bf45b094fff3d"
SRC_URI[deb1.sha256sum] = "cf17bb8933d920c2ca28541b7f19960b8f8a1ef1e3dc98b07144017375e4493a"
SRC_URI[deb1.sha512sum] = "6f80683747cb2c60a83010d6b26a8a1f2f7bad41f94121a59482966cc9a8ede459656c5a55cbfe865ec17675de0823434d693184529bbbccee1009d0e306d788"


