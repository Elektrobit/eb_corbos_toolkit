# This was autogenerated! Do not modify
SUMMARY = "rich set of graph drawing tools - pathplan library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "graphviz"
HOMEPAGE = "https://www.graphviz.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/graphviz/libpathplan4_2.42.4-3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/graphviz/libpathplan4_2.42.4-3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "20b19f27fcffcfcde909ee62ac347716"
SRC_URI[deb0.sha1sum] = "c2be68da7d02adf05a324ce46be26548d3c8759c"
SRC_URI[deb0.sha256sum] = "923abaf44e4680f7ada86eeb0e3a9aef868e48787269b61d602b2a27c0939245"
SRC_URI[deb0.sha512sum] = "bbbb4f009931d18ba4015a9ca1a58ed9068ba103afa578efae7930653a2fee8fc3ff7936eccd0ce02f1abea57ee7fee3383477ae73712730e640d5249c7c7e0b"
SRC_URI[deb1.md5sum] = "888bcab6881115bb56dac58560431d18"
SRC_URI[deb1.sha1sum] = "1589f5bb224090f477f99ba48b3db49bce3298e4"
SRC_URI[deb1.sha256sum] = "dde6f28254759bd95979f838261e53f95b98bf76bcc04925234aab6aad7661e8"
SRC_URI[deb1.sha512sum] = "0cde4184bf9e6f4935251fe38b0a384b8e9ba1f8dfac1c12270408b3fd8c346fc31887d5a95ed528af28b3560c732779e458d8d440234c0ed08ca7e9b14e0f8c"

RDEPENDS = " \
    libc6 \
"

