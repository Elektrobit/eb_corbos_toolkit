# This was autogenerated! Do not modify
SUMMARY = "System independent dlopen wrapper for GNU libtool"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libtool"
HOMEPAGE = "https://www.gnu.org/software/libtool/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libt/libtool/libltdl7_2.5.4-4_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libt/libtool/libltdl7_2.5.4-4_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "74f1031b3bb67ba2d0395689fb05d7b0"
SRC_URI[deb0.sha1sum] = "2cd716ae18845411266139f22adc754f8d6018ef"
SRC_URI[deb0.sha256sum] = "ab38167fc5aba8d133309fa98ca0a8b4e8b3c31588214ea70803a2bf3c6aa5ba"
SRC_URI[deb0.sha512sum] = "8be161e9c653389b37559072b80b8cd8daa7e1b33ac5b0478db9656d431b2a4583c7b7cd4da0fdc9412703bd09641306370c9465c22de12253743cd68422caf6"
SRC_URI[deb1.md5sum] = "2b242ce900ba1bba8ef9e366944031c9"
SRC_URI[deb1.sha1sum] = "58133ff8c1c1686c00d8d48ad4100026831555c8"
SRC_URI[deb1.sha256sum] = "f8877edda0d64026421de4e73c306903be05cf291721c6d0b9dee01af2445180"
SRC_URI[deb1.sha512sum] = "33c44a7a783e096e4a16406603bb6e4b41e593c62adc27b4bf6c696b065c065aaeec8eabba9778273ba279b642c91bd0c103a9d5172ae367e1e88b056556dd44"

RDEPENDS = " \
    libc6 \
"

