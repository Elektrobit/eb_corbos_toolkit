# This was autogenerated! Do not modify
SUMMARY = "GStreamer libraries from the "base" set"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "gst-plugins-base1.0"
HOMEPAGE = "https://gstreamer.freedesktop.org"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gst-plugins-base1.0/libgstreamer-plugins-base1.0-0_1.26.2-1+deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gst-plugins-base1.0/libgstreamer-plugins-base1.0-0_1.26.2-1+deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "4fcc720aab15d319cb52676879ed13b7"
SRC_URI[deb0.sha1sum] = "bd7693bdfec7786002f243e54a8e69d4804b84c0"
SRC_URI[deb0.sha256sum] = "a20aedb3f89c162b4859cec37076f4eba54b0bcc7e5cb254a26cc4a877a88a1e"
SRC_URI[deb0.sha512sum] = "dbf91ba17a023de64ade1019372d9755d770a989265fe4ea056c6e6296b44a7736d6f4a5b24f164901c4e9781b29f1a21a0e9d85653a258bdcf2fd187f9afbd7"
SRC_URI[deb1.md5sum] = "eb27b7eb48ab981e444e90131015c83d"
SRC_URI[deb1.sha1sum] = "92c031a346895fd3ceddd2b6356ae45465e11d1a"
SRC_URI[deb1.sha256sum] = "bc3205ea9fd35448b2cb6171da0e24bd3af893fb8a01f8eb797cbfb4d1fe7b0e"
SRC_URI[deb1.sha512sum] = "f8f39ced924a0d5bb7def762e4b4f71d6e5037794543fc52c39d2113a91af96bb1f3a4b3bfb600efa63acd792603d7efdb3bbed1149c2d5707b28c980255892e"

RDEPENDS = " \
    iso-codes \
    libc6 \
    libdrm2 \
    libglib2.0-0t64 \
    libgstreamer1.0-0 \
    liborc-0.4-0t64 \
    zlib1g \
"

