# This was autogenerated! Do not modify
SUMMARY = "Cairo 2D vector graphics library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "cairo"
HOMEPAGE = "https://cairographics.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/c/cairo/libcairo2_1.18.4-1+b1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/c/cairo/libcairo2_1.18.4-1+b1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "33a0a47234f9b4a0d7c91b29d01d6db2"
SRC_URI[deb0.sha1sum] = "51d0abf121d9fb10e9d8a9ce6b78c93b84152297"
SRC_URI[deb0.sha256sum] = "01390b049661e4cc8bd39cef78b41c2587d4035619d3b00d6c7846f43d80bbba"
SRC_URI[deb0.sha512sum] = "1cd7150a35cce2472e1ee664c07f9f2534caf1479737f2a76c560a6705cf17a04282df96d4135748b4cab87b38e3850ad3ce4dd3b5d0a39243f3eca44f711cf4"
SRC_URI[deb1.md5sum] = "cbdbd886c671fe7577c03cf6c243241b"
SRC_URI[deb1.sha1sum] = "cfe1aa671eecc7e39d6505819286de0de37b8c8d"
SRC_URI[deb1.sha256sum] = "de0e190f4566b51942387fb84fe85f064d23da896b8e2080930d53879a11630d"
SRC_URI[deb1.sha512sum] = "d376d0b93f04e12d710777ccff924fd1cd7ee9f5109a263f405c2ddcb45c937fddb2315ca43a785be945ed5bf8670b6571be92c9de5f16e02bc875358fadd991"

RDEPENDS = " \
    libc6 \
    libfontconfig1 \
    libfreetype6 \
    libpixman-1-0 \
    libpng16-16t64 \
    libx11-6 \
    libxcb-render0 \
    libxcb-shm0 \
    libxcb1 \
    libxext6 \
    libxrender1 \
    zlib1g \
"

