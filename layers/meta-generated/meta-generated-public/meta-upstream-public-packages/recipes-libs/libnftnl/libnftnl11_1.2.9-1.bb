# This was autogenerated! Do not modify
SUMMARY = "Netfilter nftables userspace API library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libnftnl"
HOMEPAGE = "https://git.netfilter.org/libnftnl"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libn/libnftnl/libnftnl11_1.2.9-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libn/libnftnl/libnftnl11_1.2.9-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "6104442f1d0b702a137151e2519b6bc5"
SRC_URI[deb0.sha1sum] = "82db7be68531fa062001b57dfaee8cc100989bd2"
SRC_URI[deb0.sha256sum] = "1b3eae46bfb9c6ab44e404797fb45278045f926d73974a84097ad47a3e27d983"
SRC_URI[deb0.sha512sum] = "95e3fe673c6fa214207b92d065911a8e403259d487d31cc52af64bb034712847c02e8bbb4eea3442af5a76332bd67283d6e4024e5d57cae1326055309405937e"
SRC_URI[deb1.md5sum] = "ee8f2a21ffd4ce254b44ed27fd3ae708"
SRC_URI[deb1.sha1sum] = "268145f28cc2c8be93dda69cb841204a6377ad9e"
SRC_URI[deb1.sha256sum] = "070278465783af9f3c38a9465d3dec8ad51468a87b8c3a52f6451d4e95e08875"
SRC_URI[deb1.sha512sum] = "4ecc30e27ee9b21f9fc0e9ca75eb2f9d9ac8ddcb61e4aae1aa9f877cd5bf9bfc8347a08773acf01e5aa6772c64d89aed4c7c02ca5880245dfd528a55379cadab"

RDEPENDS = " \
    libc6 \
    libmnl0 \
"

