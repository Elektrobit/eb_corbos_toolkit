# This was autogenerated! Do not modify
SUMMARY = "public domain open source cryptographic toolkit"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libtomcrypt"
HOMEPAGE = "https://www.libtom.net/LibTomCrypt/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libt/libtomcrypt/libtomcrypt1_1.18.2+dfsg-7+b2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libt/libtomcrypt/libtomcrypt1_1.18.2+dfsg-7+b2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "9d3f5fd733c9ba73bc0865c9530f5721"
SRC_URI[deb0.sha1sum] = "9ce57a47517d267a55786d250b8aa1d2bfbacdff"
SRC_URI[deb0.sha256sum] = "704174c153914d76b8924f35113042f437abddd7f281da9fca8861defb707a01"
SRC_URI[deb0.sha512sum] = "3d192130715744600f2442fe621817775b42cb0e23c13e68a2067d55b7effc9c35290ef797379661b5e5f1587485986aaaa64544c29d431e25217ecf06edf33c"
SRC_URI[deb1.md5sum] = "6ebf291976f584570764390daa2287bc"
SRC_URI[deb1.sha1sum] = "a6b1745d5ac7590691091aaec0b8caacaef98caa"
SRC_URI[deb1.sha256sum] = "30c14959f4ae9ba1b41dab47f6d7ca212b7cf45ce340d1a3a52e1fd25a5b643b"
SRC_URI[deb1.sha512sum] = "c9c6dfc5f96775475d0d9a247f78c39e5e76737e7b3e87024dd6434ebecc627795f708f8afb7cfd04a0d0c2b19ae26e1b87b0873cd44e42f9c58303fe8c3885d"

RDEPENDS = " \
    libc6 \
    libgmp10 \
    libtommath1 \
"

