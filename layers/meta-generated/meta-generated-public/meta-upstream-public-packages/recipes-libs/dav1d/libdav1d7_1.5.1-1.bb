# This was autogenerated! Do not modify
SUMMARY = "fast and small AV1 video stream decoder (shared library)"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "dav1d"
HOMEPAGE = "https://www.videolan.org/projects/dav1d.html"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/d/dav1d/libdav1d7_1.5.1-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/d/dav1d/libdav1d7_1.5.1-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "00fd1a932f4d979ef320ea7522f07957"
SRC_URI[deb0.sha1sum] = "3efd0713b827d3c14172db1387a851ad0994a222"
SRC_URI[deb0.sha256sum] = "8c64de4465a8ae1ca23e1dada1dfc73d7b431540fd5ae18f21430928576d5b05"
SRC_URI[deb0.sha512sum] = "4fbca23099cf026b0651f5cf42636e19ffb7ea7e34cffb427eccce6e21f28dad282452b77d59e550bd453b30ccff55be421685da1c23107b30ac10946c8b1f05"
SRC_URI[deb1.md5sum] = "280ea0979224c5cb81c437e07801e256"
SRC_URI[deb1.sha1sum] = "b46997f4cabaf874dcf80ce7de7bab255523283e"
SRC_URI[deb1.sha256sum] = "bcb430fa4c5f05bc3fa4dd9f18b7b0498ec9701c23e83bf57a29996216c3a245"
SRC_URI[deb1.sha512sum] = "7e4f952092c30d74a624d5ae49c25f0ecaaa8df52e3f6b528d2fb65d9355c4d9481c0d5fdc3484f8024e5117e165a9daec80f8554572b98413ea71ab46fe6178"

RDEPENDS = " \
    libc6 \
"

