# This was autogenerated! Do not modify
SUMMARY = "VP8 and VP9 video codec (shared library)"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libvpx"
HOMEPAGE = "https://www.webmproject.org"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libv/libvpx/libvpx9_1.15.0-2.1+deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libv/libvpx/libvpx9_1.15.0-2.1+deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "376fdfaea352ea06d425494e65d03f28"
SRC_URI[deb0.sha1sum] = "8ceffdb2de5f3b2d9672ed411d5852845c5e0ed3"
SRC_URI[deb0.sha256sum] = "5c2baac5c97a1fe01c4f0a2216743b901dc72437351e7451725a394c08037bcc"
SRC_URI[deb0.sha512sum] = "8bbfece555d2325f1f28917367c287a71bbccb717d45d4789e4b2080eb18801ca0b3e7a7e544759b3ce22e086165fa0696e3dd5ff8f48832856f5d938242207c"
SRC_URI[deb1.md5sum] = "d716e7a6fc8e30aa06317927e15ee50f"
SRC_URI[deb1.sha1sum] = "dae31333f543917e130d342217e76725ca68271d"
SRC_URI[deb1.sha256sum] = "96b7d384a6f090cf11f4634a9ad443a767ce7fa930b9b3136c27886a17e21d41"
SRC_URI[deb1.sha512sum] = "5b4683f1b5075b995940f4ec06b090236a0ea087f0ac7d41bc78ecdfe2aeb282c7db774b82aea92a9f840e5c3807e17528a81f467680f9d8f996523e790d72f4"

RDEPENDS = " \
    libc6 \
"

