# This was autogenerated! Do not modify
SUMMARY = "disk encryption support - shared library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "cryptsetup"
HOMEPAGE = "https://gitlab.com/cryptsetup/cryptsetup"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/c/cryptsetup/libcryptsetup12_2.7.5-2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/c/cryptsetup/libcryptsetup12_2.7.5-2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "0613bef73daa494ca56b22c61214106f"
SRC_URI[deb0.sha1sum] = "71181f4a821614afebc04f9bf2504c8ab693f2e1"
SRC_URI[deb0.sha256sum] = "84f6596296c346c1c8f6bb16b0d4d485215b7a23a23ff21e9c28e35822d45a7b"
SRC_URI[deb0.sha512sum] = "235fe19d01eb837423219f0309acdd76b392a396603ceb5dd94e6c902a9587d4abfdc423cc452f5febb87bfcf4c461cbafec679fa84ec15f5fcd6b7e4d20f59e"
SRC_URI[deb1.md5sum] = "1b139f88c2a5e4d1dea60d4a010f285b"
SRC_URI[deb1.sha1sum] = "bcf1c64e80c1442efb6db5b79c2687e58b11e812"
SRC_URI[deb1.sha256sum] = "c09ef97b4ec26101b0812f32ce27c697ee2d88bf44b018a541c3afbf282ee56a"
SRC_URI[deb1.sha512sum] = "63d374b86ea94ff6cfcf5963a01c85e49656a89c8ec8f3766adcb4f39b45fbb24cd90b39947f255b449dfa93fa07ce1c428e94e05ebd9176aae69cb4e4f085f8"

RDEPENDS = " \
    libblkid1 \
    libc6 \
    libdevmapper1.02.1 \
    libjson-c5 \
    libssl3t64 \
    libuuid1 \
"

