# This was autogenerated! Do not modify
SUMMARY = "Unix process pipeline manipulation library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libpipeline"
HOMEPAGE = "https://libpipeline.gitlab.io/libpipeline/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libp/libpipeline/libpipeline1_1.5.8-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libp/libpipeline/libpipeline1_1.5.8-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "485b072edc256b7e4ada4155bd048272"
SRC_URI[deb0.sha1sum] = "a077d5d9b44f061f70b63b549f973c9055f674bb"
SRC_URI[deb0.sha256sum] = "edf2aadc18f204a3ebbda0ca2797bf0d1fe8f6534ac1b2c23195561eec87a796"
SRC_URI[deb0.sha512sum] = "1f75216be23c10a89732ade4e5c78d4b7bfc4bc7a026e7a7b78c81375f0055f6035d9bb49df3c5a4fb1bf484d8d2b72dde900cf1ee3e4f8b14f08c4b14ab936d"
SRC_URI[deb1.md5sum] = "b08dd905647c47d877d1e76e6dbefcdf"
SRC_URI[deb1.sha1sum] = "715ab5cd8bf63aa736ed152e7164943a26b543c2"
SRC_URI[deb1.sha256sum] = "266ea878fb40719dc0afd6c2bfe9b728f7aaf2d6bbb7bc1bbb5bc40dea776da8"
SRC_URI[deb1.sha512sum] = "09cc537cb5279fc46739b221a548e6f5a5310a13325f17272f4485344ab8d7c7ac1db25c7b69c176a53fd7cfdc158ef4e96a2d20167b7454d4e7322fba86bf99"

RDEPENDS = " \
    libc6 \
"

