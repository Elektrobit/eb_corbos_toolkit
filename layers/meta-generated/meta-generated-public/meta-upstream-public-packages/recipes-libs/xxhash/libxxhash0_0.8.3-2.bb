# This was autogenerated! Do not modify
SUMMARY = "shared library for xxhash"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "xxhash"
HOMEPAGE = "https://cyan4973.github.io/xxHash"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/x/xxhash/libxxhash0_0.8.3-2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/x/xxhash/libxxhash0_0.8.3-2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "67acc4564e947a529a87f9111fdb4436"
SRC_URI[deb0.sha1sum] = "4789c2b1f7323382a3a7372947d40bf95d1ba301"
SRC_URI[deb0.sha256sum] = "81da7064d56fc044f5db4bb3c1e80ff50a4986dcbbf80d958eeca565b44c157f"
SRC_URI[deb0.sha512sum] = "5bcd90d5747fbb818ec87080a5d967a64a74cb8c54eb393b8916453ca42ac2460295313f7c8e7edb06b3aee79479000cf6ca55b553f777cf1628620ce519cd30"
SRC_URI[deb1.md5sum] = "5dc2a4bc2ece3aab055ac8e75a93d97c"
SRC_URI[deb1.sha1sum] = "fc71b4e0ff57a4cc795bbf422485cdf390471c3f"
SRC_URI[deb1.sha256sum] = "66665776740ced6c5ddcb48a89a92b056d0dcb13851e1ff573d2b99b766e5c6c"
SRC_URI[deb1.sha512sum] = "b544ada76e69445625c00f751df39e05b7ec6be51022a550f0a6d03d09b158bdc5b9362666dc7b5bb4c0bb21d7e003be340054b61a0e597475152e8eecf43136"

RDEPENDS = " \
    libc6 \
"

