# This was autogenerated! Do not modify
SUMMARY = "WebRTC Audio Processing library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "webrtc-audio-processing"
HOMEPAGE = "http://freedesktop.org/software/pulseaudio/webrtc-audio-processing/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/w/webrtc-audio-processing/libwebrtc-audio-processing-1-3_1.3-3+b1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/w/webrtc-audio-processing/libwebrtc-audio-processing-1-3_1.3-3+b1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "54f07ba9f46b69cb860b5b42e059aec4"
SRC_URI[deb0.sha1sum] = "578a85a2e3a0c34b31481714548b20add98092a3"
SRC_URI[deb0.sha256sum] = "00f978b3e6318bb07f13fc21e90ca8b031866fd2fc820b777b66dbe25d4a1474"
SRC_URI[deb0.sha512sum] = "0b511549b91de4f41a49eed5e8a22c26065f5c8670b667a7947c2229d76920cdab05b1042605ce1732ee8c882c269394fe7d5d6269a08c21f9f2a84f5386154d"
SRC_URI[deb1.md5sum] = "ac43ba894820d21f99810e80df04c5cb"
SRC_URI[deb1.sha1sum] = "00ef1e2286e5dfdfe27ab219789155aa152f073f"
SRC_URI[deb1.sha256sum] = "b3222b13cac750380a6f6800aace801fbc0587ab1fa23a4aa2ce307ed0391ae2"
SRC_URI[deb1.sha512sum] = "9813a444200a4b7fd67d71e88a370e740e38286a77c3ed29ba9f4760f75dc96d00d92249218cc5578dda838b8fd0213e9f2addfefe4d9ffef688b8bc14d3e479"

RDEPENDS = " \
    libabsl20240722 \
    libc6 \
    libgcc-s1 \
    libstdc++6 \
"

