# This was autogenerated! Do not modify
SUMMARY = "shared libraries for terminal handling (wide character support)"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "ncurses"
HOMEPAGE = "https://invisible-island.net/ncurses/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/n/ncurses/libncursesw6_6.5+20250216-2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/n/ncurses/libncursesw6_6.5+20250216-2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "66fceca527187dbbfd8341fded0d77a4"
SRC_URI[deb0.sha1sum] = "9e4d02ea5bb9018fff66731a7772086ac2333d7f"
SRC_URI[deb0.sha256sum] = "47baa2e11579583654583a066b69bd5a5d2f22423081f707ed6c0c3ba6d538b7"
SRC_URI[deb0.sha512sum] = "52773e0af928ae1a1b8a88e056f30f1a71e12a61b17b2c784234279495398167d85315b28f0a1a0787f0682521c566a4b9276d34256052469686944036857a8b"
SRC_URI[deb1.md5sum] = "528305c632e338ae56351cf03c26f084"
SRC_URI[deb1.sha1sum] = "febe3d2afbe7837f01052a7b5974b0972731b3dc"
SRC_URI[deb1.sha256sum] = "72121aeb08be2d915da321ddfae74f62a0764286f336279b2c2609ba07496d6d"
SRC_URI[deb1.sha512sum] = "4d43631b7e9752c990488cea238253c19b7ac8070521c09923108af2d4f1534abd3e9dea1e967f8c5f3988b6ce76f255540b1602d51f48c9d9d5985956602617"

RDEPENDS = " \
    libc6 \
    libtinfo6 \
"

