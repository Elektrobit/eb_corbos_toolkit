# This was autogenerated! Do not modify
SUMMARY = "shared libraries for terminal handling"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "ncurses"
HOMEPAGE = "https://invisible-island.net/ncurses/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/n/ncurses/libncurses6_6.5+20250216-2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/n/ncurses/libncurses6_6.5+20250216-2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "ff87a293c329827ef29a5e6369155bfa"
SRC_URI[deb0.sha1sum] = "0a64b9bc26c1de98f5080aef6e35e6abb25c2a0d"
SRC_URI[deb0.sha256sum] = "e00cbcc8c0826993f881f492c05f33ba8d79b5375dc5a2ab59c82e0c7b9179a9"
SRC_URI[deb0.sha512sum] = "b83de5311abe1153a5589df5b42d6075968eb645866b71f4c02ab9cc92bb6be07ee997676154d30a9746cf1bc334939510f4f06e72205eaea5e46288472315c6"
SRC_URI[deb1.md5sum] = "56bf054c605806b8cc6d3a7c683bff83"
SRC_URI[deb1.sha1sum] = "528bc794bb125253fc7e659b71eed591ecfa237d"
SRC_URI[deb1.sha256sum] = "259fe5736ebb105df7c6a7b5cc6231a8743666f5f57885f6c7989babe2fc0082"
SRC_URI[deb1.sha512sum] = "0759ff7fce50c4e5309910b209139727f2a399331b9ef763d93782087bc58473fc97dadad22aa179edca300b033f2ebaa571b83fc6f08c112687461b66904b38"

RDEPENDS = " \
    libc6 \
    libtinfo6 \
"

