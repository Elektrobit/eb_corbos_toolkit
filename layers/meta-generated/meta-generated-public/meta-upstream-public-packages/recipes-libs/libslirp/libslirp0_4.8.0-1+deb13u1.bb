# This was autogenerated! Do not modify
SUMMARY = "General purpose TCP-IP emulator library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libslirp"
HOMEPAGE = "https://gitlab.freedesktop.org/slirp/libslirp"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libs/libslirp/libslirp0_4.8.0-1+deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libs/libslirp/libslirp0_4.8.0-1+deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "a0355e7a3086d0321ece907ceaf3095f"
SRC_URI[deb0.sha1sum] = "076edc050e9885d59aa50c2357995c273feff413"
SRC_URI[deb0.sha256sum] = "6125698173f8be0d0de01ff897a0df3c5e50fb09f70238b26dd6574aaa0934e1"
SRC_URI[deb0.sha512sum] = "7a21227b88f3443983222633313058fe435224715830a02a423cfddc37ec8b5512b3f5a09f005d790b7a284cb86cf6416c1953d7e2766b9691ab206f433c09ec"
SRC_URI[deb1.md5sum] = "0ff8f28fd148dc2c96fa6b222e53e9ee"
SRC_URI[deb1.sha1sum] = "110ecbd5d93d7ee1859c351955364274c15de259"
SRC_URI[deb1.sha256sum] = "e02a43a6d199ff9163da97e5037c132701514144130ca0ac1aaa19254ab1ce3d"
SRC_URI[deb1.sha512sum] = "766abf5d4eb0663d270301f4355572d52890447a028a34d6a6c7a1c8e9d1e49a852837ae25702d7fcd5c087fe6d6e6d7070444576f8e5a867b83622c553093da"

RDEPENDS = " \
    libc6 \
    libglib2.0-0t64 \
"

