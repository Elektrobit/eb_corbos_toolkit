# This was autogenerated! Do not modify
SUMMARY = "filesystem operations (portable paths, iteration over directories, etc) in C++"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "boost1.83"
HOMEPAGE = "http://boost.org/libs/filesystem/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/b/boost1.83/libboost-filesystem1.83.0_1.83.0-4.2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/b/boost1.83/libboost-filesystem1.83.0_1.83.0-4.2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "b921e08b943b5add1319eefd36f35c27"
SRC_URI[deb0.sha1sum] = "97aee461b0a85eb327803ee8ee67f7568488f5ae"
SRC_URI[deb0.sha256sum] = "6b587623a4fd1824613e7ee02ba35b84cd9534b520b7f3d08d15f9ed85f28cf3"
SRC_URI[deb0.sha512sum] = "ef1ac8cb1bfca5ea06c66a2ffc500035bb0dd25a8674b6be060687cefac765bc74e98697458c4ef5daf21d08f38c6f373c17f0b9c39f6d00c306d2d6ca4dcee0"
SRC_URI[deb1.md5sum] = "b4580cbd68984a18f64d738f813042c0"
SRC_URI[deb1.sha1sum] = "08ed9a45c775864c9f3460386945e3152bc1a37f"
SRC_URI[deb1.sha256sum] = "10b958550550b2e7c71f0ae216566bb9eb959da645a6a0db25fb499549c49f15"
SRC_URI[deb1.sha512sum] = "7ba20c5fbfb29cae0f097971b6cadb1608df2525ca46dc500f08403fc15f3ebbe982f5093944b7f7ff53e42362d0662cc0a761077979ce5e4620af1618d90440"

RDEPENDS = " \
    libc6 \
    libgcc-s1 \
    libstdc++6 \
"

