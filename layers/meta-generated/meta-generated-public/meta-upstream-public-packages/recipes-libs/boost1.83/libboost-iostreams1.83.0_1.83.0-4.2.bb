# This was autogenerated! Do not modify
SUMMARY = "Boost.Iostreams Library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "boost1.83"
HOMEPAGE = "http://www.boost.org/libs/iostreams/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/b/boost1.83/libboost-iostreams1.83.0_1.83.0-4.2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/b/boost1.83/libboost-iostreams1.83.0_1.83.0-4.2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "6a76a396ba787f779edc9101b5c7c82c"
SRC_URI[deb0.sha1sum] = "d420f9549d48fa915a9112a205445d2ac44d74c3"
SRC_URI[deb0.sha256sum] = "65db6c6900a35c44a23e680aa9f5b93ce6fd51c6b18eb74f64cecbd824077386"
SRC_URI[deb0.sha512sum] = "7a4dda66d4845b096ec674db0dd87b35cbe56fb6e1e4f94d7f4850868caec5525863cda124367458acf353c6216268bf4f2e9a20fea24c1977f4ff3c06ad9287"
SRC_URI[deb1.md5sum] = "6f58b1b88485d4b21ecc0b21c012b947"
SRC_URI[deb1.sha1sum] = "b2cc6cf6af2e85236cfa232fe8bc74fd84e5c41c"
SRC_URI[deb1.sha256sum] = "f0c60676f13a63aced5ecae1b5ec7b2a05a155e7c5b947f9b58d2645927e7d45"
SRC_URI[deb1.sha512sum] = "8346c7e4aa765b9e0479f16e884db4cec94d25f1d3e37a61239fa1eb0a16e0d752d73fa8ea0c95b56f59b4be4462b7c2f71636ec134939b4d092cf077a7aeb77"

RDEPENDS = " \
    libbz2-1.0 \
    libc6 \
    libgcc-s1 \
    liblzma5 \
    libstdc++6 \
    libzstd1 \
    zlib1g \
"

