# This was autogenerated! Do not modify
SUMMARY = "program options library for C++"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "boost1.83"
HOMEPAGE = "http://www.boost.org/libs/program_options/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/b/boost1.83/libboost-program-options1.83.0_1.83.0-4.2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/b/boost1.83/libboost-program-options1.83.0_1.83.0-4.2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "7c0f8e58ea52169e340653c14437043d"
SRC_URI[deb0.sha1sum] = "a507580cf3b3c53a98ba405b89098077207832da"
SRC_URI[deb0.sha256sum] = "dc5fa835e9362fd3d285ccb0aeaecada4954b9a2ccf765891af868482edeb6f4"
SRC_URI[deb0.sha512sum] = "3034f578801e25e74d9120bf8361e895ce55a4694a449b1ec766c06abaacb8fc6d0f8f5241ceca8f01b05680e8035f65c60e17c968399fb0b40c5bfcdac79a91"
SRC_URI[deb1.md5sum] = "5d1ad75125374eac426dc811c491fa05"
SRC_URI[deb1.sha1sum] = "d3dc6de0dc3a19e4c81192a13c5bc075cba91f9d"
SRC_URI[deb1.sha256sum] = "c612739c96effb8919654638d610d6bfd9e7b46d9b85d3870afb56941020b9cf"
SRC_URI[deb1.sha512sum] = "460660d783b30ab45d73316b81a0d9f7aeb092fb7bd5ffa5149de7ec00a8838288665b5b0c2c504a9a404713aa3d3b4b4f4c040590f6c4cf12bc5a3053963956"

RDEPENDS = " \
    libc6 \
    libgcc-s1 \
    libstdc++6 \
"

