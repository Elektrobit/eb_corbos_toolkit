# This was autogenerated! Do not modify
SUMMARY = "library to read HRTFs stored in the AES69-2015 SOFA format"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libmysofa"
HOMEPAGE = "https://github.com/hoene/libmysofa"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libm/libmysofa/libmysofa1_1.3.3+dfsg-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libm/libmysofa/libmysofa1_1.3.3+dfsg-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "ec2b9cc07f658c48d3414eb07dcc9fb6"
SRC_URI[deb0.sha1sum] = "76aef6fdf2d10a7ec64effa262680cefeb50abad"
SRC_URI[deb0.sha256sum] = "27c71e7a0cb7b4d9a683b4ad721d65f11ff1d83823873ee28ac892078bcdb0a1"
SRC_URI[deb0.sha512sum] = "7d8e74ec87052c11601e613c34da2dc3ed6241cc82543130dc39fd968920f639a1065cced3f280564ba6d223b9bb1e99b4288ff696cd0a86922bc0acbc92e8d0"
SRC_URI[deb1.md5sum] = "fbe4b23d695280c6ee390a9713375079"
SRC_URI[deb1.sha1sum] = "54168e18536f71b0e56287bc6f947ec97823a287"
SRC_URI[deb1.sha256sum] = "691ae51a7b5643fb9f7c81c917d12c1dc71c74eb1cf2073f0d3f71141fbffa8a"
SRC_URI[deb1.sha512sum] = "bc021d9dbf9ee4776c0da871ef9ef9891cc62d021ca42626f580920997c85b710d794c97bbcd59ace3632faba05d0c4f662ee56fa63aca5dd74925733e4417fb"

RDEPENDS = " \
    libc6 \
    zlib1g \
"

