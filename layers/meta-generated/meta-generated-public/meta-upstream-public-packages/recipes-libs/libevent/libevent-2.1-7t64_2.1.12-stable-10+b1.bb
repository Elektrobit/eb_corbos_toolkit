# This was autogenerated! Do not modify
SUMMARY = "Asynchronous event notification library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libevent"
HOMEPAGE = "https://libevent.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libe/libevent/libevent-2.1-7t64_2.1.12-stable-10+b1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libe/libevent/libevent-2.1-7t64_2.1.12-stable-10+b1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "d3cbecd93062fec026069ab7f3ac1618"
SRC_URI[deb0.sha1sum] = "019029de4595f0f7b0700eb1d0182abe2febf221"
SRC_URI[deb0.sha256sum] = "5b2201fe46d8710bc4b2566abe0a3e29c63dd94779644f6d32c777a5281c86a3"
SRC_URI[deb0.sha512sum] = "dbf7d764a9140f14bc1b98df4d8519a12a338e26af898f38f0476aa345e5e9a42b32abe8c634100ab7adb9b5026a490dd68cb591f9eb0d7c95ee1db4d4677f49"
SRC_URI[deb1.md5sum] = "ad9b447bd3f6500bc4e19f6ce61e05c6"
SRC_URI[deb1.sha1sum] = "b223c896ce90ed5e0244f27843bbcba43eb07e28"
SRC_URI[deb1.sha256sum] = "f575eebfdfac806695a717bcde514940161227fd136fe5aa5cea3bb5db37c4f7"
SRC_URI[deb1.sha512sum] = "6aaf53b1318e8b157ead49232a6dbb9c7a4b77bf3a902b58d69be1fe44648676e5173f8e1b14a12db99a9b3051a1512ca0b62d33af9d9af92c8ba411f750e7f3"

RDEPENDS = " \
    libc6 \
"

RPROVIDES = " \
    libevent-2.1-7 \
"
