# This was autogenerated! Do not modify
SUMMARY = "X shared memory fences - shared library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libxshmfence"
HOMEPAGE = "https://gitlab.freedesktop.org/xorg/lib/libxshmfence"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libx/libxshmfence/libxshmfence1_1.3.3-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libx/libxshmfence/libxshmfence1_1.3.3-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "5960dbe12a2b1a278dca22453be659b6"
SRC_URI[deb0.sha1sum] = "eabb0e94298339585895e5070221de4ea4edd648"
SRC_URI[deb0.sha256sum] = "7b339e9e5b2349723d35af4df89bcc7aa456bbdf8ba1754358f9b44c3fe1f964"
SRC_URI[deb0.sha512sum] = "7904748399468c33e30bcd46612bf9f646688ac56acc9f99b72b294cd4e5da98ea46c5c1800645115da92e50245c19472a109797a32c3a1e9d05bbe37b10007d"
SRC_URI[deb1.md5sum] = "99ce6f6db1f51fd59d43bc9cee1831a3"
SRC_URI[deb1.sha1sum] = "75b99bd99b67173b53764efd95d4250580a2d8ed"
SRC_URI[deb1.sha256sum] = "34b494c83cebcf138d1f87c2cbdd5ee8efe9da2befbd69c2a025b0e214c64d2d"
SRC_URI[deb1.sha512sum] = "961a21c60a245ebf64237c004ec442e3a8697390f95da2cbaf4a867fd3525528bb58a1b597952a4954584952fa5f1de573d97e80fcd05ceaff3e54593e43717b"

RDEPENDS = " \
    libc6 \
"

