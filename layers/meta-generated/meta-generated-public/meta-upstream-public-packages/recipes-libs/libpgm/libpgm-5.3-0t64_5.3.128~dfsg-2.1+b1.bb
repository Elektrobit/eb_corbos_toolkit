# This was autogenerated! Do not modify
SUMMARY = "OpenPGM shared library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libpgm"
HOMEPAGE = "https://github.com/steve-o/openpgm"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libp/libpgm/libpgm-5.3-0t64_5.3.128~dfsg-2.1+b1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libp/libpgm/libpgm-5.3-0t64_5.3.128~dfsg-2.1+b1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "5417ac831f374bcb47fa46220d6cb26f"
SRC_URI[deb0.sha1sum] = "2286808c3eb972b5ebfd7c92f970049c30669ea7"
SRC_URI[deb0.sha256sum] = "865c47a7865da63e7d620f0999ab7d10cdae8b638b691061166975c654a0e5f9"
SRC_URI[deb0.sha512sum] = "3e6dade8f6d014671541d35a20e098e7c66f3c12ac7f3959d087c582c75e51be2406b10c6204bf5814f596f2eea0dced24a2f68cbb9a2768675e581a9223a6b8"
SRC_URI[deb1.md5sum] = "ba3d62ed555aa1dfb573c704f5035cc2"
SRC_URI[deb1.sha1sum] = "973ecbe3be771dfcfcab366634e6d77f31b83949"
SRC_URI[deb1.sha256sum] = "6db0a545d79fd0c5009fa4c31bd90beae50fb02b413ec71bb0fc482219b83a9f"
SRC_URI[deb1.sha512sum] = "6e7b7400fc2a1b5af79badd4f219bb98fa61802aa6542d92367c07a5a7272d0087ec7becd2f75eeeadfe6fad897b87769bb3220111974689c28bed569cccb161"

RDEPENDS = " \
    libc6 \
"

RPROVIDES = " \
    libpgm-5.3-0 \
"
