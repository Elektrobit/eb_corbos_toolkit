# This was autogenerated! Do not modify
SUMMARY = "Foreign Function Interface library runtime"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libffi"
HOMEPAGE = "https://sourceware.org/libffi/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libf/libffi/libffi8_3.4.8-2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libf/libffi/libffi8_3.4.8-2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "acf30e8b2efe35ce199554f6493f3791"
SRC_URI[deb0.sha1sum] = "4d9e9db02daf74178b6aa6d99b3cc64cc4308a74"
SRC_URI[deb0.sha256sum] = "0ebdc340de33333639c3c63874cd4b15ac2e83dfa1ef3053b7eefaf4919f4f68"
SRC_URI[deb0.sha512sum] = "3ec19b9a5820b01fc7ba14dec7c347a2725990538997b57dd6a397852ac5373c9f2a434b841403fe24afdffc6c5d0eb13def6aa1da049a1745f7e2c824464bbf"
SRC_URI[deb1.md5sum] = "0fac770fbf58db8b83f301e6aa4c1bd6"
SRC_URI[deb1.sha1sum] = "4c9a0dae1e87367e6794583e71d9bac024e71ac7"
SRC_URI[deb1.sha256sum] = "d84a783b818f2386627604e64b793eb4ac5bb9ea1ba321a194a1c9c82fe09a01"
SRC_URI[deb1.sha512sum] = "d5d78c07d099d61e25b3ab94262b39248d8e9ed2a94ae06cf0fcba8ccf2ab2b760d64ff0f69911315f95f2a1cd1970213785b7ee5ecbbcd52bffefc4bbfbb1cb"

RDEPENDS = " \
    libc6 \
"

RPROVIDES = " \
    libffi8ubuntu1 \
"
