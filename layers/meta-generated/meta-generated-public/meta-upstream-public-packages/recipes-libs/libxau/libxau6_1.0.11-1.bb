# This was autogenerated! Do not modify
SUMMARY = "X11 authorisation library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libxau"
HOMEPAGE = ""

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libx/libxau/libxau6_1.0.11-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libx/libxau/libxau6_1.0.11-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "4aec39848ed84d35bdd168928d7a37a5"
SRC_URI[deb0.sha1sum] = "3617bde7a7571de051ea98d57a978f3a357631a3"
SRC_URI[deb0.sha256sum] = "689a9f0e0ba3e2c65431f864871e303ee904de69dd28abfc462663fae030227f"
SRC_URI[deb0.sha512sum] = "53b52699aa2491c2bf8c55af16110cad39650cb4a8179ce36580dc67c4e8394f3e842efeaf2b8de51da477fc0b85b0b226184fd8bd0d6c1c72ac4c8344b54eb2"
SRC_URI[deb1.md5sum] = "a0886cccf4d0e3d3131d6aabee1f3781"
SRC_URI[deb1.sha1sum] = "51c8766644614fccde2eca41745aa0a6ca1272c7"
SRC_URI[deb1.sha256sum] = "ac1061728670f4626adaa1288953a0e6fb801c9cae72ee1c3231e63e2609d23a"
SRC_URI[deb1.sha512sum] = "e3732593bf6c3cb1a31a3d1ea785431fe215fae4d8273dafc9dfd009c459d9b908efd8e531a40576eb6de12794e5055d0c437a27395be241c9a3ee0e5ed8ba64"

RDEPENDS = " \
    libc6 \
"

