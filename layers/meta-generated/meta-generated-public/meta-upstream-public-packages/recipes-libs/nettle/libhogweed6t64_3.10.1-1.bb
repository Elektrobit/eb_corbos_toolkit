# This was autogenerated! Do not modify
SUMMARY = "low level cryptographic library (public-key cryptos)"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "nettle"
HOMEPAGE = "https://www.lysator.liu.se/~nisse/nettle/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/n/nettle/libhogweed6t64_3.10.1-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/n/nettle/libhogweed6t64_3.10.1-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "51e773a48a28fddd423e2f298671f75b"
SRC_URI[deb0.sha1sum] = "f18c65851945accdac8706a6175eb94dbeb70912"
SRC_URI[deb0.sha256sum] = "b059ed155115ac09da295322de48ee1ed58ef5fa45edcc9e12ff0e94636ef25f"
SRC_URI[deb0.sha512sum] = "d9d127aefef45df44f33145b75449ae30a7e20b674e9d4425af4cffd2bada7b32c5bd0c25429471f61949c4a96311e68d2e91f593334211f5d945c765c347c14"
SRC_URI[deb1.md5sum] = "bf229cbc4829f321e0ac56928b21375c"
SRC_URI[deb1.sha1sum] = "e6f5e29df343af123b6c0c1cffe57858d2c4cd0c"
SRC_URI[deb1.sha256sum] = "cb92d5a51c4fd6c7b7cbb62aaa60c7af830d0bea5b410fb1f47ee685e26944d1"
SRC_URI[deb1.sha512sum] = "2f543d692e29d62c5cede53fbb2c7f15bac1f3a07f80438defd75fc4939daef5a275435df019a94ebb3773a0ac3245cdce3f007b17df85021fbe7a4d9f9c66a3"

RDEPENDS = " \
    libc6 \
    libgmp10 \
    libnettle8t64 \
"

RPROVIDES = " \
    libhogweed6 \
"
