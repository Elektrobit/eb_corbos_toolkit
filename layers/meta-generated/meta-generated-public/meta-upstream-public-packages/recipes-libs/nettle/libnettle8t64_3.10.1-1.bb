# This was autogenerated! Do not modify
SUMMARY = "low level cryptographic library (symmetric and one-way cryptos)"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "nettle"
HOMEPAGE = "https://www.lysator.liu.se/~nisse/nettle/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/n/nettle/libnettle8t64_3.10.1-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/n/nettle/libnettle8t64_3.10.1-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "3cb9ab304fc612e62f2caeaacdfb38d9"
SRC_URI[deb0.sha1sum] = "706ed322be3f8c5eaef0fa1e1fc9529e6320e53d"
SRC_URI[deb0.sha256sum] = "1b03d4a9cd9c8143ba50fe6396f36937e901a317d492d179f4596862c1731cfe"
SRC_URI[deb0.sha512sum] = "947bcdd2e52f46cd5bab0f0ca883ce945d712dcf56d08647fe335dadd98123c9ec2be3f91ca07b2fac4ac877555b445bacc29b7b724917cbcd1fa35fb9c5f8f0"
SRC_URI[deb1.md5sum] = "d1ebde38ee25612bc7532380019fe7d1"
SRC_URI[deb1.sha1sum] = "4cfc08ba3e0c52f6c4e89a8cbc9b9298e5d04a49"
SRC_URI[deb1.sha256sum] = "16107ce5a7b522da021fa8aba42d42af9c5e90ddabfcda3710aff6ea95808ee0"
SRC_URI[deb1.sha512sum] = "85306b2eac98dd79623d4015688570c85b7d58a3abd1ed8c2958d1271fb19b90996449733898450113a14588b8f5d54073673c68b2db31a26f5749a9540c2f98"

RDEPENDS = " \
    libc6 \
"

RPROVIDES = " \
    libnettle8 \
"
