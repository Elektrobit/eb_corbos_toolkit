# This was autogenerated! Do not modify
SUMMARY = "Intel Video Processing Library -- shared library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libvpl"
HOMEPAGE = "https://github.com/intel/libvpl"

inherit dpkg-prebuilt

DPKG_ARCH = "amd64"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libv/libvpl/libvpl2_2.14.0-1+b1_amd64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "aeb537b2479f3aa65a206c8fd64ed30e"
SRC_URI[deb0.sha1sum] = "90d1030fe5eddece9b128caa9ba7f4123d8764a4"
SRC_URI[deb0.sha256sum] = "cee5b3fdfb5c2a944f4366406bf245992c7aaa234cdfb41acffba8f2bfbed1b4"
SRC_URI[deb0.sha512sum] = "90a66591223237ba22210d1b73d7fe133baaecdd5933f2b866d7ebd5e9c083c9a8fd7a2baf3508778662007f25ef4a1005b5799133e313953e16f3694fff2179"

RDEPENDS = " \
    libc6 \
    libgcc-s1 \
    libstdc++6 \
"

