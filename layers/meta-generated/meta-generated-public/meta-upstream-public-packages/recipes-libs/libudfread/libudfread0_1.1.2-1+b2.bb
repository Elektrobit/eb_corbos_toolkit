# This was autogenerated! Do not modify
SUMMARY = "UDF reader library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libudfread"
HOMEPAGE = "https://www.videolan.org/developers/libudfread.html"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libu/libudfread/libudfread0_1.1.2-1+b2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libu/libudfread/libudfread0_1.1.2-1+b2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "8a47e62f833644517f26ffe5c3be9723"
SRC_URI[deb0.sha1sum] = "53f1767bcc74138fa9f88338afc1ea4b90f1486c"
SRC_URI[deb0.sha256sum] = "dbb34708521e4e895d1e061b765548ea408e670c8b2a17e84529166afa88e5f1"
SRC_URI[deb0.sha512sum] = "40a52116ac09c923a1337f1af38d54df7a8df75738499c715a6327c72359035cbfbc83408cb4c7e15ffd948ca2b8bb802a418f34d5b1eb45cefa8bfd0fc3af00"
SRC_URI[deb1.md5sum] = "42d96cb7d0e056e82b5c6eb3f66aebb3"
SRC_URI[deb1.sha1sum] = "0f3a591541f9175c366491dd28597faf49dbd120"
SRC_URI[deb1.sha256sum] = "badab108ac953987ced64c4b25a38c75ac391e6f4815cca4880619f313b4da22"
SRC_URI[deb1.sha512sum] = "3aaaec19beef9005fb9fb790e6e15c36cb26a6d6542ada37b848c0e85b767be72433661d0a91fea613867692cf6c6da54c5846760b348627bd9f95ccb656f8c4"

RDEPENDS = " \
    libc6 \
"

