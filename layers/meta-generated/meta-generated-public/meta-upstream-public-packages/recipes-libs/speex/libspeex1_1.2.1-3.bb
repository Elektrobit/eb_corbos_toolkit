# This was autogenerated! Do not modify
SUMMARY = "Speex codec library (runtime library)"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "speex"
HOMEPAGE = "https://www.speex.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/speex/libspeex1_1.2.1-3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/speex/libspeex1_1.2.1-3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "3ba67f24c9a992c6af558df940185cb4"
SRC_URI[deb0.sha1sum] = "3392b4137fcad06cd9e885bedee02457e1e0b975"
SRC_URI[deb0.sha256sum] = "26623d450c2a51f9f6801b19ee5be1303aee4087557d1389020a0df00afa6e77"
SRC_URI[deb0.sha512sum] = "3a940ef5c803a05f6243a864d296137f69c1c5d2bccbdaa804f4c8d51e878bf3d7e8871dd9dc2ab6bcfb0a16ac9b0c5d1b5c4139e8663a8474a890b27ce51469"
SRC_URI[deb1.md5sum] = "e69ca5a60e6b8153fbffedcd985562f5"
SRC_URI[deb1.sha1sum] = "472aac9a1a5a74b2d317c87bebb671f5ab1ecf6c"
SRC_URI[deb1.sha256sum] = "20e12b5754792b5d2c4386c4f405d652c4d6f91ec4e6f68b0c70a48bf3095a28"
SRC_URI[deb1.sha512sum] = "c59f3d3548424f5cbec3a7a48472f38015897440ef00ed6238675788e2a91508468607c095c1f4c80cd9a80f3867f2e20c1a13dbec46010bdec24730df0113ce"

RDEPENDS = " \
    libc6 \
"

