# This was autogenerated! Do not modify
SUMMARY = "Data files for Thai language support library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libthai"
HOMEPAGE = "https://linux.thai.net/projects/libthai"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libt/libthai/libthai-data_0.1.29-2_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "dcad33696efc1f34f13945164a42e5df"
SRC_URI[deb0.sha1sum] = "668800d5f7cb8286a36dbcf9610d72ad4091ae5b"
SRC_URI[deb0.sha256sum] = "fd38d40602834d510a29140bd27fd48485105e834f03dccab1c02e2edaa794dd"
SRC_URI[deb0.sha512sum] = "1dd5987681cd74f9048876957b38e655a505dc66995e41bfb65d7f418c39048882f5eadcf4a7d3583be43a82c178bc7d1d9fe6a407b8d6828de4d701568be9f2"


