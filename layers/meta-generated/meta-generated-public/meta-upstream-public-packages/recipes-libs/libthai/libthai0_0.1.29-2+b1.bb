# This was autogenerated! Do not modify
SUMMARY = "Thai language support library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libthai"
HOMEPAGE = "https://linux.thai.net/projects/libthai"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libt/libthai/libthai0_0.1.29-2+b1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libt/libthai/libthai0_0.1.29-2+b1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "cafac6592587bb71121a5f5f96306a19"
SRC_URI[deb0.sha1sum] = "e26a84b05448e96717593c0257a9055f82a6ec42"
SRC_URI[deb0.sha256sum] = "e6364c07aeeffe9a95f267061d9df168e48e9dc9126c3b40e19dc829f67702a7"
SRC_URI[deb0.sha512sum] = "543b78a5fd4a20a73583de2f1d2ed43c6c08804a1985712f21b4aba9711197b3725122c0645d3ce25708374982cc811dae65eb5fb0f48230b9a553b9f9b2dec4"
SRC_URI[deb1.md5sum] = "ac4307b7686ed1eeb06d54d97bb2a56d"
SRC_URI[deb1.sha1sum] = "3f532d9e26f6a509fe9f1c594019523e96d364e2"
SRC_URI[deb1.sha256sum] = "4ea5b9d09449023a30e4d5237b8a69e19d6b3e576e36570818c87a093e2b5eec"
SRC_URI[deb1.sha512sum] = "c8cc95204de73a04c5d31ffa443a879f07e9c4ec053f617e9063e2f80ae20e8fe676585b376b1990dd012397272bed3079b58ef74e5cc7b5d3b981888bac0149"

RDEPENDS = " \
    libc6 \
    libdatrie1 \
    libthai-data \
"

