# This was autogenerated! Do not modify
SUMMARY = "Efficient and performance-portable SIMD wrapper (runtime files)"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "highway"
HOMEPAGE = "https://github.com/google/highway"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/h/highway/libhwy1t64_1.2.0-2+b2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/h/highway/libhwy1t64_1.2.0-2+b2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "177f80e86a547d33588772be06c21e45"
SRC_URI[deb0.sha1sum] = "7f05054b0584a9565550f919cbfb51d6d0cda27e"
SRC_URI[deb0.sha256sum] = "540c4ff28255fbfa89468061b722dfc2b773b0c1ecf163a063202482dea5b119"
SRC_URI[deb0.sha512sum] = "734519bcd80abae17635a8390bfb24018a60a3f49aaded4549b677bc8e8bbdef091524b33e15f5838e37c1cab8a42531e67da42528110371531b84e94153d2a1"
SRC_URI[deb1.md5sum] = "1ca661e780615624caad6c26952fe548"
SRC_URI[deb1.sha1sum] = "ace767eb69c3231e633c00d8058037f514f05943"
SRC_URI[deb1.sha256sum] = "05d6a112f091902db1155b8ebf355e78f92889d97394eef242736ec326199da3"
SRC_URI[deb1.sha512sum] = "edfcc7cde1d0b75a58fbf4f122b9d491cbc8edceae8745e5b3c016d0827aca8a13fa1e80d7e52f126b3d5b39ddbf884e0b86224f580f2a2e0f1aa2281de413a7"

RDEPENDS = " \
    libc6 \
    libgcc-s1 \
    libstdc++6 \
"

RPROVIDES = " \
    libhwy1 \
"
