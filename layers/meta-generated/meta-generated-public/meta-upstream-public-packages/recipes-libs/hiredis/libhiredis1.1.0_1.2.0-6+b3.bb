# This was autogenerated! Do not modify
SUMMARY = "minimalistic C client library for Redis"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "hiredis"
HOMEPAGE = "https://github.com/redis/hiredis"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/h/hiredis/libhiredis1.1.0_1.2.0-6+b3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/h/hiredis/libhiredis1.1.0_1.2.0-6+b3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "7a931c071a4eea39029f7bdd1b37049a"
SRC_URI[deb0.sha1sum] = "2330cc33bc47a9cbf9ba20af609cb129791781ba"
SRC_URI[deb0.sha256sum] = "dae3af5380cb0c12e170271f19d318529331cfa17b5fa47971837b3e2a49bb83"
SRC_URI[deb0.sha512sum] = "3d73af1235b191447393ecd7dab2be73f41a1cfb90e891ea80fa9fa19e1df92a4248dd1fafe4e743d116fd8192c38e963ab1d6466b9e553281ddce305e3ec847"
SRC_URI[deb1.md5sum] = "8b87c11b0a984a3bfbd9d43ba2b8a89d"
SRC_URI[deb1.sha1sum] = "4d68a1217bfccfdd8e54036001ed853bc1a05670"
SRC_URI[deb1.sha256sum] = "e9ca6df21fb5e4234c8bbf994ce72ad41cc25d265b2e09dbf478dc5f0d20ce71"
SRC_URI[deb1.sha512sum] = "74504d52e7bf329eaa25ebcf7b6da770055c4634d6da009f456a64ddf4e5afe2a70a33baf95727a977c7455f9b574103b8dab61503d054663f42befee6af80c3"

RDEPENDS = " \
    libc6 \
    libssl3t64 \
"

