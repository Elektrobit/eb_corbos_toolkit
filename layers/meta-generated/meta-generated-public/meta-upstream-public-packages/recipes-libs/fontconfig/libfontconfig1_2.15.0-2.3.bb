# This was autogenerated! Do not modify
SUMMARY = "generic font configuration library - runtime"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "fontconfig"
HOMEPAGE = "https://www.freedesktop.org/wiki/Software/fontconfig/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/f/fontconfig/libfontconfig1_2.15.0-2.3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/f/fontconfig/libfontconfig1_2.15.0-2.3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "51964bf406139551c59047e6cbdd4940"
SRC_URI[deb0.sha1sum] = "bcd8cee1738cf4727b6705b4c1609641189591e0"
SRC_URI[deb0.sha256sum] = "7ae91ec59857cc8e375eb2bdd371a4a69daea38f7787d06d474a847867d852b1"
SRC_URI[deb0.sha512sum] = "ebd9a9ec9d29b11f2e86a2309ce818bcbba2005fb49efa09ffc9ea442627e9fcd47bdf5f6bcc23a20f99952e6265a7894a6cc65b5b8246ea386599b47fec4d68"
SRC_URI[deb1.md5sum] = "fc0010d61ada9fe7b410b66c74f41eaa"
SRC_URI[deb1.sha1sum] = "7c9ab3453844b67002474d221073824a504a7e9c"
SRC_URI[deb1.sha256sum] = "872781cf62926b68c34a4302a3caae334ff8d4d83a2b2477f8fb454460aadc99"
SRC_URI[deb1.sha512sum] = "1e831220a58a41faf60a7f15dcc9cb9b341793af2c20302318f9cf41d2473d7841205457468fc6514b187434c1dfc932e234c7aee3ff44995c9a161ad1cc46a0"

RDEPENDS = " \
    fontconfig-config \
    libc6 \
    libexpat1 \
    libfreetype6 \
"

RPROVIDES = " \
    libfontconfig \
"
