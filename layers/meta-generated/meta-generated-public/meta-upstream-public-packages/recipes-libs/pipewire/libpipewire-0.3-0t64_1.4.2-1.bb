# This was autogenerated! Do not modify
SUMMARY = "libraries for the PipeWire multimedia server"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "pipewire"
HOMEPAGE = "https://pipewire.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/pipewire/libpipewire-0.3-0t64_1.4.2-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/pipewire/libpipewire-0.3-0t64_1.4.2-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "00f1c36bbce3fa7e3cea34e96bc9d5ea"
SRC_URI[deb0.sha1sum] = "0a1fc8c395792544c86a801cb1353872f4ba90be"
SRC_URI[deb0.sha256sum] = "68522d7dff91b0f759fe58e685e19422bc2bb43dc8d6fd41f025954da09a3d0f"
SRC_URI[deb0.sha512sum] = "320dafd2af6447e5c3552f2469cfbeae3d7504799b15f75b29c5b758e23083cac02afcef6438118670e676a0897acccdcff31f04926f2418c91adf71abb18328"
SRC_URI[deb1.md5sum] = "f4390e045d94930a318dc69368282090"
SRC_URI[deb1.sha1sum] = "ef22259d1f1312741e1407ad6258a0687fcb1c39"
SRC_URI[deb1.sha256sum] = "f25ab475f09ab5ec952f13a2d6b7a870dd5eb8c7806664baf8be9bdee3ae995b"
SRC_URI[deb1.sha512sum] = "93d2619c37cc9c0fdd0f1b8ffebd963a3bf9b833370034a6487a7957be3f4e0e11c471d0c40d95d2fda2423def756b63d85c3194f25dd5cbeae37b7a5c669c51"

RDEPENDS = " \
    libc6 \
    libspa-0.2-modules \
"

RPROVIDES = " \
    libpipewire-0.3-0 \
"
