# This was autogenerated! Do not modify
SUMMARY = "libraries for the PipeWire multimedia server Simple Plugin API - modules"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "pipewire"
HOMEPAGE = "https://pipewire.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/pipewire/libspa-0.2-modules_1.4.2-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/pipewire/libspa-0.2-modules_1.4.2-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "bbb95589b34e6b520075892a576f598c"
SRC_URI[deb0.sha1sum] = "037bd26ef318c89568f56e1b55cdb4d93803e414"
SRC_URI[deb0.sha256sum] = "f559422557a6e98700278d572211a9715638556ac4171aa28076981cfed580d8"
SRC_URI[deb0.sha512sum] = "3a79981b7ad83ddae8d69cca9c8387707163ca0ec1fecb972a2791f1fd00b49431de8e6e066684f4be4cfc3997637c2a47a6d658044229a618e5c9f6bb1a7b38"
SRC_URI[deb1.md5sum] = "65b897cf24916279a58310532dd3e656"
SRC_URI[deb1.sha1sum] = "352cb2aff13b49fad167974ee359c4b5108e76a4"
SRC_URI[deb1.sha256sum] = "b13c1955882ea689f9135bf45c020a364d3cba2d2ed69251827b5c6abd41d4b7"
SRC_URI[deb1.sha512sum] = "8e4896becd515525d77653e49563f536d507a9659b05b8b277b4a3a3a4854b3f75264d2277aef6e71b3b4ed98d5fea9a8d838c151fdf78e1aaabf95a2db900cd"

RDEPENDS = " \
    libasound2t64 \
    libc6 \
    libdbus-1-3 \
    libebur128-1 \
    libfftw3-single3 \
    libgcc-s1 \
    liblilv-0-0 \
    libmysofa1 \
    libsndfile1 \
    libstdc++6 \
    libsystemd0 \
    libudev1 \
    libwebrtc-audio-processing-1-3 \
"

