# This was autogenerated! Do not modify
SUMMARY = "Runtime library for OpenJade group's SP suite"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "opensp"
HOMEPAGE = ""

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/o/opensp/libosp5_1.5.2-15.2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/o/opensp/libosp5_1.5.2-15.2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "41124a1eaa9d06838d72aadd82abc50c"
SRC_URI[deb0.sha1sum] = "e527ef07c11c2cf588d9f9504cb56fed0cddb5af"
SRC_URI[deb0.sha256sum] = "63a758272a515abf0140069997e8d9023f2bf97fdcfd30d6d3b126681d4f26b6"
SRC_URI[deb0.sha512sum] = "a4d56562eb02d94525d209956311a89d46f24ae929c9eb345573859c7b64c35ec3815a6b9ea7614321040f00307dd310af65c76ba2b14cae00aca01ed688a1e3"
SRC_URI[deb1.md5sum] = "b63f0552d2fec100d2822b9e091fbd4a"
SRC_URI[deb1.sha1sum] = "83ad6c13d8d1fd9f0414ef7c52cb7a8725870e2e"
SRC_URI[deb1.sha256sum] = "534c21ee46d5fe10364d14f7e450631d703976786f16dc353f464c72511b42cc"
SRC_URI[deb1.sha512sum] = "146c96de2042259155c60a0f34d9890e9c1465d08413321b2b4646b9ab19fb91a2ac82d88aa187518e3087dfe7c88ed5831205406b1f3b2188309e00cd803270"

RDEPENDS = " \
    libc6 \
    libgcc-s1 \
    libstdc++6 \
"

