# This was autogenerated! Do not modify
SUMMARY = "replacement for GNU Pth using system threads"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "npth"
HOMEPAGE = "https://www.gnupg.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/n/npth/libnpth0t64_1.8-3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/n/npth/libnpth0t64_1.8-3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "b4b8799e53138b6d860f78e5b57cdf04"
SRC_URI[deb0.sha1sum] = "c0208fea2539540ed2ff1a1e89ec3b19d2618136"
SRC_URI[deb0.sha256sum] = "37d489976ef91ca0165a7789a7a7ac5923ee3cfadf316ac3e87582e15d0523d7"
SRC_URI[deb0.sha512sum] = "751a91513f2acc27eccdc37e29155efb7e416f4572e18ba92b33d826cd4efc279a876f725d7c3afb0ddd8cca69139379d26b3360698a7b99e7178472b43df1db"
SRC_URI[deb1.md5sum] = "03913e87fcd8612a6ca136170496d547"
SRC_URI[deb1.sha1sum] = "ee58a90bb7f1a7e15ca2f93ba6976b20c7df1e20"
SRC_URI[deb1.sha256sum] = "68bca0187b0121e25706fc79cee63233168f4b4acbfa1c3f34f0880be6c16a5c"
SRC_URI[deb1.sha512sum] = "63f847e3cee19d9a56f291a83de3d693851d8a799c0854bd8d89b91f9164273c70c393032a4ff9b4d3b6f03f82f736b3d510e1d803cae86e5234c14d2b8f6f8a"

RDEPENDS = " \
    libc6 \
"

RPROVIDES = " \
    libnpth0 \
"
