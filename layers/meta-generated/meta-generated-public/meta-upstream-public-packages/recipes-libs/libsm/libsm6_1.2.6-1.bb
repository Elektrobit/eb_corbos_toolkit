# This was autogenerated! Do not modify
SUMMARY = "X11 Session Management library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libsm"
HOMEPAGE = "https://www.x.org"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libs/libsm/libsm6_1.2.6-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libs/libsm/libsm6_1.2.6-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "1c06ea44170b1e8ced12ea23d9c89d5c"
SRC_URI[deb0.sha1sum] = "48405db7df8150615f1ba1f4bd3b160ac7f33d18"
SRC_URI[deb0.sha256sum] = "03038b3002e6f44322554e335d60d8ff87acfcf2e21c904b6866610a9913ee00"
SRC_URI[deb0.sha512sum] = "33ea65bea25a9a4a968c66dcf6a9499643cf92c43e82abd1a7ce06544912e275458be1ab4978125567cd057eb76a447cd440364aa0b3b689cc469933fcbe5a7e"
SRC_URI[deb1.md5sum] = "ba1b7325f62aa85b319f38a0f5ac7da9"
SRC_URI[deb1.sha1sum] = "82dd5d4608ec93b25819550c7583df5b2d1b1484"
SRC_URI[deb1.sha256sum] = "4906619bbec923da6808cb7e4e817a7667d13cd43bc7d98c77702a03bb103f42"
SRC_URI[deb1.sha512sum] = "2575def3d81c06785a81617919d3918aa439abe1eae50aa7560e34004dc794ab91088e4b55d88421ae78cfbbdb0552674f71f4b90c77c050da9b6ca8731b7837"

RDEPENDS = " \
    libc6 \
    libice6 \
    libuuid1 \
"

