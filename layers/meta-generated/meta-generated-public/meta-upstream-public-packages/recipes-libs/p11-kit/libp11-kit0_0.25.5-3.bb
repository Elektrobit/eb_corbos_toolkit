# This was autogenerated! Do not modify
SUMMARY = "library for loading and coordinating access to PKCS#11 modules - runtime"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "p11-kit"
HOMEPAGE = "https://p11-glue.github.io/p11-glue/p11-kit.html"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/p11-kit/libp11-kit0_0.25.5-3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/p11-kit/libp11-kit0_0.25.5-3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "d27fc7a8b7a7baac77b087b96d69d143"
SRC_URI[deb0.sha1sum] = "b04bc908531c41504c4197e2e1dc4fca6e820b4e"
SRC_URI[deb0.sha256sum] = "784bf2063e166c8bc851a32623b74ebd85c499043a9d57c5bbd64fa63447f45a"
SRC_URI[deb0.sha512sum] = "eda7e5f3420520e8159726afe2078f5286c50e24028d8f063edb09d34aa702f0f9f0d9d25c21502e2a4690d7b872a1edf04b375ef4f9b14dfc753fb7c4309912"
SRC_URI[deb1.md5sum] = "dbdc6253bb9c19bfbebfe3a6ec145153"
SRC_URI[deb1.sha1sum] = "004d7654aee74c5b3f4944cd8996657bbd4487ec"
SRC_URI[deb1.sha256sum] = "78bfc746e68a5217e845f488f69100ed89d10c8886fbd3ffce937acb6a7d88fb"
SRC_URI[deb1.sha512sum] = "3d4595c9dcfea30e56aac08c97ca125bc5e532b94fcc8fb6cfe83545c4368859d962d994b6e882779918f29f2cce4df08ee8c7a0acaddb3d3892fd82624ad13f"

RDEPENDS = " \
    libc6 \
    libffi8 \
"

