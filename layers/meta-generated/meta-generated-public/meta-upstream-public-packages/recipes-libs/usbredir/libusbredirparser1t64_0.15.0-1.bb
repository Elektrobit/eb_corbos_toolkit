# This was autogenerated! Do not modify
SUMMARY = "Parser for the usbredir protocol (runtime)"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "usbredir"
HOMEPAGE = "https://www.spice-space.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/u/usbredir/libusbredirparser1t64_0.15.0-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/u/usbredir/libusbredirparser1t64_0.15.0-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "05e681a0482feb69a980c9b37bf1e2df"
SRC_URI[deb0.sha1sum] = "c1ea996a36e23b141f2ea771c12457eacd51db9d"
SRC_URI[deb0.sha256sum] = "4b039802dac140bae5a6f3fb6341eeeb9ea8c3e4d7b95ad36a07a8c28572f177"
SRC_URI[deb0.sha512sum] = "acfa3744f1c7d4ae4d5d933abaf1097fe0905f0671cdf87205c433bc4e5b0f0ba54ace40845a452891450b2f22bb255e5f6b156534fb2f12efa4dd4508dd64e9"
SRC_URI[deb1.md5sum] = "34154007e2eb246b95cb386ba57d832d"
SRC_URI[deb1.sha1sum] = "0c33be385574b16be7203fb3f21ff71653d4c412"
SRC_URI[deb1.sha256sum] = "72a2674abb3dcf56519e93a8fa1e7f6907114ce772a7876ed67e5878dad12d7a"
SRC_URI[deb1.sha512sum] = "5da29717dd96af3bfcf3e02e9632c5bb4516fea1e64765590aa15e0b191113920a9bfa6cdf220a94c674930ea18d3e45abc9c2ef451b5d9e2d3c635df36fb7ed"

RDEPENDS = " \
    libc6 \
"

RPROVIDES = " \
    libusbredirparser1 \
"
