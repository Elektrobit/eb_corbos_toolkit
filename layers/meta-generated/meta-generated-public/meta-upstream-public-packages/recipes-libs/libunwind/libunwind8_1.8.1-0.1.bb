# This was autogenerated! Do not modify
SUMMARY = "library to determine the call-chain of a program - runtime"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libunwind"
HOMEPAGE = "https://github.com/libunwind/libunwind"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libu/libunwind/libunwind8_1.8.1-0.1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libu/libunwind/libunwind8_1.8.1-0.1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "4d8d51711639eacfd68d0ef51f0b5688"
SRC_URI[deb0.sha1sum] = "c645bddb3311a2231f40e9cb18a6be25c87821c6"
SRC_URI[deb0.sha256sum] = "db21a86dd05c93413f0ef36282a9c64d32410d240f332273a53be1408bec1f62"
SRC_URI[deb0.sha512sum] = "15c8da54715ce0948c7947692c7c1f4d7326ccae14325fd8fa1526f1a89595d01c5b686d9c6d531397271b2b42f367973043eb178beb099d5b6f5e62bad655c8"
SRC_URI[deb1.md5sum] = "04aa8c42ca413f463a602920750e34d8"
SRC_URI[deb1.sha1sum] = "1c40c16e680605cb17e011b37cded934d532da12"
SRC_URI[deb1.sha256sum] = "bcf2d49ba4226aa321816ddbbfb3f3dde09594b814bd7afa81191a2d583bae95"
SRC_URI[deb1.sha512sum] = "9b2ba275a1f6ab772fa9fa702a510f4fa3b8628a19342d3448b36c5e7fe13922e7916b2a488273eb1a9124690d260fe33d3c258ab58a130a76cd4a01c6c2e42d"

RDEPENDS = " \
    libc6 \
    liblzma5 \
"

