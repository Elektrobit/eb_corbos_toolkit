# This was autogenerated! Do not modify
SUMMARY = "Opus codec runtime library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "opus"
HOMEPAGE = "http://www.opus-codec.org"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/o/opus/libopus0_1.5.2-2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/o/opus/libopus0_1.5.2-2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "938057fb1163ba46da50f7f7c5efd5a6"
SRC_URI[deb0.sha1sum] = "fa00ba0ccf54199178ff2c010b84c63fb77df676"
SRC_URI[deb0.sha256sum] = "794056db33d71b2ac4bd8b5a4eb23b627bcb8a49d123c33b6e841a996253a067"
SRC_URI[deb0.sha512sum] = "5793146a91029ec40bb054fa5642c345f79d56b78f665fc0f998bde19945d05dae25e7fc90bebe3894e29a9fc129d25758ef96bc0ffe075e11c9af49e6eff9b2"
SRC_URI[deb1.md5sum] = "c5f122d1342e1aeb837d17e00b81f626"
SRC_URI[deb1.sha1sum] = "08e6c9b796e5ac4354b3d199216a0c6347e8fa54"
SRC_URI[deb1.sha256sum] = "1d980e8a4717074805a98dbe07671cb3bee068c25709315f3de836980c629836"
SRC_URI[deb1.sha512sum] = "8d47221ee3c3e6816a3bbf62b841978121eb8574aa524ee690372e90b5002d81faeb9d5d57e095825118340aab78355664e653b514a9cd832405fece8753421c"

RDEPENDS = " \
    libc6 \
"

