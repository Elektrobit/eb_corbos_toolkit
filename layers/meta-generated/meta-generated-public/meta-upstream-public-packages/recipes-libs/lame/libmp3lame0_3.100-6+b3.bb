# This was autogenerated! Do not modify
SUMMARY = "MP3 encoding library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "lame"
HOMEPAGE = "https://lame.sourceforge.io/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/l/lame/libmp3lame0_3.100-6+b3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/l/lame/libmp3lame0_3.100-6+b3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "488959c443889726e46be619e0bcb2d8"
SRC_URI[deb0.sha1sum] = "a946f12a662cf33b4f063f61352bb5367a0c7454"
SRC_URI[deb0.sha256sum] = "3867319c9fbbc8cc25f2d1dc1d75d13548c84c37fa709c1ac9ca02ac051b63ab"
SRC_URI[deb0.sha512sum] = "b242287b7610e1165b4107099d83fbb05f97c5b2f4a01fa61ca17ba67fc1b9257890c0a839b31e38833d8a5ec1a07a9a8e7ba6d9c21988e06d92e7f32881f05a"
SRC_URI[deb1.md5sum] = "0389e28177a4b66a441d4c6c2d3b2d86"
SRC_URI[deb1.sha1sum] = "0a4198159fd2a179e97aa6a867d44018ce57d42d"
SRC_URI[deb1.sha256sum] = "ed3563722129ffa4def03b7af0b589fa20eef972bdcc4599202ddb1ac654c58e"
SRC_URI[deb1.sha512sum] = "56f921012bb4210a49750d304200974c99266ea80f12ec62713dd408301bf034584b6e22f15263e59e71e44ba41a3fbeee375e0e5a68d4cd5b88f87513814fb6"

RDEPENDS = " \
    libc6 \
"

