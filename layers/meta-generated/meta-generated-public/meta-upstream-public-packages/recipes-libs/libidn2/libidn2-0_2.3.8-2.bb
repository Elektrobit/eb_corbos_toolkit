# This was autogenerated! Do not modify
SUMMARY = "Internationalized domain names (IDNA2008/TR46) library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libidn2"
HOMEPAGE = "https://www.gnu.org/software/libidn/#libidn2"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libi/libidn2/libidn2-0_2.3.8-2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libi/libidn2/libidn2-0_2.3.8-2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "c12f652b328832486b6992d355e52c29"
SRC_URI[deb0.sha1sum] = "3c7a11b95bf17674f57763834134ebd4214f87ff"
SRC_URI[deb0.sha256sum] = "90b039bcdc4578f8e1c4935adf8dbb525e36a164deefdbbb8c45bac347d48278"
SRC_URI[deb0.sha512sum] = "0916f93e1f9a5b52aee44413db73e2f56a45cf3bbde4f6900dc1a5e8643704fb887ecdd464da4d1838526ff44b19abf82d869b8a5ed1234b3c4d9f1cd3d796af"
SRC_URI[deb1.md5sum] = "47086d7eaf7481bfca77080316019e66"
SRC_URI[deb1.sha1sum] = "9ee3325aae6efd56bd85e55eb6d8968e8fcda1bc"
SRC_URI[deb1.sha256sum] = "d2e5cef812f15db1eeb35f0a193158ee102a9e94284036c0e293521f2761d2d7"
SRC_URI[deb1.sha512sum] = "b426407dcbe6c344a4358b9ff784dc474c781c6c8f1b7121517e13435eea6380558223ea603602bfba9d92ce385e3a867a8403140ca63e54bad06ff44f43639e"

RDEPENDS = " \
    libc6 \
    libunistring5 \
"

