# This was autogenerated! Do not modify
SUMMARY = "Library of Optimized Inner Loops Runtime Compiler"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "orc"
HOMEPAGE = "https://cgit.freedesktop.org/gstreamer/orc"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/o/orc/liborc-0.4-0t64_0.4.41-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/o/orc/liborc-0.4-0t64_0.4.41-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "eb8cb73a7da1c4476fb28830c1e1c627"
SRC_URI[deb0.sha1sum] = "dfafcdfe38f223c4adb7f6d697855818e2bcfaca"
SRC_URI[deb0.sha256sum] = "5b9afe78be0dd71399c0d4d7e5f26beb6ddf207279997942d8280be1b20bd58c"
SRC_URI[deb0.sha512sum] = "1841f5b4ce9253fd66bcb6f774a6ec17820f1de60d17c374129df7c92f25b6d7958895359eece76ebac8917ddeca792c6dfec5b06434a22de540ac11a222c129"
SRC_URI[deb1.md5sum] = "61018c3b853c8200e5a5d5a46c137ec0"
SRC_URI[deb1.sha1sum] = "42f53fa3f7ba374ec6176e4931ebd4aa3f3a721a"
SRC_URI[deb1.sha256sum] = "e69ee68606246657ff19bfe13058a9aef177e686b97638728f9e0e911af07680"
SRC_URI[deb1.sha512sum] = "54aa11b19a8ba2c869b15117b57cc934897afafad7876ab45d5bab1ba600bf4b76aa52e28d23b22b39a427fc2fedbdc06f0e94c42c3dbc19c57a02589201344a"

RDEPENDS = " \
    libc6 \
"

RPROVIDES = " \
    liborc-0.4-0 \
"
