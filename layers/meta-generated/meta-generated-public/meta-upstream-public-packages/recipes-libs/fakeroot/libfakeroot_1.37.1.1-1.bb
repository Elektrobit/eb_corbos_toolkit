# This was autogenerated! Do not modify
SUMMARY = "tool for simulating superuser privileges - shared libraries"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "fakeroot"
HOMEPAGE = ""

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/f/fakeroot/libfakeroot_1.37.1.1-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/f/fakeroot/libfakeroot_1.37.1.1-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "0e70c4e62803ed408eabfd4b5925d08b"
SRC_URI[deb0.sha1sum] = "b27b7a07f5b9d699b716a5559960fb934e561f55"
SRC_URI[deb0.sha256sum] = "9fe004890f90884c23c24c4fb7eaf5afd55b0b79f3bc05c498a9f54191098a81"
SRC_URI[deb0.sha512sum] = "33e1201567e36ba0e564c8b032fa354245c882b494d2a26f033ffc5aceebae86d812d2f169b89660769a0f89b6eddb719007f42a00d65bd31dd2b35caba5f833"
SRC_URI[deb1.md5sum] = "2ef73c4cb7ccb99fc97aef305c34825f"
SRC_URI[deb1.sha1sum] = "a4fd5d0771f727da9818e9d5708d6ce6fc1bab14"
SRC_URI[deb1.sha256sum] = "418dd0c1c6c45011476f66da625f72b6cf72b45dcd838b631c2c7ed1ba0fb09c"
SRC_URI[deb1.sha512sum] = "9c069c16f3334e808d1fbac65349de599188823a474666aa03f0675ef1e081c94486c1fbb0bb6b4ccf008b7121cb70b11822a53dc879da84b552a5545f4fdf7d"

RDEPENDS = " \
    libc6 \
"

