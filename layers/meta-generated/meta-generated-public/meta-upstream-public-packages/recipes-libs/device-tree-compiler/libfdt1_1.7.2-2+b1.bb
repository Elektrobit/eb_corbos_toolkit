# This was autogenerated! Do not modify
SUMMARY = "Flat Device Trees manipulation library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "device-tree-compiler"
HOMEPAGE = "https://git.kernel.org/cgit/utils/dtc/dtc.git"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/d/device-tree-compiler/libfdt1_1.7.2-2+b1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/d/device-tree-compiler/libfdt1_1.7.2-2+b1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "f942e1479931b2ef531a394dc38d1262"
SRC_URI[deb0.sha1sum] = "8b4154815fd8f84748ba38349a3feebf6be045c9"
SRC_URI[deb0.sha256sum] = "8e37034d7864807ae2063efcc82fc79aad59069546212e6e0908ed67f9f7e107"
SRC_URI[deb0.sha512sum] = "f4e94c4a124dbc765f4ad0311ed6e236b2e4ca0e2bc567c40736a4d0a43808b5ece5969d2d56475e7d217d3e9b6125696d587e4a334c39911dec1c99cc61233c"
SRC_URI[deb1.md5sum] = "be18ae48fc1d2710fcc9bdbd147042a3"
SRC_URI[deb1.sha1sum] = "6da56c583f1f97c4e5d420b1c0ae2b0dc5327dc9"
SRC_URI[deb1.sha256sum] = "43b3435ff8d67a3cbd91f88bdeffcb147f7f5da61fba50cf004505f03025ae1e"
SRC_URI[deb1.sha512sum] = "387432979c1c92069ec5d54c1d95c6957c0acc3dae12802975958332e61f2f3b3b03b58e73fc09db5ded26b7f4067f197358bd515781c61c2a5c2346f3e50f06"

RDEPENDS = " \
    libc6 \
"

