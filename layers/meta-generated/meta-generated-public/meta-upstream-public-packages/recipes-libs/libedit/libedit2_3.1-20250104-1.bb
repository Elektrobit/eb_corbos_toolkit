# This was autogenerated! Do not modify
SUMMARY = "BSD editline and history libraries"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libedit"
HOMEPAGE = "https://www.thrysoee.dk/editline/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libe/libedit/libedit2_3.1-20250104-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libe/libedit/libedit2_3.1-20250104-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "fd7269ccbfb9da8080f776e1d96823c0"
SRC_URI[deb0.sha1sum] = "03ef2da39167fb6105479d165caab156b3535297"
SRC_URI[deb0.sha256sum] = "b002ea172b9c1e34a67bc497c523c67bb74c3f0a4e98113cb083990a1f1d3bfe"
SRC_URI[deb0.sha512sum] = "7f3eff57057651fa2f553d83c553bdf2c598f99b6ed2634c5a79bb22ae8dd46da531c22aa5221a292b8a5d4e7cd68773276c6e9a363a2f5059168d6007ec7d86"
SRC_URI[deb1.md5sum] = "2ed86497112d630d9973a4041d1e7af9"
SRC_URI[deb1.sha1sum] = "15b1682c4cc74efa277bd7f8793a26f17ed48f24"
SRC_URI[deb1.sha256sum] = "496c31df89fac9cb7e98102fcc21daf887376dcd9914f6322c86dd5bd4360ff1"
SRC_URI[deb1.sha512sum] = "20ad9abf2bb27f1876f488abffbcfb5f0342a4d54b254268a1240e7dd82bda79a97350ff620891923fbd1f950e6d985515f65d163014e926d99f982e14ce7df9"

RDEPENDS = " \
    libbsd0 \
    libc6 \
    libtinfo6 \
"

