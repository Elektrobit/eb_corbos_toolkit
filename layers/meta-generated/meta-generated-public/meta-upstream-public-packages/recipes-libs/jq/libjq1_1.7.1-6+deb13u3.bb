# This was autogenerated! Do not modify
SUMMARY = "lightweight and flexible command-line JSON processor - shared library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "jq"
HOMEPAGE = "https://jqlang.github.io/jq"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/j/jq/libjq1_1.7.1-6+deb13u3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/j/jq/libjq1_1.7.1-6+deb13u3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "18ccb89299b075ab72607c7efd520854"
SRC_URI[deb0.sha1sum] = "8f552251072a73c57a210b45a06c3f8914270747"
SRC_URI[deb0.sha256sum] = "62444043e4b8f21a5154e5b7084d85db00da509e163c52a950bb8aeb75e4012e"
SRC_URI[deb0.sha512sum] = "0de41dd6fcad1c3871cb5c26f1c09f1ab4b054567e2dfae9fb31b82b5c9ea724df882f76c0ca898b2dedcf7224f5067588be2376581c9117f94b53a874b0eaf8"
SRC_URI[deb1.md5sum] = "cd8ff020372c324cc1bd52f1bd0c102e"
SRC_URI[deb1.sha1sum] = "b175548bde68584747c65be140eb3f742d6fdfba"
SRC_URI[deb1.sha256sum] = "b8bf914f7106442f4a42db26867750b7fe031d11b2abff944822872386371ddf"
SRC_URI[deb1.sha512sum] = "f3eb1656c9ef99dc4ac75287d9cc7a0197c1b2d1797f5f992916490c99a9b2193940a0370d89f5f60324fddbadd9a8633d2cb9fdd4451a6bd610a3df45a71c42"

RDEPENDS = " \
    libc6 \
    libonig5 \
"

