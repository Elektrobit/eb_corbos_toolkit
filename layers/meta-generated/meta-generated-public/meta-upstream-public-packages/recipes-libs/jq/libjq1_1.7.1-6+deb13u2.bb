# This was autogenerated! Do not modify
SUMMARY = "lightweight and flexible command-line JSON processor - shared library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "jq"
HOMEPAGE = "https://jqlang.github.io/jq"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/j/jq/libjq1_1.7.1-6+deb13u2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/j/jq/libjq1_1.7.1-6+deb13u2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "7650acda32234980f69342aa111bddb5"
SRC_URI[deb0.sha1sum] = "b8b613de6336c793442ca724edcb30be97ee3de0"
SRC_URI[deb0.sha256sum] = "140ac37e4b35370c3f34c95407cba75b35570e0be4bb9eebbf40bd72d182257c"
SRC_URI[deb0.sha512sum] = "d92d3b9cb79a4fc50ceee293a740ea406ffc8e855bd6995dfa9f81347a6020b940487c611ce64344b0a917da7dc7530e112d4e6ea5dc0a24a773ecd900f017c3"
SRC_URI[deb1.md5sum] = "376ca7634b1a05b5b426373117aa3b72"
SRC_URI[deb1.sha1sum] = "cf0d79bfe53388808e6db954cf45249f4883bf25"
SRC_URI[deb1.sha256sum] = "8ab0ac37a8f068af4139d57e0fb856b4349403d9ed5b8005c686ffffefa08544"
SRC_URI[deb1.sha512sum] = "927038ab34f25fdad174024eaba19a9380095bd8e89886558644ec6642ba95e18518415572228dbbcda4602523eab78f623f9984272e5b76a81a3522b7a5aa41"

RDEPENDS = " \
    libc6 \
    libonig5 \
"

