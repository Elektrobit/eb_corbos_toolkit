# This was autogenerated! Do not modify
SUMMARY = "X C Binding, randr extension"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libxcb"
HOMEPAGE = "https://xcb.freedesktop.org"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libx/libxcb/libxcb-randr0_1.17.0-2+b1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libx/libxcb/libxcb-randr0_1.17.0-2+b1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "f85b0abba4ba40ab6cc4e900ed6ae436"
SRC_URI[deb0.sha1sum] = "09a9641fe65abdc88ea9dafd70e91348b3fecaa2"
SRC_URI[deb0.sha256sum] = "f5d9fe5fdf797918f81f0abf6cfd4270bd54659540cddb4da709ab7154523214"
SRC_URI[deb0.sha512sum] = "1def1e56376f144e1b649edf155d01d4eb7337e9e84d9a4888c509e9f186b618dbf263c6cd6730ac44975483c9079d50668611cd641388e3e43f57430a3c20bf"
SRC_URI[deb1.md5sum] = "e2c98e604e2ac625bf5ff473d93e1b35"
SRC_URI[deb1.sha1sum] = "dde9c2864a43e61438443e149b16a5498355464f"
SRC_URI[deb1.sha256sum] = "dbeb78d1d032959fe65548758ab12bfc6bb5919ec2984c3d871496b52aef929a"
SRC_URI[deb1.sha512sum] = "06d481d8b279665a7007c5b3c5b687196658b02b7ef2623e96387e8c95d3611ea43be47764ad5e542b780635c8c80a2647d529b638046801617099bbbbf1f7a2"

RDEPENDS = " \
    libc6 \
    libxcb1 \
"

