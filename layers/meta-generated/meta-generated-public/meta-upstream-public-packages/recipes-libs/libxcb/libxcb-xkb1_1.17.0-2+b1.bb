# This was autogenerated! Do not modify
SUMMARY = "X C Binding, XKEYBOARD extension"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libxcb"
HOMEPAGE = "https://xcb.freedesktop.org"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libx/libxcb/libxcb-xkb1_1.17.0-2+b1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libx/libxcb/libxcb-xkb1_1.17.0-2+b1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "4bd3fc21b9f6bfa6335e0f836b43f193"
SRC_URI[deb0.sha1sum] = "7f2038d90c6e6ecee04b34dbf496cdaa4318fbf7"
SRC_URI[deb0.sha256sum] = "a46b8d860fbff32c8021dac6036d83859c24ad8700cd1b977cda116d37a2dd35"
SRC_URI[deb0.sha512sum] = "2f41106ff36f7b78104041d2fc6a7ab39d45fdc32c8fb17832cfaef67648e42214a4531bac3e82ea523a471b0367029a620a42420bad46b2b66af5dad018d3e0"
SRC_URI[deb1.md5sum] = "751f1a184abe67266cfd7430e5f415c7"
SRC_URI[deb1.sha1sum] = "edd85b1f289a1a3da820d724c2dc34541a37dd6a"
SRC_URI[deb1.sha256sum] = "739b023ad82b4c9ac2c6cc9e6cc8602a17a05f7f5387d45a5a60eafdc17bf0e5"
SRC_URI[deb1.sha512sum] = "3a29ebc806f08e796149a6abc1853c0d5a74ea63b5837c1f8998da34727b21b8db620952be088038fdf38f2d06643e881eaa87e93b3a6b773627c4b6eb52a962"

RDEPENDS = " \
    libc6 \
    libxcb1 \
"

