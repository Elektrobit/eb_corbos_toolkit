# This was autogenerated! Do not modify
SUMMARY = "X C Binding, glx extension"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libxcb"
HOMEPAGE = "https://xcb.freedesktop.org"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libx/libxcb/libxcb-glx0_1.17.0-2+b1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libx/libxcb/libxcb-glx0_1.17.0-2+b1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "7be8d227e8bba4a66b15072095b5c350"
SRC_URI[deb0.sha1sum] = "6a56ed108b1faa7fd833a024ba31eded84b43dd4"
SRC_URI[deb0.sha256sum] = "cc59a3fa1c4ce376c3a32798179950810bd7b9be9a35bc76de1f5b5e7cc3925e"
SRC_URI[deb0.sha512sum] = "91b6c8ce9c79946acbd5ed8f9f671b001bd1073b0784d50b254f46d92744a8f9969f3cdb3513793506a9a244d09c219517e2c637a25a7d0faf0262e417293619"
SRC_URI[deb1.md5sum] = "82939b5ccd4001341c2968e9cf0aadbe"
SRC_URI[deb1.sha1sum] = "a9855aa5a99a42fb91ea9482590488745c9a0c96"
SRC_URI[deb1.sha256sum] = "a0d96ab5faea8fa1f3e095d6236597622a6b763f061f8f9fa23b77733608fdbc"
SRC_URI[deb1.sha512sum] = "8ef0a40ef2ab3404f6ffc943a5e80888175206dd0ac561ab6afc7309e42b52e6b280136b2ce90d3ea0511551c55604127892323a0ff8335833437f446569506e"

RDEPENDS = " \
    libc6 \
    libxcb1 \
"

