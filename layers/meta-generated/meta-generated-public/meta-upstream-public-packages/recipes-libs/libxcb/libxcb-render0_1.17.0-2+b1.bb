# This was autogenerated! Do not modify
SUMMARY = "X C Binding, render extension"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libxcb"
HOMEPAGE = "https://xcb.freedesktop.org"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libx/libxcb/libxcb-render0_1.17.0-2+b1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libx/libxcb/libxcb-render0_1.17.0-2+b1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "0a56f7419e9492e35132dea644873a13"
SRC_URI[deb0.sha1sum] = "94694566461cb64aaa0dd2bfa8020958a5ec0a9e"
SRC_URI[deb0.sha256sum] = "7f6e36978e0f70a590fbad4042a692c70b50ca7cbcdc53fa7e9d9ab87933acc6"
SRC_URI[deb0.sha512sum] = "fee98e5d075609b37291321c75f51687a21db2c8f0d744978180352286cb3a6aa7a913bf796a59abf166d1ed371587713f5a47e52e1e2c1b49ac6340b5bab5db"
SRC_URI[deb1.md5sum] = "a2d883b8a3ab6f9637fb851ac293bde6"
SRC_URI[deb1.sha1sum] = "676542e987e4de116e1088ea6472a26a3a5e5717"
SRC_URI[deb1.sha256sum] = "7d6faf0afad0b27a047bbf320bf80999e94b7e6a0f73e42069e8b08958910466"
SRC_URI[deb1.sha512sum] = "410a434f33877e98cb5811645256ebfd6428b1980051f246d4a67a2ef3d37138cec93ca4931b09ec7896eb7a5038bc70a59e9a5e7752cc78772bc6ccf08e8030"

RDEPENDS = " \
    libc6 \
    libxcb1 \
"

