# This was autogenerated! Do not modify
SUMMARY = "X C Binding, shape extension"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libxcb"
HOMEPAGE = "https://xcb.freedesktop.org"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libx/libxcb/libxcb-shape0_1.17.0-2+b1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libx/libxcb/libxcb-shape0_1.17.0-2+b1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "8e4a29c6a554d6d139873280b98d37a4"
SRC_URI[deb0.sha1sum] = "ee833cefcf6527328396ad6d8a6542965bf22f57"
SRC_URI[deb0.sha256sum] = "eb94a643d66714929053e78ff8f38a90ce8af4ed854e3cbca0b14f8bbccc7bfc"
SRC_URI[deb0.sha512sum] = "bbde85b2b61de7e3c372341ed1571eb1aedc0b89ebdb7c1f16a321c9e8d4d7a335f7e053e5acd1252e67c338c2daff7560edaded9730e33315f6bc563b89ccb9"
SRC_URI[deb1.md5sum] = "2e5f43bbc58d9d7e723cfd117907e3b6"
SRC_URI[deb1.sha1sum] = "8da826022c0754cdfa8703a3feff793b45f1ab1a"
SRC_URI[deb1.sha256sum] = "49f24031f68b9188524954fd1cc237d7cbfe9392d91624cef88d06be13c8075f"
SRC_URI[deb1.sha512sum] = "1e23c75631bebc499e77e0bef1acf82d82491a7d954d6925069c8f941f935662290c6d15a94056950576a8f294b10710937a7f70c1f906a8ef54306fbd88adbb"

RDEPENDS = " \
    libc6 \
    libxcb1 \
"

