# This was autogenerated! Do not modify
SUMMARY = "X C Binding"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libxcb"
HOMEPAGE = "https://xcb.freedesktop.org"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libx/libxcb/libxcb1_1.17.0-2+b1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libx/libxcb/libxcb1_1.17.0-2+b1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "ab87e347ccb5ae730863b6989ea47b34"
SRC_URI[deb0.sha1sum] = "fc9d1247247dd8d4e0e231b26ff01fe7509a55f1"
SRC_URI[deb0.sha256sum] = "5c222a72d11b866447da31693254f738430726e3e065a384e82687b2fd2f978b"
SRC_URI[deb0.sha512sum] = "84295eec08bbd8bf31b8f9d02dc97e64bb6e45dfc83f6cba8f1e2890ea5aad478049bead57d233cf4794b8535edd7d76fea4d9f1d08fc142bd4337ef87d9e669"
SRC_URI[deb1.md5sum] = "427137589309436091d5892a97461463"
SRC_URI[deb1.sha1sum] = "e966957e4699677442fcae8914b375b653164f02"
SRC_URI[deb1.sha256sum] = "d0178198e80ed4cacdececabe2c112ec88c7a9258cc11a55b8e267ab14a90d82"
SRC_URI[deb1.sha512sum] = "7a40df25c0f6bcca2ee1a68c5747648c808e4ab7539f75f19e4f9f350a19a39dc6bb3d35ec7bb9a84e1d5070539a17fc4c931afb0d0bcdc65521c0c9a8d4cf7c"

RDEPENDS = " \
    libc6 \
    libxau6 \
    libxdmcp6 \
"

