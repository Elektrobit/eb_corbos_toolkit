# This was autogenerated! Do not modify
SUMMARY = "X C Binding, shm extension"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libxcb"
HOMEPAGE = "https://xcb.freedesktop.org"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libx/libxcb/libxcb-shm0_1.17.0-2+b1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libx/libxcb/libxcb-shm0_1.17.0-2+b1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "2cd4bb649ed04718953d9edee0746d09"
SRC_URI[deb0.sha1sum] = "4bddb4aed86342c5147f99fd72ce1eb167b8dd68"
SRC_URI[deb0.sha256sum] = "d1777a813f484e89f3dcaadd1d5f2b1a13e9313b6bf70eded16d8ce743208fef"
SRC_URI[deb0.sha512sum] = "2cc82c1dcc4188646976cc16125dae452ec7a933b0747131892d09987289926ddd954eb3657b0b3f26c79175d22fe4ef28396171114bbc3c47174fe1f0405051"
SRC_URI[deb1.md5sum] = "fefb93ceb48601e3902ee057811f4cc6"
SRC_URI[deb1.sha1sum] = "e1b950f41398e3d562a13ff456b19065c2581589"
SRC_URI[deb1.sha256sum] = "e9e871dc5d2f9265eb5d3028f0d0545cb6f8b748a68997b4c43f5a9416c7ead7"
SRC_URI[deb1.sha512sum] = "95675d162fbf5b426da01b1770629a9d5ce7c61f88f1d99adceed41f9c850c952ee163e4a7880b1c0bf53e070a811a25dc0e60d5164e3994e03fe137a0bcd918"

RDEPENDS = " \
    libc6 \
    libxcb1 \
"

