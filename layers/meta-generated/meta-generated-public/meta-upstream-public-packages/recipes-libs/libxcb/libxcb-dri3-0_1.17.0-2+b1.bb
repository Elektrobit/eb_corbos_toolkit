# This was autogenerated! Do not modify
SUMMARY = "X C Binding, dri3 extension"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libxcb"
HOMEPAGE = "https://xcb.freedesktop.org"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libx/libxcb/libxcb-dri3-0_1.17.0-2+b1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libx/libxcb/libxcb-dri3-0_1.17.0-2+b1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "36f8da27acb0ce45dcec66c7a5db5bbe"
SRC_URI[deb0.sha1sum] = "127e08aeb15cb0f9366bf4350b96299b0b954d4d"
SRC_URI[deb0.sha256sum] = "f446d42fb5fcebbb3e347368ba83616769fdb271d85b2f49048e337f3163d267"
SRC_URI[deb0.sha512sum] = "c9dd419b329a8785c56f2f55d99ce44b0ed5d79752d67522db68ad190daaa0fe71add94fc45122ca96dcc1fb088997dbbbde12195f0601285d2b5ef3affa8153"
SRC_URI[deb1.md5sum] = "830774967ee45ec4e219063376211913"
SRC_URI[deb1.sha1sum] = "99a8dbdaf1fb431de77368553e09352fda96dd72"
SRC_URI[deb1.sha256sum] = "247bf758dd78d6c285fdd47942ddacf4a3189fd50de4f0891c9bd9aea12da3a1"
SRC_URI[deb1.sha512sum] = "fec3d4e9e014cfc4f43591dfa026c2e0c25d50bb2a95005f66dc08e0aeeb2deb945b1afe61a9ebdce4c373f8d639b33fd35f573c46a201031eb9cba7f2762043"

RDEPENDS = " \
    libc6 \
    libxcb1 \
"

