# This was autogenerated! Do not modify
SUMMARY = "X C Binding, sync extension"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libxcb"
HOMEPAGE = "https://xcb.freedesktop.org"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libx/libxcb/libxcb-sync1_1.17.0-2+b1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libx/libxcb/libxcb-sync1_1.17.0-2+b1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "8a09019f592e618eba82acb4e86cccc9"
SRC_URI[deb0.sha1sum] = "db4efdbb54a4f10b9287a5e856a9da17332edd30"
SRC_URI[deb0.sha256sum] = "0ce4770ed1505be9ddc6473045e4662d062aff2f3077ee684265f01cfb543559"
SRC_URI[deb0.sha512sum] = "99fb8adb4c25606eba9510001aaf8e250c36d568744e55bb194c2ea719aad15459607c789e04f681e6c85ff18101307cc0d2e68e291b3009c028489693b0b3ae"
SRC_URI[deb1.md5sum] = "30f568b528cec05d5a71fe754dfea7db"
SRC_URI[deb1.sha1sum] = "df6016399e2433a10ae4ffabde1cf22073702fed"
SRC_URI[deb1.sha256sum] = "eb428ac77daac9e5eea8a4e9ba48d1d78cc8ca400e415c8e4628cc729c6f4749"
SRC_URI[deb1.sha512sum] = "7027dae61043048c3ab1bdd3e550a1b364e3072903aa70b188dc1bff64e2f83dcbbb66c3e2b754a2b3b2b30e8855b633d07ba43a038209bd8483a93401739d27"

RDEPENDS = " \
    libc6 \
    libxcb1 \
"

