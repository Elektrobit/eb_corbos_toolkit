# This was autogenerated! Do not modify
SUMMARY = "X C Binding, composite extension"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libxcb"
HOMEPAGE = "https://xcb.freedesktop.org"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libx/libxcb/libxcb-composite0_1.17.0-2+b1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libx/libxcb/libxcb-composite0_1.17.0-2+b1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "d4b63cdee02b321ebfc6ee8d5774885b"
SRC_URI[deb0.sha1sum] = "e4a1c2fef06cdfcfb88b3b8bc908798bddb4d440"
SRC_URI[deb0.sha256sum] = "5e9eb63ce6ae1fb282059510078f2df88c3780bfea37ac2dac5c374250cb4789"
SRC_URI[deb0.sha512sum] = "e04472365f2b639b87f72cdd1d7b5d08877e7abc8d5f1c765f70b657de71fc399429324aa4fc077d1060d0702a9ceb4b65299a52ce966d921de36eabd5bb4161"
SRC_URI[deb1.md5sum] = "aa29262d3afa9dad834e198dbf87052f"
SRC_URI[deb1.sha1sum] = "fc5a06a7a88cb4abf493a183fe8db7a1c46771f7"
SRC_URI[deb1.sha256sum] = "d37523c77b7d7786286dd466f876d6310c6c35e9eb12fcb36c70c4732118eb0e"
SRC_URI[deb1.sha512sum] = "3dc5f46a69c89888509b235f7aed0407823dfc37ac194a88227179b520935cd099a98264e310d6fe717e50e18d93e74a0d47438cee7a1ca26e1954a6b4767e9e"

RDEPENDS = " \
    libc6 \
    libxcb1 \
"

