# This was autogenerated! Do not modify
SUMMARY = "Common UNIX Printing System(tm) - Core library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "cups"
HOMEPAGE = "https://github.com/OpenPrinting/cups/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/c/cups/libcups2t64_2.4.10-3+deb13u2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/c/cups/libcups2t64_2.4.10-3+deb13u2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "e477256eb77db3edb891cf04d6268f97"
SRC_URI[deb0.sha1sum] = "ac84a5e307d0f01e1ab1139503300c63bf79cb18"
SRC_URI[deb0.sha256sum] = "278c57da32afceec1f406869e790b29f40c75b02bb8e512dd903d5a5264df9d2"
SRC_URI[deb0.sha512sum] = "eef58c77e07771453123a9b48f7b5b121271da7e119c888f5cecc5cb2d84a21236c8bbf6dabf638253e596c971640f16bb7f5f03337ea5f61dd63767dd889a6d"
SRC_URI[deb1.md5sum] = "95b6e39e163d1b76d418a88d15a7c941"
SRC_URI[deb1.sha1sum] = "23bb5b06884a8b681acb08a810ae5c0ae1190f2a"
SRC_URI[deb1.sha256sum] = "7ab4a1f78863f9f4c9fab7e56633e84932c94fb835c8f9e83062988be53e5b5d"
SRC_URI[deb1.sha512sum] = "1c3630761ef39555babd0bc0dc92d32b4b8ee2b12a14b828b2ae93f2f4de0e78005d79498f23b0620687746b897fbb548ca38509c895c9e709a08648e8a844f7"

RDEPENDS = " \
    libavahi-client3 \
    libavahi-common3 \
    libc6 \
    libgnutls30t64 \
    libgssapi-krb5-2 \
    zlib1g \
"

RPROVIDES = " \
    libcups2 \
"
