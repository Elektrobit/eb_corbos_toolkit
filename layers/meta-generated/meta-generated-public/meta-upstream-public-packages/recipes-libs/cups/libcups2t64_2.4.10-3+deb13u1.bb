# This was autogenerated! Do not modify
SUMMARY = "Common UNIX Printing System(tm) - Core library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "cups"
HOMEPAGE = "https://github.com/OpenPrinting/cups/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/c/cups/libcups2t64_2.4.10-3+deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/c/cups/libcups2t64_2.4.10-3+deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "70f7227f29e3e7136b744b64cb0c5f73"
SRC_URI[deb0.sha1sum] = "5b9e654b6e040c48681682d9724ae04033c75238"
SRC_URI[deb0.sha256sum] = "3ad4c8a3aeb00f3e5c950e43e92618f1b6ebffc6a1d7d46a62c75a56098dded4"
SRC_URI[deb0.sha512sum] = "69caf9ccaaf27e539f73a8b99af326ebd9e2bed3cc736c61d25558c9eaababffa1c0103b24f0a07657d8a323b974a56578c89154ee5925fe23300e376c847cd2"
SRC_URI[deb1.md5sum] = "9414d2db7fe6a5e2ddc303835d071ab0"
SRC_URI[deb1.sha1sum] = "8dbae968fdef329347ccfb3bcb1d22d396322ef3"
SRC_URI[deb1.sha256sum] = "db60b136533c89cda258785465f0db2d6e69241cca7fd3117c33e519843bd75e"
SRC_URI[deb1.sha512sum] = "394845247a2e6786ee152f4f31ed55bf7f4fa46d54a53a03df4c9d9c90525be92f219715f001e62cb711b1393fd03d1aa7f873f6e9b3b2983d4413e78b9e20ff"

RDEPENDS = " \
    libavahi-client3 \
    libavahi-common3 \
    libc6 \
    libgnutls30t64 \
    libgssapi-krb5-2 \
    zlib1g \
"

RPROVIDES = " \
    libcups2 \
"
