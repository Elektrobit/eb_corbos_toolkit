# This was autogenerated! Do not modify
SUMMARY = "Not Erik's Windowing Toolkit - text mode windowing with slang"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "newt"
HOMEPAGE = "https://pagure.io/newt"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/n/newt/libnewt0.52_0.52.25-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/n/newt/libnewt0.52_0.52.25-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "f22049ae9928dde8259b157cdd0175bd"
SRC_URI[deb0.sha1sum] = "d72af305e6d3fad0c19ff7e845a70f33e8c605f0"
SRC_URI[deb0.sha256sum] = "083faa786377345d00669886b50eb4b3767d572518a668e94cda1ae34d027d28"
SRC_URI[deb0.sha512sum] = "019489798ce07ed2965e12fa0e6abdcd5602eda4d361c8b2b0e34aa7e7dede0cf1229b3ae1ce6a20e05fd7e973dffbce582b5b9058e479486ee649cf9bc2f0a3"
SRC_URI[deb1.md5sum] = "937cc6f3425afa60f7776a303bcdebcc"
SRC_URI[deb1.sha1sum] = "07dcc7899db820d74f6bb746e56b6d721c0e88a9"
SRC_URI[deb1.sha256sum] = "1b163dc089895f2a5ca849d6a526f33b268fbfc7f5fc6db8f12bd1e6d5a6c62c"
SRC_URI[deb1.sha512sum] = "347d6ce9db292cc471a59b17ff352c4bcd03cbcdbc51d8c9a3588f54acd8aae67759194c5aa5c8924c27b2a693340f5aff87b0455a2c3d919e2693fa1b493fa1"

RDEPENDS = " \
    libc6 \
    libslang2 \
"

