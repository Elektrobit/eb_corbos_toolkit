# This was autogenerated! Do not modify
SUMMARY = "Qt 6 network module"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "qt6-base"
HOMEPAGE = "https://www.qt.io/developers/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/q/qt6-base/libqt6network6_6.8.2+dfsg-9+deb13u2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/q/qt6-base/libqt6network6_6.8.2+dfsg-9+deb13u2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "98a8449de8cb9c9a9cac0c5a7bb82dbd"
SRC_URI[deb0.sha1sum] = "9499b79286ce5145a0fa3318456ca524cba46d08"
SRC_URI[deb0.sha256sum] = "394b3645254a9c2a4a24957d5cf32e3e6aab66c15a6f2cc9aa2298622bbd2f61"
SRC_URI[deb0.sha512sum] = "1da0cc60e1104fa2a1cb316ae4b86c3a0accfaacd0339d59a146a4726669286f43eb522ae9599f0a02dc83364bb38bfc5413d331f217dde96badbf0d66f07479"
SRC_URI[deb1.md5sum] = "61c82e785cde5251820861012e7382e7"
SRC_URI[deb1.sha1sum] = "084e5b0198d4611541830b8cdb62c8a3278cb9b7"
SRC_URI[deb1.sha256sum] = "ab52b4dd1b197ee500d3ebb93dae1a6caaf567163392c7fbb7472e0fe348b30f"
SRC_URI[deb1.sha512sum] = "1f7de3cbbd05e33c20347356e3404e080ebbb02723fa5757c99ab4cc51c33facfef10b6b5bc7ef768a2db5dc3011fc8259b798ce582570b2b6071f733b6d6c99"

RDEPENDS = " \
    libbrotli1 \
    libc6 \
    libglib2.0-0t64 \
    libgssapi-krb5-2 \
    libproxy1v5 \
    libqt6core6t64 \
    libqt6dbus6 \
    libssl3t64 \
    libstdc++6 \
    libzstd1 \
    qt6-base-private-abi \
    zlib1g \
"
RDEPENDS:append:amd64 = " \
    libgcc-s1 \
"

