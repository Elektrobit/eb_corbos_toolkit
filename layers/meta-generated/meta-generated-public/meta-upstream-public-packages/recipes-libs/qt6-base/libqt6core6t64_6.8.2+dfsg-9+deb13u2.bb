# This was autogenerated! Do not modify
SUMMARY = "Qt 6 core module"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "qt6-base"
HOMEPAGE = "https://www.qt.io/developers/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/q/qt6-base/libqt6core6t64_6.8.2+dfsg-9+deb13u2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/q/qt6-base/libqt6core6t64_6.8.2+dfsg-9+deb13u2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "d7c3bb13115c07a644d892c35482c170"
SRC_URI[deb0.sha1sum] = "1cb59f0301b0c86b6fc7dec8d0402c21281d2fa2"
SRC_URI[deb0.sha256sum] = "c7691937813e6cdf712aa98013bcac9d414f6fdeaea041ff53de5f8ae9b58e10"
SRC_URI[deb0.sha512sum] = "5bc31f2acc6c48b94bbfa4757681eabcd4992c87676d5704d0fe82c582e95a9596c47f839adf901858202d59a8bf211550da4e05772970c9610985bb4b8af656"
SRC_URI[deb1.md5sum] = "35a26b7948a3ae7cd80ab144ba0d7511"
SRC_URI[deb1.sha1sum] = "18d6c3ee65c786e63ec70235f7a73601445ed459"
SRC_URI[deb1.sha256sum] = "9a357f28ace917f65d114aaa26aed4ee67e2858797f0a2d01130f299350df208"
SRC_URI[deb1.sha512sum] = "7be434ea1ac70c5d0a4709306b21f1db4a6af1bf652047795fc1587d0a9f223bf3ab756cda1558123cbc73370b5ef3b17964e1607c0ed47d70bcc187c22f7c1b"

RDEPENDS = " \
    libb2-1 \
    libc6 \
    libdouble-conversion3 \
    libgcc-s1 \
    libglib2.0-0t64 \
    libicu76 \
    libpcre2-16-0 \
    libstdc++6 \
    libzstd1 \
    shared-mime-info \
    zlib1g \
"

RPROVIDES = " \
    libqt6core6 \
    qt6-base-private-abi \
"
