# This was autogenerated! Do not modify
SUMMARY = "Qt 6 concurrent module"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "qt6-base"
HOMEPAGE = "https://www.qt.io/developers/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/q/qt6-base/libqt6concurrent6_6.8.2+dfsg-9+deb13u2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/q/qt6-base/libqt6concurrent6_6.8.2+dfsg-9+deb13u2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "a00566381b643df3b09383a120bc9798"
SRC_URI[deb0.sha1sum] = "7972eb8889246b987bb3c13c2c85a7bc2bcdc5fe"
SRC_URI[deb0.sha256sum] = "b0b67257b4b70ac3e035f21d40e498055e9b0807e5f35e3e58b122267e8043d5"
SRC_URI[deb0.sha512sum] = "3829484c4803a4a8831d6cb7c8ed0e11a44137330de709b4e749b4de91729d5fc89f7453bf014217e452ee2273a89729cbfa07cc03ba5352b61104688a62f0bd"
SRC_URI[deb1.md5sum] = "2d675c448f1bd02ea849c23b2256f59b"
SRC_URI[deb1.sha1sum] = "0b931c348998eeef275c04222112e6bb65ddb2df"
SRC_URI[deb1.sha256sum] = "6254afbf0783ed6ee6f0061ee670434d891acd245728b7dbe63efd459bc1456c"
SRC_URI[deb1.sha512sum] = "c8d20b8ab047be8217c387495426a6e2e2e539509a2a22365496b408c776d21fd67ba2f57ad6190afb1a46478ad8386c1b366f2dda08917a641a599562d8759b"

RDEPENDS = " \
    libc6 \
    libgcc-s1 \
    libqt6core6t64 \
    libstdc++6 \
"

