# This was autogenerated! Do not modify
SUMMARY = "Qt 6 OpenGL widgets module"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "qt6-base"
HOMEPAGE = "https://www.qt.io/developers/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/q/qt6-base/libqt6openglwidgets6_6.8.2+dfsg-9+deb13u2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/q/qt6-base/libqt6openglwidgets6_6.8.2+dfsg-9+deb13u2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "8c4ace7b27576115a40f5e9a9b9cbb33"
SRC_URI[deb0.sha1sum] = "96e6a4fd89bbda37f115087d2aa4998d3a26072e"
SRC_URI[deb0.sha256sum] = "93701d54555133c36e5b2edadfe07942f3d2999036363ec3e327f04e546dda2f"
SRC_URI[deb0.sha512sum] = "6367b01876abe461fb0f3d69dc0e96841b6dfac75c784457e831236d2e61bc5192ee87a1f9ab75f0511a2bc39a2fe3ff5df3e51d8a9b95b952f2aa673ed5ec27"
SRC_URI[deb1.md5sum] = "c7b7dc5ceef2196dd470d7bd9feea1e7"
SRC_URI[deb1.sha1sum] = "928289d012f543eb03e9b59d80907917da0b742e"
SRC_URI[deb1.sha256sum] = "a5e263a7ced863398417a9b2f3feb8d9df78c43e1d8d8f8fa0b76ffd1ff65f5f"
SRC_URI[deb1.sha512sum] = "7073952e49d3838092dfd64027178baecac53dde3b1c7c4f5887fd7b6a62c6e6707931c40542497eb99f717c8faefb6eaae0a099d1be52cb9aed5445164eee52"

RDEPENDS = " \
    libc6 \
    libqt6core6t64 \
    libqt6gui6 \
    libqt6opengl6 \
    libqt6widgets6 \
    libstdc++6 \
    qt6-base-private-abi \
"

