# This was autogenerated! Do not modify
SUMMARY = "Qt 6 SQL module"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "qt6-base"
HOMEPAGE = "https://www.qt.io/developers/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/q/qt6-base/libqt6sql6_6.8.2+dfsg-9+deb13u2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/q/qt6-base/libqt6sql6_6.8.2+dfsg-9+deb13u2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "daed09fca90fc99b0487089b407bf3c5"
SRC_URI[deb0.sha1sum] = "1aac455e992a6f3c4ae472001482f1067c891516"
SRC_URI[deb0.sha256sum] = "430249fe698e14488337064d7177aa8b630e16a35d2dd3bdda79fe83f956fff9"
SRC_URI[deb0.sha512sum] = "b63dafb571107f10fa41beb7154d6aa772148b789a5ea34e4c753a44927bb06229bd918e81bfa668f9aec47c0b78397f58ac1d2daa0994581d59456db982c9d6"
SRC_URI[deb1.md5sum] = "14d597941790602f8120594cdbca320a"
SRC_URI[deb1.sha1sum] = "e6a53d8f993ab02f8bdec6107dc3ea36d9961556"
SRC_URI[deb1.sha256sum] = "4cfd21d7cea66f6684cd01e1bb82518a27a45fc6d8aa189b9a66b79ff59d7f9a"
SRC_URI[deb1.sha512sum] = "f5fca360a6dfdfe1efc46fd00f00238b96b25483900349d6afbbeb19cd29ffd9b517c2c4628ae71705fe6d4b3d34ebd5aef4da935a2def4e7de920103ddcda77"

RDEPENDS = " \
    libc6 \
    libqt6core6t64 \
    libstdc++6 \
    qt6-base-private-abi \
"

