# This was autogenerated! Do not modify
SUMMARY = "Qt 6 GUI module"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "qt6-base"
HOMEPAGE = "https://www.qt.io/developers/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/q/qt6-base/libqt6gui6_6.8.2+dfsg-9+deb13u2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/q/qt6-base/libqt6gui6_6.8.2+dfsg-9+deb13u2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "8c2cd4aa850634ab6c1b2f191c282dd8"
SRC_URI[deb0.sha1sum] = "26ff3f97be07b060a03ff09bb89ef2c49c9f8fd9"
SRC_URI[deb0.sha256sum] = "a39717b874f7b71c69f27199299dc09d5f47b809af3064cf067e5e443b5d011b"
SRC_URI[deb0.sha512sum] = "111854b538b76cbae7c313a40ebee786f0589b280ebba625f0814b44ddcdc372be4b6517648b95cd819a1ae95896abdd32062215310fde472d6587c2963a3d3a"
SRC_URI[deb1.md5sum] = "01d974876be42ab158fff4112fca5f20"
SRC_URI[deb1.sha1sum] = "a91dfb90744c84354363e53a3501ed3e50c0aca4"
SRC_URI[deb1.sha256sum] = "665de7d3d4ef9376797b5123a6169cd63a55e3f4f26d338ebf58fee227582d75"
SRC_URI[deb1.sha512sum] = "60e805a61ba0139b25315cbfd91120d0bdf36d8e2a0ba553b56028805b4cb315376635f3e7f789a310ad17d95740c00dc7b141c4fa63cb620efee09ceca71d38"

RDEPENDS = " \
    fontconfig \
    libc6 \
    libdrm2 \
    libegl1 \
    libfontconfig1 \
    libfreetype6 \
    libglib2.0-0t64 \
    libglx0 \
    libharfbuzz0b \
    libice6 \
    libinput10 \
    libjpeg62-turbo \
    libmd4c0 \
    libmtdev1t64 \
    libopengl0 \
    libpng16-16t64 \
    libqt6core6t64 \
    libqt6dbus6 \
    libsm6 \
    libstdc++6 \
    libts0t64 \
    libudev1 \
    libx11-6 \
    libx11-xcb1 \
    libxcb-cursor0 \
    libxcb-glx0 \
    libxcb-icccm4 \
    libxcb-image0 \
    libxcb-keysyms1 \
    libxcb-randr0 \
    libxcb-render-util0 \
    libxcb-render0 \
    libxcb-shape0 \
    libxcb-shm0 \
    libxcb-sync1 \
    libxcb-xfixes0 \
    libxcb-xinput0 \
    libxcb-xkb1 \
    libxcb1 \
    libxkbcommon-x11-0 \
    libxkbcommon0 \
    qt6-base-private-abi \
    zlib1g \
"
RDEPENDS:append:amd64 = " \
    libgcc-s1 \
"

