# This was autogenerated! Do not modify
SUMMARY = "Qt 6 print support module"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "qt6-base"
HOMEPAGE = "https://www.qt.io/developers/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/q/qt6-base/libqt6printsupport6_6.8.2+dfsg-9+deb13u2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/q/qt6-base/libqt6printsupport6_6.8.2+dfsg-9+deb13u2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "ebf6792ec9f3a7ac7713471846f1a221"
SRC_URI[deb0.sha1sum] = "1321368415a26b6dc86e07925ca14d7a42d91efa"
SRC_URI[deb0.sha256sum] = "d20432a7e3af059f1f091b1c24e22f9f4ef1735b0b8d55e8bf15b6feb1637952"
SRC_URI[deb0.sha512sum] = "be6eba0238ca27597b08c2ab6985ed03cf57a2568434a7a92c9efe3279b0ef3af1a4e654dce22994359a614394eb3995e97e248abd824e563ef0ae11df4af787"
SRC_URI[deb1.md5sum] = "bbd60920ab08593fe02d081044353fb3"
SRC_URI[deb1.sha1sum] = "2bae65442553f877610541240cd193c844ece579"
SRC_URI[deb1.sha256sum] = "c89b2e0627900d84caf7c8578d71d0793805f0ecf745284fa8b562e2d01a1e67"
SRC_URI[deb1.sha512sum] = "7130cd7d672123052b74003fe87a6caf13f17b141566a8ffa7f66ae9a981ea105d58cec75e7d4b416345d390a523c2321d143745f68c385127cb50b120b3395d"

RDEPENDS = " \
    libc6 \
    libcups2t64 \
    libqt6core6t64 \
    libqt6gui6 \
    libqt6widgets6 \
    libstdc++6 \
    qt6-base-private-abi \
"

