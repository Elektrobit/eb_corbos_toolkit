# This was autogenerated! Do not modify
SUMMARY = "Qt 6 D-Bus module"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "qt6-base"
HOMEPAGE = "https://www.qt.io/developers/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/q/qt6-base/libqt6dbus6_6.8.2+dfsg-9+deb13u2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/q/qt6-base/libqt6dbus6_6.8.2+dfsg-9+deb13u2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "0292de48a44202104698b84445d2935c"
SRC_URI[deb0.sha1sum] = "3e1b8ef4017df7dc3183246960c6cf8e5deac783"
SRC_URI[deb0.sha256sum] = "ea2b6563e4e3f6c8c2838453cb2e0e70933e5e08fde6b8dc5ca7cefad9c80764"
SRC_URI[deb0.sha512sum] = "375520ffe5a161cd211e8f34b610241170b313850562f47694f3b1e2c0f33afc37cc1b749848c5ae245c9ae473388d6b00d7366c7de1eb0d01ba80de1c6909c1"
SRC_URI[deb1.md5sum] = "6adbca6082626301960becd847efbc45"
SRC_URI[deb1.sha1sum] = "4a81e7440ba3505b5e862e5ef6d5a45faf32f62b"
SRC_URI[deb1.sha256sum] = "8b638af64728b15c4aee768abed39ab96d40063edde17fa0f633253fdc5bce92"
SRC_URI[deb1.sha512sum] = "15b9ed5b2c649b258d1322ed0425d3385b5d02e2f8d1a4123b9fad51abf9d1d125ce7e8db123e7f45aef9f73d36d7d9a40ccefa3c595e96db96fc207ba811d6c"

RDEPENDS = " \
    libc6 \
    libdbus-1-3 \
    libqt6core6t64 \
    libstdc++6 \
    qt6-base-private-abi \
"

