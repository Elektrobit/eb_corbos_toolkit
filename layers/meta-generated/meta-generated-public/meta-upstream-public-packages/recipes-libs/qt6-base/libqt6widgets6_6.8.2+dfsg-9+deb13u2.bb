# This was autogenerated! Do not modify
SUMMARY = "Qt 6 widgets module"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "qt6-base"
HOMEPAGE = "https://www.qt.io/developers/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/q/qt6-base/libqt6widgets6_6.8.2+dfsg-9+deb13u2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/q/qt6-base/libqt6widgets6_6.8.2+dfsg-9+deb13u2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "ff8fd4b1584a9d78a23c95d9619c9b8e"
SRC_URI[deb0.sha1sum] = "8ca7a14fea0f601067047e3c94e4a05446ace29b"
SRC_URI[deb0.sha256sum] = "f61ccd0c809a665a6061c6a28d265965e8712e616599a81e50699ff8394afeea"
SRC_URI[deb0.sha512sum] = "aa853c04bb7efbc7169e43e260d853f65823d86c2800eda98683746f5625b5323ea06225cde71323592f14135d4c860cbd2a4fda6aa0f11c59c1c3d13a135334"
SRC_URI[deb1.md5sum] = "429e5121e62b455dc1d5f4c3c3c798ee"
SRC_URI[deb1.sha1sum] = "a7813424ebbdd1958b80f065afea65688f51d5ec"
SRC_URI[deb1.sha256sum] = "04176b005896051fe0210a40766427daf9e7bc512214b929cd28e559514d947a"
SRC_URI[deb1.sha512sum] = "94b7480077695d8fbd10745d18f7b01fb197f0aa6d6af55e4ab6ad22324a96011fbb261d0f71a44c93e61d6bab2135d0c83c59b27d3424336d441f00490275fb"

RDEPENDS = " \
    libc6 \
    libqt6core6t64 \
    libqt6gui6 \
    libstdc++6 \
    qt6-base-private-abi \
"

