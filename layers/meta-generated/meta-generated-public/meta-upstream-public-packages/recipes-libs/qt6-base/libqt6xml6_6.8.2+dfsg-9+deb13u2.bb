# This was autogenerated! Do not modify
SUMMARY = "Qt 6 XML module"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "qt6-base"
HOMEPAGE = "https://www.qt.io/developers/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/q/qt6-base/libqt6xml6_6.8.2+dfsg-9+deb13u2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/q/qt6-base/libqt6xml6_6.8.2+dfsg-9+deb13u2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "a96ae660ea1ec8cf01fdcc09c211c4e0"
SRC_URI[deb0.sha1sum] = "53de19803a9b5a368099f232809de71cb0e35e80"
SRC_URI[deb0.sha256sum] = "6ba7668e09150684cf98578862ac1c507583495db4581e5eda301dd210c71c4e"
SRC_URI[deb0.sha512sum] = "1cdfa6e09b6e6aeb581239614e1674c073b9531eb98f9474bcde2322e46275c32af228c97fee3136f402bc3cebd2dd791a00db290eac9b0e784b9db7d8b23d43"
SRC_URI[deb1.md5sum] = "f8fb613f7c6efe4c23c9529485bf3fe4"
SRC_URI[deb1.sha1sum] = "b318c24be116add787c505dd1fda67b0a7a3454d"
SRC_URI[deb1.sha256sum] = "03db66acd0028350bac543f166c1635b0a7f54a8d4162c62f70638f7283180eb"
SRC_URI[deb1.sha512sum] = "1395d0a96f71c01dccab6dd724b15a8b1f486a2f8afe6cf2b3dd89516f94d467b55c6e6739af4b02c74918885537674b2322d2d2bbeaa2be1ab28d65beb9e80b"

RDEPENDS = " \
    libc6 \
    libqt6core6t64 \
    libstdc++6 \
    qt6-base-private-abi \
"

