# This was autogenerated! Do not modify
SUMMARY = "VESA CVT standard timing modelines generator -- shared library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libxcvt"
HOMEPAGE = ""

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libx/libxcvt/libxcvt0_0.1.3-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libx/libxcvt/libxcvt0_0.1.3-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "f7b05a70a88e8642231be827eb959a5d"
SRC_URI[deb0.sha1sum] = "639f4cab59b53f5b0c5d78e6d605d709390b50fe"
SRC_URI[deb0.sha256sum] = "0faccb95f5d306fc30c8b128572b92ff97bf59c547f1f8a46b57e0b4c6dd045b"
SRC_URI[deb0.sha512sum] = "b5b46b0f68561f0c052eb59f2102b7c1fec3b7e9e8d3e9a54905d2d9f2a658aa877aafecf99227913632018cd59bcb5df19f94d13cfed04fa9ab0ca3150ba200"
SRC_URI[deb1.md5sum] = "4aaf2687b4a62cc91de7f16b352ce270"
SRC_URI[deb1.sha1sum] = "db4aaef0df5fafef8467fc22eaed77802a057c84"
SRC_URI[deb1.sha256sum] = "cae0bcff9cfaedcc2877dd62f852ede573141ac03ad5198b7a074628e8616020"
SRC_URI[deb1.sha512sum] = "a4aff3a4afa23201cdd16ce748677e5e7d46f578a2f52293193419709de1d7d3ad8ab9b202c45f682df8a6ee2ac05cecedb1a592164f59a65ceaaa4a16b0a46c"

RDEPENDS = " \
    libc6 \
"

