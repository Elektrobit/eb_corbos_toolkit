# This was autogenerated! Do not modify
SUMMARY = "General Purpose Mouse - shared library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "gpm"
HOMEPAGE = "https://nico.schottelius.org/software/gpm/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gpm/libgpm2_1.20.7-11+b2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gpm/libgpm2_1.20.7-11+b2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "981c96706e9fbf68f38d70e19f4f2013"
SRC_URI[deb0.sha1sum] = "2de18c4c0c1800dfb0de915f9d94c7f2e11b4f6f"
SRC_URI[deb0.sha256sum] = "c8779444e5bb8df39c8bce3ef7dd3d662686a9ab770dcc96bb0f4aeb2077a67c"
SRC_URI[deb0.sha512sum] = "a5bbfe4051f749f7ffe82471da445b14f3c3d27a56fde6aded1ac5fcc9d9a0f60c04bfa1675db46dc747edac3029643a716f8a4e50222005be15f0e423a10b95"
SRC_URI[deb1.md5sum] = "810b131f24e09872b01ac620e6f70665"
SRC_URI[deb1.sha1sum] = "d323114161b15ee10246fab8b03c4c3306a2f78d"
SRC_URI[deb1.sha256sum] = "98772e064654b12f74175ab8c0cb80d77c04aeff82eb0c197076a76825d8d286"
SRC_URI[deb1.sha512sum] = "efc96a93df95156c2ff021352321dad9494675979a2a56b3e2a94c6bbe21667eadca7e8b3523101878225ae9bfd7f6ad8a486d8987edd8238c78781ec43e9a4a"

RDEPENDS = " \
    libc6 \
"

