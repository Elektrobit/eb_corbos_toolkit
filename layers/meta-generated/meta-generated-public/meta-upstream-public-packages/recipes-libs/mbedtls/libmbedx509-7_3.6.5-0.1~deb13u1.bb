# This was autogenerated! Do not modify
SUMMARY = "lightweight crypto and SSL/TLS library - x509 certificate library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "mbedtls"
HOMEPAGE = "https://www.trustedfirmware.org/projects/mbed-tls/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/m/mbedtls/libmbedx509-7_3.6.5-0.1~deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/m/mbedtls/libmbedx509-7_3.6.5-0.1~deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "2ef7bd1209ddca669332ecb29fec3176"
SRC_URI[deb0.sha1sum] = "df20d9e892a8a4034ce7d9a3c98a697546064cfd"
SRC_URI[deb0.sha256sum] = "93511b18fd8432897ebf08ea62ee91d7f41d3135a8c5342d92d979f3e5489236"
SRC_URI[deb0.sha512sum] = "4763eaf2f43c96959a52a978d6df69a8b8182ee3e5cf8bb004c5b9739959c36766892576123ffc1a61285c48e2b38cd5fc63e8d4e744357e276e27b0303c8e46"
SRC_URI[deb1.md5sum] = "646b176aa0142eca9279dc6b09221530"
SRC_URI[deb1.sha1sum] = "634384cb1877dde84a673bc667d60eaef41a6a70"
SRC_URI[deb1.sha256sum] = "1b8871afa9d88a8784ff105fca9338548d03b320d1db917043a2e2fcee1654fa"
SRC_URI[deb1.sha512sum] = "636a2e0ace535069f84f65abee1545384bd3dc04459c95bfa0f8d68d294527ec410accd09f0a19783d626ead4c9076bb8f6a0c3d08265e165c0c0b4910df3dbb"

RDEPENDS = " \
    libc6 \
    libmbedcrypto16 \
"

