# This was autogenerated! Do not modify
SUMMARY = "lightweight crypto and SSL/TLS library - crypto library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "mbedtls"
HOMEPAGE = "https://www.trustedfirmware.org/projects/mbed-tls/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/m/mbedtls/libmbedcrypto16_3.6.5-0.1~deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/m/mbedtls/libmbedcrypto16_3.6.5-0.1~deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "b97b8c3588a081efb974985d5be9388d"
SRC_URI[deb0.sha1sum] = "35dea5b481e7bf00d4e45e6d70596f11d48ec741"
SRC_URI[deb0.sha256sum] = "530ca22985b4381a1f110abdedc0acfd5172c4d3bf621616828a2c9e91e2aad3"
SRC_URI[deb0.sha512sum] = "6dd86ba3e9c0049a90c91abf447ec06ece34d7043992b0a8ce5ec2b67ff4284494113e5122d04eef87c05c09510e4856f135d554160f2c033f96ccd45102ef6e"
SRC_URI[deb1.md5sum] = "93acb9a5e9449b2d97aaa8bffe2f7e04"
SRC_URI[deb1.sha1sum] = "f25447f934226e354b98394eea1c2f78e2d825ca"
SRC_URI[deb1.sha256sum] = "4089d1825ebd922a7a594b76465a0363f1e06222c78c3c92e9380daa8036073c"
SRC_URI[deb1.sha512sum] = "ff9ca3d6e9c5d7baa1913b5da832e406b275fb44457a1a7251007f71c25e89c70bad19522e7fc7a8c7c7323920668cfec63faf65f41f84ec37005aae3fcf855c"

RDEPENDS = " \
    libc6 \
"

