# This was autogenerated! Do not modify
SUMMARY = "lightweight crypto and SSL/TLS library - tls library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "mbedtls"
HOMEPAGE = "https://www.trustedfirmware.org/projects/mbed-tls/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/m/mbedtls/libmbedtls21_3.6.5-0.1~deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/m/mbedtls/libmbedtls21_3.6.5-0.1~deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "6c53ceb61c796b7c41125aff65918f27"
SRC_URI[deb0.sha1sum] = "2903a886694d4bba5f84c5c38e8d8e9fab6cd54c"
SRC_URI[deb0.sha256sum] = "9768cdf622a3b0c127f6903eaaccc0ea02d1a47c5e39e65e3b060c8f3baf2b33"
SRC_URI[deb0.sha512sum] = "cd38ee12a476e034d541688a9372dd8441411024ee7909891b005f7ff59c5e6aff56a0a2fc039e4bc9abe929a4aac2e78917a48a8c8735494b7f8187b4287ef9"
SRC_URI[deb1.md5sum] = "10576732293eba10b9ec6d701292a1c7"
SRC_URI[deb1.sha1sum] = "f8efff11eb0470c45cc141feffef83f020f6c0f9"
SRC_URI[deb1.sha256sum] = "07f680aedc13c7fe68459108681444382c5b636504435af9543faba75091449a"
SRC_URI[deb1.sha512sum] = "82ebd02ebc175b1b3ae603bb83cd43dbbc886e147b96e08fcfa6e5e04edd7a7d66cd5e9e02969dbdf2010a90180377c32a8fef597fbff36f1d8e215fffa34f2f"

RDEPENDS = " \
    libc6 \
    libmbedcrypto16 \
    libmbedx509-7 \
"

