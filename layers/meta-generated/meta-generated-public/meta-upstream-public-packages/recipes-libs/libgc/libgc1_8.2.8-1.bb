# This was autogenerated! Do not modify
SUMMARY = "conservative garbage collector for C and C++"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libgc"
HOMEPAGE = "https://www.hboehm.info/gc/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libg/libgc/libgc1_8.2.8-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libg/libgc/libgc1_8.2.8-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "11a3a83a14612eae9a97a91c91f4fc77"
SRC_URI[deb0.sha1sum] = "508b0ffe82f0b039bfd7b0199f386fd973da5396"
SRC_URI[deb0.sha256sum] = "0279fc16692a3a4a6d5f84051f5e55fc721f3cbb0e2bbc052d8980888f18c698"
SRC_URI[deb0.sha512sum] = "662b319bfb196f974ff6c3cdc511cea6de445a0b8709ee70adde2e1fe493fc0831ee799a1f491c757f1a1e068bb72d0fb0624d1fcd16f774490fb148078c4920"
SRC_URI[deb1.md5sum] = "ac428ed1186d11d09f720040b691875c"
SRC_URI[deb1.sha1sum] = "e0f899feefaabb033efdca11a052cdef9504b7fe"
SRC_URI[deb1.sha256sum] = "58747952e7bd66396023aa8bf53f5039217fddd750b337dfa13352d4fc07f528"
SRC_URI[deb1.sha512sum] = "f81437c08cb880e474d7755e0d13f790123b6c4736c5eb0c7dd15ec9ff6ec44f018885c1afc5fa54165a9896fde7a658dffb122c31ce585a3cab197d0b623274"

RDEPENDS = " \
    libc6 \
    libstdc++6 \
"

