# This was autogenerated! Do not modify
SUMMARY = "GLib library of C routines"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "glib2.0"
HOMEPAGE = "https://gitlab.gnome.org/GNOME/glib"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/glib2.0/libglib2.0-0t64_2.84.4-3~deb13u3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/glib2.0/libglib2.0-0t64_2.84.4-3~deb13u3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "cc93c231ac30a4744134ebd3bd1e39db"
SRC_URI[deb0.sha1sum] = "43bfd0c80ba9526302754fd35fd5edf5398b2ca4"
SRC_URI[deb0.sha256sum] = "e7bc3813fa7effa8bbd0d5547e6198ba18f53f5e79d305b8c34e8dce27f6c454"
SRC_URI[deb0.sha512sum] = "173f68c076b72238fa45728617c5a9fa433d87af5ea3c037cc39f33957b5ff7e09896d97c7fb8e24c6d38e9a1fae705a4f1a30cf34ef62782d7dec43c54b7274"
SRC_URI[deb1.md5sum] = "a8e609b9cc9a83ea0896b89d81020cf9"
SRC_URI[deb1.sha1sum] = "fa28fd1dfb6888fe009042aff5cce586f3709601"
SRC_URI[deb1.sha256sum] = "97d54c95f7e190cc21cc6a94e3e9654c5fac6e7b86db33ca6ff00feae60bced4"
SRC_URI[deb1.sha512sum] = "c812530b91156ee3afee96baa92089b60ea041ca1117a0ac0f96c3ad0ada45d6a58060047f5d4cc22cc433cd620f07ef719cb0ffa5769cbc56835b9565150b29"

RDEPENDS = " \
    libatomic1 \
    libc6 \
    libffi8 \
    libmount1 \
    libpcre2-8-0 \
    libselinux1 \
    zlib1g \
"

RPROVIDES = " \
    libgio-2.0-0 \
    libglib-2.0-0 \
    libglib2.0-0 \
    libgmodule-2.0-0 \
    libgobject-2.0-0 \
    libgthread-2.0-0 \
"
