# This was autogenerated! Do not modify
SUMMARY = "SELinux policy management library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libsemanage"
HOMEPAGE = "https://selinuxproject.org"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libs/libsemanage/libsemanage2_3.8.1-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libs/libsemanage/libsemanage2_3.8.1-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "bd188a7d6b4067f02d8b916431c7d16e"
SRC_URI[deb0.sha1sum] = "0ebc529eca4b503084ccb1ccf25e95b5c718d42c"
SRC_URI[deb0.sha256sum] = "f97da7505d17ad3bdd8fc56302256df7e158e5e0d8b02cb766654199cbc406a9"
SRC_URI[deb0.sha512sum] = "daffd3059e3647410bfe1a75cc138916c82291c2dc1e20dd7101014d9401c65b2d528e674f2d67e847d96eecb896303208073a3ac6bcaf79c7900fd4d1798cfd"
SRC_URI[deb1.md5sum] = "f90a46e62f80ae20d81b9af869bdae75"
SRC_URI[deb1.sha1sum] = "d87ae42e3ea46dc0035f9c9e8b93a60a61d1a555"
SRC_URI[deb1.sha256sum] = "ed73a76d3c39ac5cbd0a447527bba3dc33d3ec3785af7583b70ab41f85fc0243"
SRC_URI[deb1.sha512sum] = "387c21e59d13e1310c6deffe18c19825cc2d919ded03a1f8338a7ae70631ca561e1ef958b5a3711086055d9bcc99dd8ec3f6d92d9a1b43c9757537cc7a254619"

RDEPENDS = " \
    libaudit1 \
    libbz2-1.0 \
    libc6 \
    libselinux1 \
    libsemanage-common \
    libsepol2 \
"

