# This was autogenerated! Do not modify
SUMMARY = "Common files for SELinux policy management libraries"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libsemanage"
HOMEPAGE = "https://selinuxproject.org"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libs/libsemanage/libsemanage-common_3.8.1-1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "e27a7f67a7f2d8a78ccc5d7ff402a103"
SRC_URI[deb0.sha1sum] = "ed442bc1e7946d6bc82c2f846a3a99af63d0fe2c"
SRC_URI[deb0.sha256sum] = "65375d886749c236bd1da4d9990b7c2469d2fe66019a28e5614f6814376d3dcb"
SRC_URI[deb0.sha512sum] = "90afaabca9e7902cfa93c8e28989fe0704001b3dcb51b632decb38be390404c9e49a2c6152e9e00f8fc6d21eb924952bb4b7c67daff9496c81072400099a9e62"


