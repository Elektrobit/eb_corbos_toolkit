# This was autogenerated! Do not modify
SUMMARY = "Tag Image File Format (TIFF) library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "tiff"
HOMEPAGE = "https://libtiff.gitlab.io/libtiff/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/t/tiff/libtiff6_4.7.0-3+deb13u3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/t/tiff/libtiff6_4.7.0-3+deb13u3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "22c223cc85d0ec5c73daf59cf1a9b928"
SRC_URI[deb0.sha1sum] = "faa5bddd33fff3675e7b76863c6ef140347fb3b2"
SRC_URI[deb0.sha256sum] = "6bb2038f36817ae1ee6d33df03917b21835dcc2e0f3e3e80a71390e83c171173"
SRC_URI[deb0.sha512sum] = "341df3542d806bfed0429d8bd4a591fec6eb5243ddc3963292aeb053ad87e349cc8a7f71c6d25ff67e560b2b2b9d596c9809da23d761f08a2f51f966a278e447"
SRC_URI[deb1.md5sum] = "663c60f3559787976656bd89a3094622"
SRC_URI[deb1.sha1sum] = "5e4fec5c53e730725b92a01b3e6663878562fa79"
SRC_URI[deb1.sha256sum] = "208e9fdc14ed88a30f31fdfb993d1e8ab19f9ab29f3cd8546ffb4ea3f74f5a3f"
SRC_URI[deb1.sha512sum] = "fc2f724344fbdec9f2e23eeb73cc197cb27b01ebb5aa38762c6fc011ea7f6c6e6b0c4c8017a0f8807c595210d59fd173257700ea8b9b1d49f67502381aaa81fc"

RDEPENDS = " \
    libc6 \
    libdeflate0 \
    libjbig0 \
    libjpeg62-turbo \
    liblerc4 \
    liblzma5 \
    libwebp7 \
    libzstd1 \
    zlib1g \
"

