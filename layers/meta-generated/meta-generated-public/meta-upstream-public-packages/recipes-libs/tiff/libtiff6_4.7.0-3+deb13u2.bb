# This was autogenerated! Do not modify
SUMMARY = "Tag Image File Format (TIFF) library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "tiff"
HOMEPAGE = "https://libtiff.gitlab.io/libtiff/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/t/tiff/libtiff6_4.7.0-3+deb13u2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/t/tiff/libtiff6_4.7.0-3+deb13u2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "c510dc7c6ddec953c6eed3ba380a6c35"
SRC_URI[deb0.sha1sum] = "f97f2a01e4feaf2cb2e08abc854f1f333cad26ee"
SRC_URI[deb0.sha256sum] = "c8e37d4c33b7bfb6b1ffdafac5b81ec2eaa809dafe90801b0c04bbfa8f5e6891"
SRC_URI[deb0.sha512sum] = "26601c8482f544621522fa3b200180ed013090dbeacb75591ecedb35caa18c1a90e60d9dc40bc7bff13948ac92b0c824b7b970e7a8d61f0e9345b7f91e676791"
SRC_URI[deb1.md5sum] = "f6ea200824352f1e9fee8f211d15dbdb"
SRC_URI[deb1.sha1sum] = "49e51e4ebb8196337164f34317f74bd570d4ff7c"
SRC_URI[deb1.sha256sum] = "f58619b593325363b1c6070842cb7b8bfca8e727feb31ab92fcd3e98f137f4d0"
SRC_URI[deb1.sha512sum] = "1a615bdf4feb812250128e68e65b1f817105eb522adb738636c0992f2d66238896e1b3cd7419ed5af28d502cc37a4183ad90b219b4c1052d9af4230a45201307"

RDEPENDS = " \
    libc6 \
    libdeflate0 \
    libjbig0 \
    libjpeg62-turbo \
    liblerc4 \
    liblzma5 \
    libwebp7 \
    libzstd1 \
    zlib1g \
"

