# This was autogenerated! Do not modify
SUMMARY = "touch screen library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "tslib"
HOMEPAGE = "http://tslib.org"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/t/tslib/libts0t64_1.22-1.1+b1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/t/tslib/libts0t64_1.22-1.1+b1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "959bdbc7e442c403324064ae9789de1e"
SRC_URI[deb0.sha1sum] = "31ab9d8d71eec36bc393bb4ef23908fec7692ce3"
SRC_URI[deb0.sha256sum] = "38660b112e09465a0932df975a414b5b8d6e9401657e433829e8334e7f215d6e"
SRC_URI[deb0.sha512sum] = "aebe1c8669e3a80ad91948d3c47df4410604d2d16e12915bf9dea1b97aef85be436caee50fe1d16a8084112cb31380829849594844f0d88a92005c1c4f03abcf"
SRC_URI[deb1.md5sum] = "b9b69c5679224b3a89efa33c2fdc15f6"
SRC_URI[deb1.sha1sum] = "99c6b1a02dff2ec91c17f2b8e6d7720d27169b50"
SRC_URI[deb1.sha256sum] = "9d8809fef3271377d95fbf976716802b0c99a0ce6143117547e4eedf44271ea0"
SRC_URI[deb1.sha512sum] = "e65a6f710ba7d3c42c6c8caecd6fc95f9b0bbe707b54ad9df073b5c8e6f9f0a90fc959f37a3ac73c0c29ee7d5740ee7c7ee0553ec1243adbaf04a4bba63be6f7"

RDEPENDS = " \
    libc6 \
"

RPROVIDES = " \
    libts0 \
"
