# This was autogenerated! Do not modify
SUMMARY = "library to interact with debuginfod (development files)"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "elfutils"
HOMEPAGE = "https://sourceware.org/elfutils/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/e/elfutils/libdebuginfod1t64_0.192-4_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/e/elfutils/libdebuginfod1t64_0.192-4_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "58dc70c3a40db0b12229d1f14f5ba2c7"
SRC_URI[deb0.sha1sum] = "78cc6a4ad993cf9411b13d07f9fe27fd53f0aaa0"
SRC_URI[deb0.sha256sum] = "399d156a8a631889c71b1fdeb853d8effc40f812870a0b7b0eb09e04eb0dfa5e"
SRC_URI[deb0.sha512sum] = "898fb2ef6ecb8f5d49488984cec85d819a1dcf4a60dec101e59c0b61dcb7a3ca35e9fe08c387e565176cc95b8cf62cbbe904b378382a64c3c147d8d685e5a118"
SRC_URI[deb1.md5sum] = "fe45559b01daef180a71c168537f47a2"
SRC_URI[deb1.sha1sum] = "2029df49d1d273248d2a5a796ec946c8f3bc0ecd"
SRC_URI[deb1.sha256sum] = "f7259adcf1bd66808dde3d36eb47958542ad0e4b2074cf9ca97f7ba82be243c2"
SRC_URI[deb1.sha512sum] = "7c1988619991551939ab9bc9f4556cf23c7fb677cc69519b1ada3a795b7e2cfee4472fc09b8674e9406a68e3193b4fd510500d33e876b1ba707dac26f35bfefa"

RDEPENDS = " \
    libc6 \
    libcurl3t64-gnutls \
    libdebuginfod-common \
    libdw1t64 \
    libelf1t64 \
    libjson-c5 \
"

RPROVIDES = " \
    libdebuginfod1 \
"
