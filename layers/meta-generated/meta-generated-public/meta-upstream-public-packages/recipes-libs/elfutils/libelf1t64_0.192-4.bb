# This was autogenerated! Do not modify
SUMMARY = "library to read and write ELF files"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "elfutils"
HOMEPAGE = "https://sourceware.org/elfutils/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/e/elfutils/libelf1t64_0.192-4_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/e/elfutils/libelf1t64_0.192-4_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "906aacb5a1d743e4945a8690fb5fd59b"
SRC_URI[deb0.sha1sum] = "cefbbeb41869ffacff621e1a31bf66617df50832"
SRC_URI[deb0.sha256sum] = "94497b7e17b6f574a0605b380d454e20d3f01a9c63b70c2a2263f679d30053e1"
SRC_URI[deb0.sha512sum] = "7c89921ae79ffd6fcce286bd20c55df2facb8fce5f66cc13490a0f1cd71d237b5726b85d8076a898fdd53aa711108738a255e19e4057d98ef63277343d155795"
SRC_URI[deb1.md5sum] = "a615a526a971d5ff78073b6bc4f5466a"
SRC_URI[deb1.sha1sum] = "6a922586b1be17b60dfc6190e91446ffd46a82c7"
SRC_URI[deb1.sha256sum] = "815b4265c7d6c89c5bbad456bdeed7af893da6912c9d16cf4c581001927c0e37"
SRC_URI[deb1.sha512sum] = "8e2a89f10a90fb8972951e86d0e1f0040ec2f2ff351e6a107246f9a7b3f5edf1f6cffd42631548bce9e2f3a9692c8c8f00f65dd1d1af2e46cb515ce201e53129"

RDEPENDS = " \
    libc6 \
    libzstd1 \
    zlib1g \
"

RPROVIDES = " \
    libelf1 \
"
