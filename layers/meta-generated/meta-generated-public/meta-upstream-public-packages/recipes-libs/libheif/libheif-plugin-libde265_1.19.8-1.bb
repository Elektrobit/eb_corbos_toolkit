# This was autogenerated! Do not modify
SUMMARY = "HEIF and AVIF file format decoder and encoder - libde265 plugin"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libheif"
HOMEPAGE = "http://www.libheif.org"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libh/libheif/libheif-plugin-libde265_1.19.8-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libh/libheif/libheif-plugin-libde265_1.19.8-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "351ffb8509c45d7db37628f722d013c0"
SRC_URI[deb0.sha1sum] = "5e37f7e62d35472e94c5fcaf046a6ea858e8fc94"
SRC_URI[deb0.sha256sum] = "719918204bc83dc3aac68973b997e0934e96e4ef59052c5670e05548f3863904"
SRC_URI[deb0.sha512sum] = "d531cd2e2b2782da77f2b4c21049b93ae161b1567690c7a96b3016f32f5d0e2a5d88879ddcf4e5e48665bbf755e744412f6f139714495ba115e2e82002203081"
SRC_URI[deb1.md5sum] = "8802af19767dd54316393f20eae68265"
SRC_URI[deb1.sha1sum] = "8fa7ec56bdad64de81caf01c38ccb5ef571ca1dc"
SRC_URI[deb1.sha256sum] = "3199a69861538b105e30a127f54d298fb4b881923a8dc1bb621da5e85237ee97"
SRC_URI[deb1.sha512sum] = "e9ea037482061b72635d8d5aa40b987dfd4154027b9402fde4f66c186dca0cc235bcc6395b91dd109b4a0d6d7ce6d11f893602bf1349962c20e95f8243da9c4d"

RDEPENDS = " \
    libc6 \
    libde265-0 \
    libgcc-s1 \
    libheif1 \
    libstdc++6 \
"

