# This was autogenerated! Do not modify
SUMMARY = "HEIF and AVIF file format decoder and encoder - shared library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libheif"
HOMEPAGE = "http://www.libheif.org"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libh/libheif/libheif1_1.19.8-1+deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libh/libheif/libheif1_1.19.8-1+deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "4ba44e3e72ea1510ec4c37ec18c2115e"
SRC_URI[deb0.sha1sum] = "613240084af3323b82eb15ea87521934a24ea7be"
SRC_URI[deb0.sha256sum] = "8fe91ad5bfcd390ae25ebb0ff8e2001155c258136982fd854393ffef4321ce13"
SRC_URI[deb0.sha512sum] = "c479ff4258e74c99e9cf5aa993aea0a169d9fbbb42707fc0a67cba4f4cd60dbeb85e7f762a51f7e7176b2c11bbbed27f0ff57e3d8bdedb4911390563423e362f"
SRC_URI[deb1.md5sum] = "1fee80b071c198a87f6423d6ad669ca1"
SRC_URI[deb1.sha1sum] = "8954d31b7fb3151b712fa3d21ef2257905a0bb46"
SRC_URI[deb1.sha256sum] = "f260a7de138e232f3632ed65db9db86a3e5188ce1f3aa05d007593f69c84c46c"
SRC_URI[deb1.sha512sum] = "4bef8a920fa278ee4c08bcaa7896fe4b1e9ff5e272b2d717fe11a344665667568f5059af2ac137e2494c81a814ced177e9f7167ca7a99ba3cba1550ce7161eb6"

RDEPENDS = " \
    libc6 \
    libgcc-s1 \
    libheif-plugin-dav1d \
    libheif-plugin-libde265 \
    libsharpyuv0 \
    libstdc++6 \
    zlib1g \
"

