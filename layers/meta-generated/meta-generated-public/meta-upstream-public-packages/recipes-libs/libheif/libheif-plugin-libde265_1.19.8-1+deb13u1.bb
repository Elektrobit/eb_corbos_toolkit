# This was autogenerated! Do not modify
SUMMARY = "HEIF and AVIF file format decoder and encoder - libde265 plugin"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libheif"
HOMEPAGE = "http://www.libheif.org"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libh/libheif/libheif-plugin-libde265_1.19.8-1+deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libh/libheif/libheif-plugin-libde265_1.19.8-1+deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "34fe04420a727df88369343f4c5d1034"
SRC_URI[deb0.sha1sum] = "800472947b9bab6754373e9b599bf7ae956cc22a"
SRC_URI[deb0.sha256sum] = "fb951f0b3d81cb222412c6509daf34e6f2a45ad3aeefc2c286bee364e6f9f262"
SRC_URI[deb0.sha512sum] = "8bf2bd8b5ec0611b0660d3e8959922be8ec07abb0e61c8d1454a53fdbb4105940638505c6e8278429cd55e6415d44aa45488d9cbec6b680565761a3a31409eff"
SRC_URI[deb1.md5sum] = "db32a70a7c0afb0e91715c1735b0da43"
SRC_URI[deb1.sha1sum] = "43ca9f9764992e2ab75fbb51ff7c7a6cdf647b59"
SRC_URI[deb1.sha256sum] = "a74cbc3778a21ea62a09dfb11e74763667376adaea2c6d6993bd93a7f99203c4"
SRC_URI[deb1.sha512sum] = "59eadb558d1bc07dff0bfe717f894b0a7a0a5f1cda82be97dc59781e6815401c8af229b7e8d2284121ae86d2c7dabd72ba3ed8f2be44b1051d8fbdf043f981e2"

RDEPENDS = " \
    libc6 \
    libde265-0 \
    libgcc-s1 \
    libheif1 \
    libstdc++6 \
"

