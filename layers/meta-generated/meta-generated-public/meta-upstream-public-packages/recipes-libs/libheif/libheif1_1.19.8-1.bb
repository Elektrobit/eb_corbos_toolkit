# This was autogenerated! Do not modify
SUMMARY = "HEIF and AVIF file format decoder and encoder - shared library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libheif"
HOMEPAGE = "http://www.libheif.org"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libh/libheif/libheif1_1.19.8-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libh/libheif/libheif1_1.19.8-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "4e065e74764b4e6e4481f335867973a4"
SRC_URI[deb0.sha1sum] = "04d63b7e722e47ed3e0cd74aa01066c6d382621d"
SRC_URI[deb0.sha256sum] = "06460065e7768d7a4a72cb02a0eddd386936756a33596bb23901faeb72dc8f68"
SRC_URI[deb0.sha512sum] = "35be5c84dc8ea07cece54c7a345a0a2c8012e24b6dbaab40b31ac509ed084bcfbd4cb68cf48a5c53f61985b13ff0e7c60129cb2ca48e60c055fe57e59d5f0fc0"
SRC_URI[deb1.md5sum] = "c0ae279caa84ac336fce2303fcdbf3bc"
SRC_URI[deb1.sha1sum] = "9f478055ecc78b80ede604b9d654eea93f1c3faa"
SRC_URI[deb1.sha256sum] = "10d07cd4d2c374bfe9e1f9d197027cb6783d72efcfc5f1b159538b815f7552dd"
SRC_URI[deb1.sha512sum] = "531d49575f35eb0044a470b12d45ed0f868ef7e41fab904544fa834a41f1cfaa8dda04d09750e06821e4cf529d21bb2f8d56590b6650f30902990bb961a42a7c"

RDEPENDS = " \
    libc6 \
    libgcc-s1 \
    libheif-plugin-dav1d \
    libheif-plugin-libde265 \
    libsharpyuv0 \
    libstdc++6 \
    zlib1g \
"

