# This was autogenerated! Do not modify
SUMMARY = "HEIF and AVIF file format decoder and encoder - dav1d plugin"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libheif"
HOMEPAGE = "http://www.libheif.org"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libh/libheif/libheif-plugin-dav1d_1.19.8-1+deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libh/libheif/libheif-plugin-dav1d_1.19.8-1+deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "a091375d44ff645683a2f393a89ce5c5"
SRC_URI[deb0.sha1sum] = "a50699f901c627fad228cfb9e37d5f2f222269a4"
SRC_URI[deb0.sha256sum] = "42a07af572606ee50084ec24e6638a9ed7f3d08b75f733c2360ce7990c5d046e"
SRC_URI[deb0.sha512sum] = "289467e9e013e96b282f52ded72af6a990ce0d354334b26d35bb875da69b25e3def0ac394a7098544b1df1e5acab0f9e246b28033e4f1e3fa2c44572b0fc0cf5"
SRC_URI[deb1.md5sum] = "fc385fde5839382fe2764427e5fec3b2"
SRC_URI[deb1.sha1sum] = "8e0b3dfd82bf641d7521620953f5b80486ca9677"
SRC_URI[deb1.sha256sum] = "df0e2dc792c80161373beb7e3d2c9a01edddfe3e2759cfea747091f7b0b4e385"
SRC_URI[deb1.sha512sum] = "ef03820e3a73ceb094a3917679ffcd13672ae06eaca26a3e35cc4af8c3c412d7daf36c33761b521933e5c587e3ee2e0aabe1d645628cb58c8eac33a38a398c2a"

RDEPENDS = " \
    libc6 \
    libdav1d7 \
    libheif1 \
    libstdc++6 \
"

