# This was autogenerated! Do not modify
SUMMARY = "HEIF and AVIF file format decoder and encoder - dav1d plugin"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libheif"
HOMEPAGE = "http://www.libheif.org"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libh/libheif/libheif-plugin-dav1d_1.19.8-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libh/libheif/libheif-plugin-dav1d_1.19.8-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "5cc75db5bb05cbf3c3e03d21620882f7"
SRC_URI[deb0.sha1sum] = "4db82883543536a32eb80350a3ac4149d85009de"
SRC_URI[deb0.sha256sum] = "fed7de7d14f7df765bb6ef1a79bd55b90475808793a5c41dc9ccb9deacf639ae"
SRC_URI[deb0.sha512sum] = "4b8ce1f376fad560b739071ffd759bf401e0861eba6a53e9c0a5ec6a9dc2eec8338b7ec480dff5b3779933c6509ec7db5dfa1c56760dfb8180fc2c0529f66e80"
SRC_URI[deb1.md5sum] = "3aad0f79f68e363b4874548e05a3a363"
SRC_URI[deb1.sha1sum] = "617642d362e0f4d55dd3bc12bd7975dde31920d2"
SRC_URI[deb1.sha256sum] = "1010614124e95c37b9374e559528c1936ab693b087bdbf19371cc4468f604dda"
SRC_URI[deb1.sha512sum] = "7f44980c9be9fb1ad92bbda9c1d9cc089fd246a3e329edf05c6e78b6e4588f9092713da100cc3149dc2755ec50f801195f1ecf312f2b6e58c9d43ebd92aa7212"

RDEPENDS = " \
    libc6 \
    libdav1d7 \
    libheif1 \
    libstdc++6 \
"

