# This was autogenerated! Do not modify
SUMMARY = "architecture-independent files for source highlighting library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "source-highlight"
HOMEPAGE = "http://www.gnu.org/software/src-highlite/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/source-highlight/libsource-highlight-common_3.1.9-4.3_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "9180391ca658ba061633e77b265d1f66"
SRC_URI[deb0.sha1sum] = "693e419ca7391c12e614f5ad0e317ba73767d71d"
SRC_URI[deb0.sha256sum] = "4914dbff96bc9558e467239719fd64f27faaf0c26e5b8cc63cbb460484781e2d"
SRC_URI[deb0.sha512sum] = "e3f80ce611e23f38c26f6f0769a274613f72039b555b2a0f49f290e5069062ffe01b33c0dfe1fd17f57d3abb0f76fd97aeedac9389a01d4b9a50a28479f04607"


