# This was autogenerated! Do not modify
SUMMARY = "PulseAudio client libraries"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "pulseaudio"
HOMEPAGE = "http://pulseaudio.org"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/pulseaudio/libpulse0_17.0+dfsg1-2+b1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/pulseaudio/libpulse0_17.0+dfsg1-2+b1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "23a6e757fa15d2a47adf70b08d212280"
SRC_URI[deb0.sha1sum] = "62da1af706448351ebaead24cba3ceba27ab551e"
SRC_URI[deb0.sha256sum] = "786aca79119cb249562708fd24dcdf817604cfe75bbfcb8cda3464042e17f40e"
SRC_URI[deb0.sha512sum] = "890c6fbdaf0e06490d9807dae41256b5665ba22da5cd7031aee8f5caa894e57e454f5e3d14e7718b617e0fd5729c4ecb2c943933757d76c0891c45b5eed59ef5"
SRC_URI[deb1.md5sum] = "60c81315bbe92da708b80fb06585d81c"
SRC_URI[deb1.sha1sum] = "5aba62e10ebfcc00174e7388732482149fba5ae3"
SRC_URI[deb1.sha256sum] = "2de5610e3affe69cfb11110f890375261b47c9e0fc1a81eef7ecc4d6d2dc9a6d"
SRC_URI[deb1.sha512sum] = "6aceee8b8a078f10aa08013e27eb580d18ec0a1489fbd732b5058b119df5389369ba5adb15501b029344a914077d9d0dfe3cfca192f976d7920c577a8f55a5bb"

RDEPENDS = " \
    libasyncns0 \
    libc6 \
    libdbus-1-3 \
    libsndfile1 \
    libsystemd0 \
    libx11-6 \
    libx11-xcb1 \
    libxcb1 \
"

