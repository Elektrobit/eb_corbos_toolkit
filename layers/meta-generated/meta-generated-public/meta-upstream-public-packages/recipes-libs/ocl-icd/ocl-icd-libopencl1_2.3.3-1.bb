# This was autogenerated! Do not modify
SUMMARY = "Generic OpenCL ICD Loader"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "ocl-icd"
HOMEPAGE = "https://github.com/OCL-dev/ocl-icd"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/o/ocl-icd/ocl-icd-libopencl1_2.3.3-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/o/ocl-icd/ocl-icd-libopencl1_2.3.3-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "b80867cdf7a40cf127e39d30e2b1ee88"
SRC_URI[deb0.sha1sum] = "7ba38fdb1863c04e02cf20c91a0a6bcc35ffb5eb"
SRC_URI[deb0.sha256sum] = "99dfd409ae92505ee56742feea4e82a1e052818c5b0036ee618a371b5e28c9d1"
SRC_URI[deb0.sha512sum] = "8524f033e479a4c0e727c53134669eca153243ee217ff9908cc1e24a96340efb7fa8d554fc4540f1a7274d47158ed357d50a845509e833c116b69f3464cd0929"
SRC_URI[deb1.md5sum] = "e0dcd99547d2b37802dfce5601738a67"
SRC_URI[deb1.sha1sum] = "2c57b5c996d25db192230eda822d4986d3c0ca6d"
SRC_URI[deb1.sha256sum] = "eadc1b9341c36dbac2ad2f1ae159f55533512cec888425d53e42abacd814742b"
SRC_URI[deb1.sha512sum] = "a93b15ec8479f5a2304b9271642d2ea4fbdb48e36d45c19b11cd35f608712baf083d8cdecdffe8717017e9918b3292dad1ef7fa8a1671a74ab7ae5034849d4f7"

RDEPENDS = " \
    libc6 \
"

RPROVIDES = " \
    libopencl-1.1-1 \
    libopencl-1.2-1 \
    libopencl-2.0-1 \
    libopencl-2.1-1 \
    libopencl-2.2-1 \
    libopencl-3.0-1 \
    libopencl1 \
"
