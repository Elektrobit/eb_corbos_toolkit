# This was autogenerated! Do not modify
SUMMARY = "Ogg bitstream library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libogg"
HOMEPAGE = "https://xiph.org/ogg/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libo/libogg/libogg0_1.3.5-3+b2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libo/libogg/libogg0_1.3.5-3+b2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "67b028052107849a5983e6ef1244360d"
SRC_URI[deb0.sha1sum] = "0127c9f82ed94b60b9df91af15966fd89d59a389"
SRC_URI[deb0.sha256sum] = "911aec914f5bda0788164ff8068b682537378bf8d407b1d6c1b377522f96b83b"
SRC_URI[deb0.sha512sum] = "6fe811bb9481569ef255cd2cef4ce69c83ab35d860af3de273559d567d14f2bf5f40be1fb60ecefe4b539911b48de278d89099605051e9065fac40a1ba6f979f"
SRC_URI[deb1.md5sum] = "5aa663314b0df415daf5c862d979ae87"
SRC_URI[deb1.sha1sum] = "dc0010c88284b88a4f92bb983ca2ec92b91c34fc"
SRC_URI[deb1.sha256sum] = "d59a83ab352bf0c16ce9513fdf264f87214813ca8c628c652801ef476ece8286"
SRC_URI[deb1.sha512sum] = "39cf5fe5e54fb93add0178ef0f5fc371654161986b9c305c7f61518cdb8e280a2b18a6482a389cc07b96d165fe0a65ee3c6fcdc2370ca0b714215753119944b7"

RDEPENDS = " \
    libc6 \
"

