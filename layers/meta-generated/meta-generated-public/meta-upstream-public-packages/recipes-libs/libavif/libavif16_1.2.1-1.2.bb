# This was autogenerated! Do not modify
SUMMARY = "Library for handling .avif files"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libavif"
HOMEPAGE = "https://github.com/AOMediaCodec/libavif"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/liba/libavif/libavif16_1.2.1-1.2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/liba/libavif/libavif16_1.2.1-1.2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "c1583daf87a2cc83a8a311be3f4bc3b5"
SRC_URI[deb0.sha1sum] = "05d111176ddeccc069dae07a8fe13031bdc6b7ec"
SRC_URI[deb0.sha256sum] = "ba6c334454d3562560ad583fbe2c998e203b0fc5a0e0e91112ddcd3cff4704bb"
SRC_URI[deb0.sha512sum] = "e669cd4ea70dc53ccd1e0acff9d6246bc9b1dd48a18055ade2352d38979b6244d23e7ef1c522f4adf5cf700c721de849b10425d793d3bcd19745a750ddd5ddbe"
SRC_URI[deb1.md5sum] = "6c3aeec297de567c4768e43fcd01cbaa"
SRC_URI[deb1.sha1sum] = "4e27be989e083e4461691089881c798b1d75e5dd"
SRC_URI[deb1.sha256sum] = "1435e95c019f54b062b5526119664121dbb05d2b76f50f6733f90abc2ef700bc"
SRC_URI[deb1.sha512sum] = "c0eb616321d82af48de98bd150939aa7ec8994f57cf07af5ca36d037f781f83f4f3716d3c6ed9aa0368bc5b40744f3a55da8027c8af1c617bb5d31eee5805abc"

RDEPENDS = " \
    libaom3 \
    libc6 \
    libdav1d7 \
    libgav1-1 \
    librav1e0.7 \
    libsvtav1enc2 \
    libyuv0 \
"

