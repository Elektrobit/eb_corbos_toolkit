# This was autogenerated! Do not modify
SUMMARY = "tiny C SSH library (OpenSSL flavor)"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libssh"
HOMEPAGE = "https://www.libssh.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libs/libssh/libssh-4_0.11.5-0+deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libs/libssh/libssh-4_0.11.5-0+deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "cf348ab283fc2187fc8c0ef68a859635"
SRC_URI[deb0.sha1sum] = "c281a5c8dc2a807fcfadcafc4ea96212708496ab"
SRC_URI[deb0.sha256sum] = "bc8cbc13617d1b21fa6f686f9f269a4f849f00624d5bb179785a058981701233"
SRC_URI[deb0.sha512sum] = "32fed66101564fb5f7823a2ce2edfec6d6e7a5dc55c5fcc7a97fffa006f650789562a261bbe3f01cda71fe4a7ce05b6dd7398c86cf9c6dfd4f5a8cdcff3cb5ff"
SRC_URI[deb1.md5sum] = "8ee964d820fdcd35bb89d813cf32bb13"
SRC_URI[deb1.sha1sum] = "2e7722d8ae134a5838a91b8e06f589e44445e7e5"
SRC_URI[deb1.sha256sum] = "bc70c157a3850050e256d293be0e5a851b1f98ae6dd4e31b2c7d237b670eb1c9"
SRC_URI[deb1.sha512sum] = "3288028252e6f8d0f12753e7ac1f9ea6b56e4e372b4ae7778d4f665c63cee5cbc84a04ac44faff259cdcde7a020a62d127152cd794e580bf6dcdafbb73acac02"

RDEPENDS = " \
    libc6 \
    libgssapi-krb5-2 \
    libssl3t64 \
    zlib1g \
"

