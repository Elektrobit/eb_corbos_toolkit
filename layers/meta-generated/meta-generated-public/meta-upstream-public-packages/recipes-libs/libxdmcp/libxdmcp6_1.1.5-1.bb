# This was autogenerated! Do not modify
SUMMARY = "X11 Display Manager Control Protocol library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libxdmcp"
HOMEPAGE = ""

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libx/libxdmcp/libxdmcp6_1.1.5-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libx/libxdmcp/libxdmcp6_1.1.5-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "94f9ea6d11adfdd4fa1469e8648f08ff"
SRC_URI[deb0.sha1sum] = "63f1d1dfe27c54257297c70aad3862682e09d0fd"
SRC_URI[deb0.sha256sum] = "0740dc760916b2008b45417a42a8fd7dd5de370fb57d31373f15034cda8acf0b"
SRC_URI[deb0.sha512sum] = "6e90e7a5cc0cf6a3cda95570f4912af3710208fec94525a37708d816c00390f9ecbdd264414386b859382ffceaf611758d56009139ef11691b81e0f37719dc40"
SRC_URI[deb1.md5sum] = "bcb4b474ffcbee3748dead6f00d466bd"
SRC_URI[deb1.sha1sum] = "c9ad9b7de45a31b874b5d81f43a1788090a1371e"
SRC_URI[deb1.sha256sum] = "e10bbb0802181992ecf091e9425171850eee16068729c109214ba4924f81fb52"
SRC_URI[deb1.sha512sum] = "02795034122fd9f98f544531418605a0089d522fb8092e78f5d5137e0a17c7264a6969f8638692b3595750c925eb5c04c48c0c11ea2973cae1946de91b10e453"

RDEPENDS = " \
    libc6 \
"

