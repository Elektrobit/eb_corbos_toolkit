# This was autogenerated! Do not modify
SUMMARY = "SELinux library for manipulating binary security policies"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libsepol"
HOMEPAGE = "https://selinuxproject.org"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libs/libsepol/libsepol2_3.8.1-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libs/libsepol/libsepol2_3.8.1-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "ff21bab0f78f4fa6728a412fbfb9bbad"
SRC_URI[deb0.sha1sum] = "a4ec74f05fba7eb2f69b32cfd63e9ecdab8c51c5"
SRC_URI[deb0.sha256sum] = "3595d2d3a6d24695e7953f4f00cdfe6974c9242d9a8dfee8998e77fbf7b2ba09"
SRC_URI[deb0.sha512sum] = "1f90ce8550d1b6328174107ca903e51e3ce87ff70143bb832681bf7f930a37132ed7a358c20c2f13811507916bff9b2566d9901ec2105c807463c92eeed82d2e"
SRC_URI[deb1.md5sum] = "18c9d3b0c5cb95b53d4e7b3a31a2f32b"
SRC_URI[deb1.sha1sum] = "06c04dd287d6d0a6fef1c02fb680e6a05184a845"
SRC_URI[deb1.sha256sum] = "0119cbb4d12a6b5093430a00714019bac87a446f34f21d834453742f1af35b8b"
SRC_URI[deb1.sha512sum] = "6cfee6393af43a4aee2a56f20c6ba64b63ab9e9ec9c7a569df63b2f399cb5e4628a83f012d7ae79ecfb4a10229ad353f5a41f4de31d2c58828335bc7fd336747"

RDEPENDS = " \
    libc6 \
"

