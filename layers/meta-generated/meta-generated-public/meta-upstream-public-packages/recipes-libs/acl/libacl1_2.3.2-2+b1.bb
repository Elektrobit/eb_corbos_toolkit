# This was autogenerated! Do not modify
SUMMARY = "access control list - shared library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "acl"
HOMEPAGE = "https://savannah.nongnu.org/projects/acl/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/a/acl/libacl1_2.3.2-2+b1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/a/acl/libacl1_2.3.2-2+b1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "e9a3f4f9c1e4b225066d5102567f2fe6"
SRC_URI[deb0.sha1sum] = "53f2b0612c8ed8a60970f9a206ae65eb84681f6e"
SRC_URI[deb0.sha256sum] = "08074f01e384bc07c0c2d79a58cf4a6523f71cf75d1808101c79617656c9a39d"
SRC_URI[deb0.sha512sum] = "4a747908e80442e32af00e34662666b829e171cb6c2c7c0ad98d449a03a4d647e41ab3883711a54859e4e6297e85985fb18e2f28038c7b3cb6d095acc4618deb"
SRC_URI[deb1.md5sum] = "cda23fa6ffee4760f7d58f926761f079"
SRC_URI[deb1.sha1sum] = "4f8e9f411632e7dbed968f903a605b71b28ba57b"
SRC_URI[deb1.sha256sum] = "10b2399169e42e6d8db55944116cb2ed61caab997cf700acb83de0b0668e5721"
SRC_URI[deb1.sha512sum] = "288b4ca5d8a4f3c4dc6c7af464d12567c669b5357c2bec0eea95bbe324bb46dd2525d3cc894877b322130a5d44bd87c0508abf362ce3eff5c16b8cee626bef2e"

RDEPENDS = " \
    libc6 \
"

