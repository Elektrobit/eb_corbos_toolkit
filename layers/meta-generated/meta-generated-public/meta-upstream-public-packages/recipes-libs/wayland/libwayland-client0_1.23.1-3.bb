# This was autogenerated! Do not modify
SUMMARY = "wayland compositor infrastructure - client library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "wayland"
HOMEPAGE = "https://wayland.freedesktop.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/w/wayland/libwayland-client0_1.23.1-3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/w/wayland/libwayland-client0_1.23.1-3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "c394695dccdc96243173a5699fe0b184"
SRC_URI[deb0.sha1sum] = "b0b02ae2b556f1a811c46c7f38acc40914757d93"
SRC_URI[deb0.sha256sum] = "d1607e1db1a7c5378a2e5c6ae7b20f64dc6acf134f953d84a7f5204b74339f33"
SRC_URI[deb0.sha512sum] = "14cb0d9275dcd7cc29bb557140c033102f8246a93e3dcce25910ad1603137210f58cb94c906a43ac6372876862d76905c2ecd036153208c110038914d678af62"
SRC_URI[deb1.md5sum] = "a83235785951590a305e0328220789eb"
SRC_URI[deb1.sha1sum] = "a6f134475b0bbc6f028465bb80ec3cf0bdb20115"
SRC_URI[deb1.sha256sum] = "8abdc649e46470548c545f827e16f52e1bc16d05d4a3794e6dedb2d74ce58c9a"
SRC_URI[deb1.sha512sum] = "fc5a909bc1d7fdff6e38898694f4d8a754e98a486e659bad010990cd27ff1d5327c9e81d95892ffd1d4a5b6cb552c2cb87dfd6ed5aba39c6aca77b2a028743b7"

RDEPENDS = " \
    libc6 \
    libffi8 \
"

