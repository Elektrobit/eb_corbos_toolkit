# This was autogenerated! Do not modify
SUMMARY = "wayland compositor infrastructure - EGL library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "wayland"
HOMEPAGE = "https://wayland.freedesktop.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/w/wayland/libwayland-egl1_1.23.1-3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/w/wayland/libwayland-egl1_1.23.1-3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "7a63e8456ba8c555c69d073ecf0d21e7"
SRC_URI[deb0.sha1sum] = "7e3ddd82bdffb7ad2ae9866fbd79724d77f72107"
SRC_URI[deb0.sha256sum] = "7c5c3429028b39b9432792db08cb218c43891df439ebc648b83ebee676a80ec5"
SRC_URI[deb0.sha512sum] = "7c95c9be6828044366ff6b09879bdf4eb90293db6bf467fc1c77023c025ec900d0804d9ab1968016e2356e0e0da76fcebdee7e7ec93af9bee4397e5d376d2576"
SRC_URI[deb1.md5sum] = "aa2f20ef6f78948fd7c26d2d23c24b3f"
SRC_URI[deb1.sha1sum] = "13e3e994a8628f68e49998f2684fd9904100c686"
SRC_URI[deb1.sha256sum] = "fe01fb2f3c5d5b54784563d9826fa505fab61dc30333d71343352bddd3812b18"
SRC_URI[deb1.sha512sum] = "c76e3d8b41bb2f4b388f9b03ea93e3686ee46206805022050e4cd71f71c4c8a82dd7efcdc5103226ac95ecbfb1c1d9e97159e41e573c33e154e4d201ed225659"

RDEPENDS = " \
    libc6 \
"

