# This was autogenerated! Do not modify
SUMMARY = "wayland compositor infrastructure - cursor library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "wayland"
HOMEPAGE = "https://wayland.freedesktop.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/w/wayland/libwayland-cursor0_1.23.1-3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/w/wayland/libwayland-cursor0_1.23.1-3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "b3472a9c3a41fc922671329bc080ed39"
SRC_URI[deb0.sha1sum] = "6ea4e4116e0e4fa99aead4aedb8591a169a1b6db"
SRC_URI[deb0.sha256sum] = "26fccae2b1228744de0cad6c688550b8d13cd4e8d4ccf0cfdae015634ece673f"
SRC_URI[deb0.sha512sum] = "351a84adeb1aaf0860f450139921577997a2fc053294326369d1930d21ebbac58a236a162957e4128a22acbe65c277efb48f386af03adab4bdd86910df5738db"
SRC_URI[deb1.md5sum] = "096bd02a8515b7e6efc80a7a87a55a28"
SRC_URI[deb1.sha1sum] = "9d765bc38ad7aac804dc536f397751a9acb4ea8e"
SRC_URI[deb1.sha256sum] = "824c1ca46458530a670bfd003f1c083e66e395e1800c294a22af38641ccdc11a"
SRC_URI[deb1.sha512sum] = "e69222f9034ce56b3b5abe51eeabddb8f850d4949725faaa82bdab6ea1959993067cdb1f6a05eb118074cbfea7cec164792366a79b1ed2ba5614f4b299cacca2"

RDEPENDS = " \
    libc6 \
    libwayland-client0 \
"

