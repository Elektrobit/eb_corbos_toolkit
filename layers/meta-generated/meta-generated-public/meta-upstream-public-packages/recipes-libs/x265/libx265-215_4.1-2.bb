# This was autogenerated! Do not modify
SUMMARY = "H.265/HEVC video stream encoder (shared library)"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "x265"
HOMEPAGE = "https://bitbucket.org/multicoreware/x265_git"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/x/x265/libx265-215_4.1-2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/x/x265/libx265-215_4.1-2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "2f1bd5eb56ec1faa915d76f0d746c8e2"
SRC_URI[deb0.sha1sum] = "aa9c453cda1e06f88b8f6d312c860ebfb7f6eae8"
SRC_URI[deb0.sha256sum] = "4bb075b465dbc136b0c5050b956432ea7e443a16d592aa89ef28bcaf4b0ad734"
SRC_URI[deb0.sha512sum] = "176e351d9c37c4507d082aec77864352db936f5912eec4515bb9636894923e0b91f282f1c74d79d1a78c5d460fc4d9acc025cdb626694c3409e5f575a6f70e7b"
SRC_URI[deb1.md5sum] = "76177e3289f421deab8bd87068d9cc4e"
SRC_URI[deb1.sha1sum] = "3216747749acba082e75bde90eae0235232bb78c"
SRC_URI[deb1.sha256sum] = "c786ffe37393781b39fa99100aaa93891436dc0d8e0a4a5209cc1102679ebe22"
SRC_URI[deb1.sha512sum] = "65b27bf655d96227f4a4a7458292f45719e79695fab067d35bef68157b534db92b369fc37cac210454c38f0c413f5e24b77a3ed027dda8a2904942fa1a5db925"

RDEPENDS = " \
    libc6 \
    libnuma1 \
    libstdc++6 \
"

