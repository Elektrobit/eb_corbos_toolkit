# This was autogenerated! Do not modify
SUMMARY = "RPC protocol compiler and definitions"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "rpcsvc-proto"
HOMEPAGE = "https://github.com/thkukuk/rpcsvc-proto"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/r/rpcsvc-proto/rpcsvc-proto_1.4.3-1+b1_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "ba5aba8ca6f62471d31fb924ca310ca0"
SRC_URI[deb0.sha1sum] = "c95a412e9bee64b98acf97d8bc36017fd9a9105e"
SRC_URI[deb0.sha256sum] = "6ae3c216e6c7d8e042ad3f122b8aa89aff56b2b5174b1c5780a7841b3becd61c"
SRC_URI[deb0.sha512sum] = "c4e9af2391248ac55479dbcff5f47878a8d8a0d3c8ea960a3fb00cf2cd5a7021e956b8b72bdff4441ee76c3d872b477c98b264e7e8eecc763e425c7098e1e883"

RDEPENDS = " \
    libc6 \
"

