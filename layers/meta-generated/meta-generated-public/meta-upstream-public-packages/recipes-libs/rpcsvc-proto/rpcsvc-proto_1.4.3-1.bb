# This was autogenerated! Do not modify
SUMMARY = "RPC protocol compiler and definitions"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "rpcsvc-proto"
HOMEPAGE = "https://github.com/thkukuk/rpcsvc-proto"

inherit dpkg-prebuilt

DPKG_ARCH = "amd64"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/r/rpcsvc-proto/rpcsvc-proto_1.4.3-1_amd64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "863959fc5bf804d0e575681f5b1ba374"
SRC_URI[deb0.sha1sum] = "42fc22c76dade04c99d8a23141a5fe12d46ae697"
SRC_URI[deb0.sha256sum] = "32ac0692694f8a34cc90c895f4fc739680fb2ef0e2d4870a68833682bf1c81a3"
SRC_URI[deb0.sha512sum] = "da5e13d757634463dcca49a6c7c392ddf27e44d13358621e4afac6ee1f934242cff1c057a7bfb95ede8e9b3e3f8b3388dc6c8d18b3ec17e01dd1c8d0a6980afc"

RDEPENDS = " \
    libc6 \
"

