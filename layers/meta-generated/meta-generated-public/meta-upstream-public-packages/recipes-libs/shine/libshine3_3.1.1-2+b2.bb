# This was autogenerated! Do not modify
SUMMARY = "Fixed-point MP3 encoding library - runtime files"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "shine"
HOMEPAGE = "https://github.com/savonet/shine"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/shine/libshine3_3.1.1-2+b2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/shine/libshine3_3.1.1-2+b2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "7c22a5a93eec8cfac04b39bcd4205cba"
SRC_URI[deb0.sha1sum] = "492adfeb544ff57511ce158bb593540418fc0a1a"
SRC_URI[deb0.sha256sum] = "8908eb0c70893d122ee9cbed7186736ad94b45716404ef9622845bdd7d17b29d"
SRC_URI[deb0.sha512sum] = "08f6aa1440dc85e042495b326b52a3a7859fcd8f7136ba925a58d92b4362127818f75bdb4e9ff20535b00e37282d1fdc231ec13fee7b15a613ba1a1b67bbd8b3"
SRC_URI[deb1.md5sum] = "fa2dc97dc3362a16aae83acca1275599"
SRC_URI[deb1.sha1sum] = "1f24b7390b5fc4fecb246fd8ed99db39f497fdd6"
SRC_URI[deb1.sha256sum] = "d54a5f7154c0e826338bb18c34c69de9a036f3264adf59cef39bc30f07baa6d0"
SRC_URI[deb1.sha512sum] = "157800667c03456eb7478debda62dbd954eb9e21467985849bc23faaaa94ce3243c3879bc4766a65f58617c5a9e793fa037166f7d7823ed5f10b9076485a2231"

RDEPENDS = " \
    libc6 \
"

