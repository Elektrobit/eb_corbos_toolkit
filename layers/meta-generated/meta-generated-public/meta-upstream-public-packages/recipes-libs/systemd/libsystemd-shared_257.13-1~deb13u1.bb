# This was autogenerated! Do not modify
SUMMARY = "systemd shared private library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "systemd"
HOMEPAGE = "https://systemd.io"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/systemd/libsystemd-shared_257.13-1~deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/systemd/libsystemd-shared_257.13-1~deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "bfa65036ae8d578a3989a268e6c45036"
SRC_URI[deb0.sha1sum] = "f66c9933019d8dea904f6c0e036a4c91518d897e"
SRC_URI[deb0.sha256sum] = "2d349824e57f88507e2a33360610d8afc143a4ad5e80ee4bf8f37b826d6f37f9"
SRC_URI[deb0.sha512sum] = "ca5764a3a811126457362b5aca24e670601d1c56c0f8edf460c2b0f9e6a0212d202196f9dab6b53682f30b108fdbe54fcaa5ee17933def28cbc000a4c4ce6d48"
SRC_URI[deb1.md5sum] = "53b27e42d5ca6083ad65e77ae2559a57"
SRC_URI[deb1.sha1sum] = "f9eef5ad1f219a23d46c11740d65a4bcc00cb9b5"
SRC_URI[deb1.sha256sum] = "b48df445566ff6c39395c9fc571524c9e03803bc2e434d7869fc21e723c64b4d"
SRC_URI[deb1.sha512sum] = "f87978fdcb54e1da30d9342a508899546d7a7c47103eb9202c73808213822075fe55b43523e1fd531d65031f35de2ae4a4aef26d51dc56e346373ddbcb8027cc"

RDEPENDS = " \
    libacl1 \
    libaudit1 \
    libblkid1 \
    libc6 \
    libcap2 \
    libcrypt1 \
    libmount1 \
    libpam0g \
    libseccomp2 \
    libselinux1 \
    libssl3t64 \
"

