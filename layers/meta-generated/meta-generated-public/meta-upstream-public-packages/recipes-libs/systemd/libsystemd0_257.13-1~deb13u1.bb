# This was autogenerated! Do not modify
SUMMARY = "systemd utility library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "systemd"
HOMEPAGE = "https://systemd.io"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/systemd/libsystemd0_257.13-1~deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/systemd/libsystemd0_257.13-1~deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "d0c6b2615647d5f983b761695566bf51"
SRC_URI[deb0.sha1sum] = "638ec3b8b73704259155db4463837046ac280c09"
SRC_URI[deb0.sha256sum] = "ab0d4127b5e46e6f8c015a1db15a62ba9ae274cdefa150083adf90ada0600ea1"
SRC_URI[deb0.sha512sum] = "125a810fb58e17ae09716042e0b8dabfb1943350927061b2623d3f274e959e3580fcf72301268c108668470e5c80f81b847b37eaeeb3255c9fdb6d4d263ae655"
SRC_URI[deb1.md5sum] = "f9b47dfbbe5af4fa7250661b0befb5ac"
SRC_URI[deb1.sha1sum] = "12182690ab7a5cafb5bfe829891b8e145e85910c"
SRC_URI[deb1.sha256sum] = "d2f63c408549c29eaefb6f4c948393edce99f45ee8e43c991391bef63fb7d54b"
SRC_URI[deb1.sha512sum] = "e6b9d3d63fd0f36dc0a0ad67f606fd1c2d0c2e717f4f4fb2471cd41ad6a3d95f44a4c810773b64c204b5b96ae705a4f13605c4eec27a831d915388bd6bf726f2"

RDEPENDS = " \
    libc6 \
    libcap2 \
"

