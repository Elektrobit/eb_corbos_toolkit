# This was autogenerated! Do not modify
SUMMARY = "libudev shared library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "systemd"
HOMEPAGE = "https://systemd.io"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/systemd/libudev1_257.13-1~deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/systemd/libudev1_257.13-1~deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "98d221263b315d7833ec4bc932fb36be"
SRC_URI[deb0.sha1sum] = "f47bf0f66480e70f4b275c7225cb613b01829d85"
SRC_URI[deb0.sha256sum] = "5d41c284f5a93b05bc7d648b61a02dd2bb9ff05b2261ad1a8b7d96044a0cfa88"
SRC_URI[deb0.sha512sum] = "af7791ced811aeca7be1a8af415a60f325a54e7c51938e6c7c6be80fb342d1c1d613abd6a841688211e3deffa5ab45223b35bb85efb8f4cc35a34e69a048d5b4"
SRC_URI[deb1.md5sum] = "44fbdd0dbaf630ce7ca8ab508f5ba1e7"
SRC_URI[deb1.sha1sum] = "8cd4ebb59c350a4214d6e45398cbe3b558940ab2"
SRC_URI[deb1.sha256sum] = "459b1c9c17cc3c586e90d13d2a991715d498c6eed6c046cabf321021167bc380"
SRC_URI[deb1.sha512sum] = "abc3b4607ab51b19b4556645ad3ce1626593e823c57cf1b85f4c802fa406ef291fa9d6a7de34586a630eb1da68ff3e3d440cca578ec6d01f475c04533defdc3e"

RDEPENDS = " \
    libc6 \
    libcap2 \
"

