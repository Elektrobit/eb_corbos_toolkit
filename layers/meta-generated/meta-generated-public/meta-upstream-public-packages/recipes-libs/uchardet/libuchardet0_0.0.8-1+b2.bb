# This was autogenerated! Do not modify
SUMMARY = "universal charset detection library - shared library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "uchardet"
HOMEPAGE = "https://www.freedesktop.org/wiki/Software/uchardet/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/u/uchardet/libuchardet0_0.0.8-1+b2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/u/uchardet/libuchardet0_0.0.8-1+b2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "7d8280f7f60cd6342663cbb04a7d68fb"
SRC_URI[deb0.sha1sum] = "2009337b0d42ff7bb2e102655962e3ede6e3c53a"
SRC_URI[deb0.sha256sum] = "eb772a1649d900ac46ffeab61a8b911e81d571f88ef5dcd0eed9aad5b45b003e"
SRC_URI[deb0.sha512sum] = "a84c97ebe8dc06392f3644c598d3190e2d0c2e24a2e69084c74f9c1cc5e0bf47b9cbf616e947ada90bd6eb6680ed7d11ad40311111ef2eca7ad9b5907ad7e7f9"
SRC_URI[deb1.md5sum] = "02dbbcc3a6fc3f85486f014e75be5f93"
SRC_URI[deb1.sha1sum] = "38f2b9792782fa2f6984fe6fdbffecb5027eb025"
SRC_URI[deb1.sha256sum] = "38146ee97c8327fbe80f141c0307295e35e7750807c69d660c8db68c3c96a63b"
SRC_URI[deb1.sha512sum] = "676b092ea4ef90a1481d2e6b98cb60b73c7a96c5dfa24ddbb46d97b6c6a91e7796102a84a7cb25d3279d4b6aa23e42d27582c6ab13836b77f0ca36d4dd2cdc40"

RDEPENDS = " \
    libc6 \
    libgcc-s1 \
    libstdc++6 \
"

