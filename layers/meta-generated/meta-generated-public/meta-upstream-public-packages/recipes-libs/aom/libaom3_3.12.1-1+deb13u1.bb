# This was autogenerated! Do not modify
SUMMARY = "AV1 Video Codec Library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "aom"
HOMEPAGE = "https://aomedia.googlesource.com/aom/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/a/aom/libaom3_3.12.1-1+deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/a/aom/libaom3_3.12.1-1+deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "af6c0449754a8c6a219ecd5f11c54f70"
SRC_URI[deb0.sha1sum] = "10bbb28b6e0f3e2439f9a83acd615c409e5b7fab"
SRC_URI[deb0.sha256sum] = "743eec7c94ae30295bc557ebac3dfae948e7390e89a2743c585d56297e9d312e"
SRC_URI[deb0.sha512sum] = "28f6ba38e4eb6eef538ebdb36676ca3738c57a34c6f51690ab7394fb923471838a6adf6746d4523e9c9558380f0a13cd923ef61529def5184f4c419c2d7622e8"
SRC_URI[deb1.md5sum] = "02a13e1ce4b2a81bbe74ff5929329c67"
SRC_URI[deb1.sha1sum] = "2df3419f1ff8be8ce001e80a7a987b7c4a605c71"
SRC_URI[deb1.sha256sum] = "552e2bd21772a39713a0c63e814039f558b355d048f0d0bfc4009658253cc1e9"
SRC_URI[deb1.sha512sum] = "35612ea116fb90a6081976a6805822e1241eac03cd7505248ed1a50f0716423c4dc50360080f87e338790e8768209e244b21e7fbea90c9f817d27a71edcc8146"

RDEPENDS = " \
    libc6 \
"

