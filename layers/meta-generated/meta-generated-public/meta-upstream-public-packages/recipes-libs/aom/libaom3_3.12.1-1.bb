# This was autogenerated! Do not modify
SUMMARY = "AV1 Video Codec Library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "aom"
HOMEPAGE = "https://aomedia.googlesource.com/aom/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/a/aom/libaom3_3.12.1-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/a/aom/libaom3_3.12.1-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "c7dffeadfdb1999123bdbf14b3e91253"
SRC_URI[deb0.sha1sum] = "d8cd6332973da7765c8210e657882014f2c4914d"
SRC_URI[deb0.sha256sum] = "16321210c4a3e27bf5ad1d56c1f09c9f7958f0c8ec3b8ae894ea1be322c5d055"
SRC_URI[deb0.sha512sum] = "4ee0f3f9afadffba6492d8c578960a0d4e9af9b67d6fdbb3d6fcd8894a272bf67ef25caca2a7d7f29c5968f8fb44502dc059462d503e43c459bcc905a5f33388"
SRC_URI[deb1.md5sum] = "2fbb7310bb9f4a09cd703fe8830fb900"
SRC_URI[deb1.sha1sum] = "f39dd6b5cc7c1ee0ba5d2091abb1aef4d1fdbdc4"
SRC_URI[deb1.sha256sum] = "212d41a189b5b8e168cfcfe355a9e97de3c9d7867f71e6f0b6bf88a66352b809"
SRC_URI[deb1.sha512sum] = "7a03e22239fc3bcfd41ad868ad6f0767aa7a41c3cd3538e45f334db7edea226ef3e9caa0dfa9fad474832ecb629f2e4601d6457c1615a584aedf309aae3af5c7"

RDEPENDS = " \
    libc6 \
"

