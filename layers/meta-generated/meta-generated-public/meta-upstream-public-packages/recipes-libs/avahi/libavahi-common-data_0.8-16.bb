# This was autogenerated! Do not modify
SUMMARY = "Avahi common data files"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "avahi"
HOMEPAGE = "https://avahi.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/a/avahi/libavahi-common-data_0.8-16_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/a/avahi/libavahi-common-data_0.8-16_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "8936b03ecb290dc02cc3b6c546b9f7e8"
SRC_URI[deb0.sha1sum] = "94dcac792bfa170ef0bb5f86925a6d45862b9c17"
SRC_URI[deb0.sha256sum] = "a3c0cb1326ed60cbbef133c31af28759f7a922d886d001a138d52bbf0af908d6"
SRC_URI[deb0.sha512sum] = "46670c63e77fde0a92059c99dc89cdbe118c0c177e5ffa52ad6654b0da1a9394c575d51ac0f9bc6e28218d9666237fbcf61f492b9b39035884ec7371e8cd66a7"
SRC_URI[deb1.md5sum] = "a5cdaadadd634fa12ed0b8c42f04957f"
SRC_URI[deb1.sha1sum] = "1f73f053f9bc40c093e223777516708cc80f768c"
SRC_URI[deb1.sha256sum] = "75d80488f931f6cc577aaf366b1a17099bd4d0c179dfd33d014f564094255da9"
SRC_URI[deb1.sha512sum] = "9a2be706a36bf5a0b0340f5d142a63ce197f1f6ee6291e00dd0f878d733a2aa9c5e9efe4f0f479d9f0ba0f297e0c52e1ff4967a3e73dc07c2bde84d8fa812ce5"


