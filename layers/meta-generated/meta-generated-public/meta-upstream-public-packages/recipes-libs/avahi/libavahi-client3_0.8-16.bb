# This was autogenerated! Do not modify
SUMMARY = "Avahi client library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "avahi"
HOMEPAGE = "https://avahi.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/a/avahi/libavahi-client3_0.8-16_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/a/avahi/libavahi-client3_0.8-16_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "45a207f75278c74820a830642f4cd532"
SRC_URI[deb0.sha1sum] = "152521dc3e5b0921413687d638264e950baf3552"
SRC_URI[deb0.sha256sum] = "27df3f1c0190d13ec6d014c5515c2ec8e9a49d0983f48fc9e5756ee4e62d7e37"
SRC_URI[deb0.sha512sum] = "ba500229f1a66523d0ddb7bc20b80057b324b6cbf49c48c4d5b3f37a03dab4d5878e94f4b6c76ac620f4d09d86cb70909287baee0d12ad1b0091ed4322e08d19"
SRC_URI[deb1.md5sum] = "98b875e34b1c8592efe0983101abf764"
SRC_URI[deb1.sha1sum] = "19d4a0d2fc8f831d4fb3de8170f27d04262ea3d2"
SRC_URI[deb1.sha256sum] = "aad7c1a4f0e8b9131881ebdd61150bb9e15f11534aafe4877e61fefc266f1586"
SRC_URI[deb1.sha512sum] = "9f0e2c66f4ead6accb2abbc93a397ba1babab5c6ad4d8a59e6b2d8c9bc5e9329ec92718da8ff43eb63dabad09811ed3fbb3a3e953b98e8899117c781dacb7b6d"

RDEPENDS = " \
    libavahi-common3 \
    libc6 \
    libdbus-1-3 \
"

