# This was autogenerated! Do not modify
SUMMARY = "Avahi common library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "avahi"
HOMEPAGE = "https://avahi.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/a/avahi/libavahi-common3_0.8-16_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/a/avahi/libavahi-common3_0.8-16_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "9e3786375c17bb7fbaa5a6f61225df13"
SRC_URI[deb0.sha1sum] = "a67d85b78cf895a3ac5ddac6e3a28a7e5a8c5cb7"
SRC_URI[deb0.sha256sum] = "fb092fc55f1c7f3db0ac64467f30ebae8145543570b8e99f17ce84cf1dd28bb6"
SRC_URI[deb0.sha512sum] = "80746fce37d5384a525a7441d5399d25114ee54a1677a0807dd8640594bab859df934aca84f31976df3304acbd21bde822c445176709e7f99c7428a468658cd7"
SRC_URI[deb1.md5sum] = "fe3719e849dcfb18af3bfb930d8bc6f7"
SRC_URI[deb1.sha1sum] = "4634099f51491d9077f6a95fbde33c3af466e533"
SRC_URI[deb1.sha256sum] = "495d3502dbaed9e71c54cd0030fd135d62140b7c780620cc14a0a8a615adda14"
SRC_URI[deb1.sha512sum] = "f5dc9d2e3b807073c00fe7cfb119eae4950832bdca46e39756717c938376e57cccf4068bdae4007e3bfd5a68d73ed38758b041ff05700dd6628a14c5d92be72c"

RDEPENDS = " \
    libavahi-common-data \
    libc6 \
"

