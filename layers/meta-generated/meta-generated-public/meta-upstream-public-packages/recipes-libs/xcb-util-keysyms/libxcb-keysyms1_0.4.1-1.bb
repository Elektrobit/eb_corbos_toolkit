# This was autogenerated! Do not modify
SUMMARY = "utility libraries for X C Binding -- keysyms"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "xcb-util-keysyms"
HOMEPAGE = "https://xcb.freedesktop.org"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/x/xcb-util-keysyms/libxcb-keysyms1_0.4.1-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/x/xcb-util-keysyms/libxcb-keysyms1_0.4.1-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "b0b88542bb21c67f8edf750a4364c4dc"
SRC_URI[deb0.sha1sum] = "2a740f96c46a97efe924740919e69143749f84e9"
SRC_URI[deb0.sha256sum] = "6989138382e5b9966aa731db68f851858c1d40cf8c98d7e5d7952c9e5a09d710"
SRC_URI[deb0.sha512sum] = "85945506da44476bb7bce5aca1c9a7fc32e7f969e0207a15d1ecdee5bcb6feb6b7d7f477face2fdfe43650fe46a74902ab743f2e952b2fb57f0d8813dc3d0f99"
SRC_URI[deb1.md5sum] = "992ef132055e77b4ebf6ac31c12d8606"
SRC_URI[deb1.sha1sum] = "f6705ea32d8b36ba9e473b8e2168afb501244b14"
SRC_URI[deb1.sha256sum] = "aa1d09f42d23dc8fb4d7e6069d8d15fe20080f8574321220bcf0d028c8e7a57f"
SRC_URI[deb1.sha512sum] = "5a164892a7a728b263ddfd6ca2dd6c8f6b782dcf7a71763115dc1fa4e3c7345df8c7bee4373c951bd52442b97e5336b3920c9a5d13f79e93a5b012ec6e903099"

RDEPENDS = " \
    libc6 \
    libxcb1 \
"

