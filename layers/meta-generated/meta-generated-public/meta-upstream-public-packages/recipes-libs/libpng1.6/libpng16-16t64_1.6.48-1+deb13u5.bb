# This was autogenerated! Do not modify
SUMMARY = "PNG library - runtime (version 1.6)"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libpng1.6"
HOMEPAGE = "http://libpng.org/pub/png/libpng.html"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libp/libpng1.6/libpng16-16t64_1.6.48-1+deb13u5_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libp/libpng1.6/libpng16-16t64_1.6.48-1+deb13u5_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "0cd2789cb2b8855e0a0798c0c5ffb213"
SRC_URI[deb0.sha1sum] = "565c5c9c0d5279036bff64da652ac5f3e0f38885"
SRC_URI[deb0.sha256sum] = "2465b4e9fa85cff54dc10a6da3e64074d8d9292c86e4a8f989b809d6b158e97e"
SRC_URI[deb0.sha512sum] = "1ac0aec835f2ea02f61f5748a5e64afde2c8705b2e5b6e48603f51d7f83351780ae14d27e878428022113eea77199f876f7740ce4e243e31972be576c5dafb08"
SRC_URI[deb1.md5sum] = "c8575c5406ec2b3f6dc05a4e1e0e138d"
SRC_URI[deb1.sha1sum] = "cb76f79eaa8e053872508586ad41688af5b84dc5"
SRC_URI[deb1.sha256sum] = "11096ad43504ca24e8044bcc89e922d932a2812ff25568613b28d22235190ba5"
SRC_URI[deb1.sha512sum] = "9a9f31eac73bb42408fbb8607705d744c202f2b3f999615731557e7c58de9825098d429d3aaa91bbfe920f30533b2a01040f1073091a3c47b1ac253d37ccc81e"

RDEPENDS = " \
    libc6 \
    zlib1g \
"

RPROVIDES = " \
    libpng16-16 \
"
