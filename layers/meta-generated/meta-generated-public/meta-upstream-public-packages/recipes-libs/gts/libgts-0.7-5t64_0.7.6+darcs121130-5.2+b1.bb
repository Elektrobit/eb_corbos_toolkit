# This was autogenerated! Do not modify
SUMMARY = "library to deal with 3D computational surface meshes"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "gts"
HOMEPAGE = "http://gts.sourceforge.net/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gts/libgts-0.7-5t64_0.7.6+darcs121130-5.2+b1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gts/libgts-0.7-5t64_0.7.6+darcs121130-5.2+b1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "47af14fdec8a413060bf2ed3f181a7e9"
SRC_URI[deb0.sha1sum] = "d67124322d435214acefbaa41dec31233978f9c3"
SRC_URI[deb0.sha256sum] = "496e776db876750a6379549630e6a5e411a79b2b66e8eb5105e551ce7aafcf37"
SRC_URI[deb0.sha512sum] = "72ad06695ef6c7a1eacf7699216f1e987d9cd053350731f4e2cda5547f98f75b414fff8241b2bf62b77e7ed816602c328f6a94bc5dda89e31dc1eca5c0683cba"
SRC_URI[deb1.md5sum] = "0a45505edc5f96e9abd070519d3f67e8"
SRC_URI[deb1.sha1sum] = "a3e5c35d32fbd137f3d9fba2580a5211309e7d56"
SRC_URI[deb1.sha256sum] = "82f7b1c63e3e77e0c786e4d07c59e33c8a94fde1c3be6b638f5f937dd8d19654"
SRC_URI[deb1.sha512sum] = "12a7477d82531059ed493a1526a1757f9870057f28ced9f5564a3e84dea8e4d75a562b33589c0686c0d27214884130480edcc4a723e1840bb3f31e18e8c9dd69"

RDEPENDS = " \
    libc6 \
    libglib2.0-0t64 \
"

RPROVIDES = " \
    libgts-0.7-5 \
"
