# This was autogenerated! Do not modify
SUMMARY = "Core GStreamer libraries and elements"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "gstreamer1.0"
HOMEPAGE = "https://gstreamer.freedesktop.org"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gstreamer1.0/libgstreamer1.0-0_1.26.2-2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gstreamer1.0/libgstreamer1.0-0_1.26.2-2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "e3b03b6b5cbb0a61ec6f9de077209a16"
SRC_URI[deb0.sha1sum] = "cd8aba6def097c21470a9e4d4aba8157c30d15e8"
SRC_URI[deb0.sha256sum] = "08b463307fbde5496a346b1bb300b465cd22bd326f6f4634f482bf441af28a9b"
SRC_URI[deb0.sha512sum] = "0e54bed6a739a234ec7d839cdbfcb771ec0db65ea55ee97b8541e0a05687a324d69491d1ddc0881cd2fa2442fe32862976d75f386fd12d5f90fa12d95fe6da28"
SRC_URI[deb1.md5sum] = "ca725781f7a9717700e761b496f84ac8"
SRC_URI[deb1.sha1sum] = "cae089fd87297d574a8a7cbb86c411a52b457a7d"
SRC_URI[deb1.sha256sum] = "77d44e8bc93793f815ea7b8cdb9c1b0b0bf6fd5797e2e69a7ef95bb37f249a86"
SRC_URI[deb1.sha512sum] = "047807b103402c85cd38daf2204ea4f4e5c1becd2574df0b400d8210d85562ba7a1e61ba243adbde629ee13a8ce16d5f8083729a5a76d85dc66cd688bceadf9f"

RDEPENDS = " \
    libc6 \
    libcap2 \
    libcap2-bin \
    libgcc-s1 \
    libglib2.0-0t64 \
"

