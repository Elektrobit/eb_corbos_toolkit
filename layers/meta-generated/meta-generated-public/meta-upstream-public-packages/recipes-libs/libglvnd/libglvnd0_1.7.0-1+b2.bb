# This was autogenerated! Do not modify
SUMMARY = "Vendor neutral GL dispatch library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libglvnd"
HOMEPAGE = "https://gitlab.freedesktop.org/glvnd/libglvnd"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libg/libglvnd/libglvnd0_1.7.0-1+b2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libg/libglvnd/libglvnd0_1.7.0-1+b2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "edae38858e1a62866ca6b73fa24dbb24"
SRC_URI[deb0.sha1sum] = "1cb8e99a46f5b7d8248f3e08482a0f63fb1e423b"
SRC_URI[deb0.sha256sum] = "887f74008166549ce9e100c906aa937e95d6e5ce1c8d86efe8c95fd953359b9c"
SRC_URI[deb0.sha512sum] = "0f7a71a1a2f29faf34e59572c1f58e49c17b2d03b9ab7982aa5ebbe25576329a6cf27ab26e763a7dae6590757fca27f2ccbeee4ba0f368abc0326c3f43045b4d"
SRC_URI[deb1.md5sum] = "a84a9a30a34a997e69ad2d63e772f49b"
SRC_URI[deb1.sha1sum] = "df7527527aafb6caec1274e5c50736a1a6cf2cde"
SRC_URI[deb1.sha256sum] = "29ec7b8cf1c9a47055de643eb0a1921854e762b4789a7f3bc3b0dea498fd4da9"
SRC_URI[deb1.sha512sum] = "946d2ef5f46ce630b2dd9789c3f1c2a01eb76dbbb1ba3723424b2b522815403597a58c4cc5f1c81e0d1898232025287ee6c7a7aa92a427b458b130247c40a8b5"

RDEPENDS = " \
    libc6 \
"

