# This was autogenerated! Do not modify
SUMMARY = "Vendor neutral GL dispatch library -- EGL support"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libglvnd"
HOMEPAGE = "https://gitlab.freedesktop.org/glvnd/libglvnd"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libg/libglvnd/libegl1_1.7.0-1+b2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libg/libglvnd/libegl1_1.7.0-1+b2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "147e7b9c9dd00c7efba73f4c4562e183"
SRC_URI[deb0.sha1sum] = "c1a56f90fe0c6aad038eaf50ba4def85a79d71fb"
SRC_URI[deb0.sha256sum] = "62e7bc8ccd47a60e55aad17f83d8d474310d782eb8589bbce2ab714c31712406"
SRC_URI[deb0.sha512sum] = "2d4a0fa28ee3650ff0b5118242b9fbe90e4ebb3fc0b2aef77db70f9109e0b5c2be9e83e45b72af3de2f73a680db06dc85c7029817cee4ea265f7dca01ff6d78d"
SRC_URI[deb1.md5sum] = "f774664e704ebdbc6bc77517fcd0b0ca"
SRC_URI[deb1.sha1sum] = "801011d23b7d320e987ad420a36a3110ef6d246b"
SRC_URI[deb1.sha256sum] = "b663ad1777df7ed8e320f897bbf678c2baef67f5458fe4a43195ac9b444c7afb"
SRC_URI[deb1.sha512sum] = "46d7d56634b6db91fa3e952919908dce0aa283b0eb655a10e6b703be2049d63b5f81c6d6380548d312510ac9efbc5ac4eb44b011c2ca8baca07c8788945d41a6"

RDEPENDS = " \
    libc6 \
    libegl-mesa0 \
    libglvnd0 \
"

