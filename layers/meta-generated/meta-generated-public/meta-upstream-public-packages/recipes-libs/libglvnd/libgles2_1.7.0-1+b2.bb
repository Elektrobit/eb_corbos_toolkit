# This was autogenerated! Do not modify
SUMMARY = "Vendor neutral GL dispatch library -- GLESv2 support"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libglvnd"
HOMEPAGE = "https://gitlab.freedesktop.org/glvnd/libglvnd"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libg/libglvnd/libgles2_1.7.0-1+b2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libg/libglvnd/libgles2_1.7.0-1+b2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "14ae317a6e0ee5964ea4381675d0d8e9"
SRC_URI[deb0.sha1sum] = "ce04cc42aa757124846df6bad7bb877a9e77c3fb"
SRC_URI[deb0.sha256sum] = "e12c18aa77939d122ee1dea520ba0440b97dc19200b7396e03dff03a3ece74c1"
SRC_URI[deb0.sha512sum] = "9b32d7162d8786337eb5e1d112b143af9017f7976262d064bcc38d0778339d9c0e2e7e8dcd07cc3dd9353babcc46366bfcad58a2a49a6f2efdf5c7f745e77fae"
SRC_URI[deb1.md5sum] = "34a21c3dbf2955e5de49066958e1a9b9"
SRC_URI[deb1.sha1sum] = "21642e1540296cd3c73416697b9b9363bbd54a76"
SRC_URI[deb1.sha256sum] = "c727fa1746ed3e343d1a2917932363d71e961eacca0443a1e2296587e03c47fb"
SRC_URI[deb1.sha512sum] = "661a8c7d5485b0929a1845511f9cdf21f5b25bc8498ef2cbc9b85195aae5c147419091bd9bff2669a8484b90069193e7b2ee1a681875a5fe82b10b91cd507aa7"

RDEPENDS = " \
    libc6 \
    libglvnd0 \
"

