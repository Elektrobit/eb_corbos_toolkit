# This was autogenerated! Do not modify
SUMMARY = "Vendor neutral GL dispatch library -- GLX support"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libglvnd"
HOMEPAGE = "https://gitlab.freedesktop.org/glvnd/libglvnd"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libg/libglvnd/libglx0_1.7.0-1+b2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libg/libglvnd/libglx0_1.7.0-1+b2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "98651dd8a213bb8bc7b3267a4a426649"
SRC_URI[deb0.sha1sum] = "ac70f81050a5be042a8d02ff964befff6aa02660"
SRC_URI[deb0.sha256sum] = "2721fdca0fe3bd963cb39482eabc253af52b88f4a7f6dbb69e475549daf5af3b"
SRC_URI[deb0.sha512sum] = "722b274453ac48dd007ee879b29dfe0b0f1fd2a37427225a918bff8c342e791f4f5c205cf209cc31fad6e3f737331860165f0cfb133136208a514014f5d6e9f1"
SRC_URI[deb1.md5sum] = "5a0e4103edffd7ec3f0c223ca79b2afa"
SRC_URI[deb1.sha1sum] = "d4eb3d87623c0a7bc24e76861c36dc1d041d324e"
SRC_URI[deb1.sha256sum] = "0245aafaac5e68ca9511f23c5bebf010327e63c65790c03dbb80bf14d485956d"
SRC_URI[deb1.sha512sum] = "0f21aa164b6a432920cae22def6bb55872501eb7531fff87091f8fb4dbc9e05f36a5d5dd5983ffefa510523f377e5da9dd14981dfafe8869454687565012c2ff"

RDEPENDS = " \
    libc6 \
    libglvnd0 \
    libglx-mesa0 \
    libx11-6 \
"

