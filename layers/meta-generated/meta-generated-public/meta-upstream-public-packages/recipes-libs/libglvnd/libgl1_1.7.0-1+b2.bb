# This was autogenerated! Do not modify
SUMMARY = "Vendor neutral GL dispatch library -- legacy GL support"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libglvnd"
HOMEPAGE = "https://gitlab.freedesktop.org/glvnd/libglvnd"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libg/libglvnd/libgl1_1.7.0-1+b2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libg/libglvnd/libgl1_1.7.0-1+b2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "b6cfc89725c0f9a5ab99fe1b73ced720"
SRC_URI[deb0.sha1sum] = "5e21e8d65bb04275934383376ef9ce55ac004f0c"
SRC_URI[deb0.sha256sum] = "87fa2f6e5abaed4ed385fac879c8dd735af719ee2300222d901793c66e041678"
SRC_URI[deb0.sha512sum] = "47e0ccf5968f527137b5bb086fd665a0f7005c4daf4a4b47f89181458fb0dad6fe0a986ae0487c8640493497f3cde495d7503b8ddd161f9f5adf837aac4f48e5"
SRC_URI[deb1.md5sum] = "871181445aa5412aca32f53cec7e4625"
SRC_URI[deb1.sha1sum] = "64edda451b59f29ac8debba8d9419aefa6d58b37"
SRC_URI[deb1.sha256sum] = "7943f99962aa3316515760bf44e66f0c15a3c813ad750b784b43e319fa2e6003"
SRC_URI[deb1.sha512sum] = "b638d05b3ae7c6ef244e6ce63bd84611d53664da628f495a04833d693d762c4045451ff2ea449761ac57bdd14bdc7dd4974fa626ad9636ef6846f8d64daf06fc"

RDEPENDS = " \
    libc6 \
    libglvnd0 \
    libglx0 \
"

