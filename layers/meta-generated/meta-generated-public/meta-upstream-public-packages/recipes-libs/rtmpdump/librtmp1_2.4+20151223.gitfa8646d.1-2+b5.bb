# This was autogenerated! Do not modify
SUMMARY = "toolkit for RTMP streams (shared library)"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "rtmpdump"
HOMEPAGE = "http://rtmpdump.mplayerhq.hu/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/r/rtmpdump/librtmp1_2.4+20151223.gitfa8646d.1-2+b5_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/r/rtmpdump/librtmp1_2.4+20151223.gitfa8646d.1-2+b5_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "355aeaaf937d70dcc873a458f6244c6e"
SRC_URI[deb0.sha1sum] = "890c75ffd3bd595233728f775acfa20693e53810"
SRC_URI[deb0.sha256sum] = "93baa2004cbe6c8721b9e81beed078612540aef120970b4751305c51c6697368"
SRC_URI[deb0.sha512sum] = "22a37e1252ec3419fec3481c8b99ef8410a1e3ae733feef7ccd12753012fc2868f9e04cf0dcf8744d702d61b51c5f388d37f89f2b994609d75f862c7cfcaaf5e"
SRC_URI[deb1.md5sum] = "e08922801c67c6789664085c60d2b41a"
SRC_URI[deb1.sha1sum] = "52c73625cf9757cab13603cb176c76e5822c42b2"
SRC_URI[deb1.sha256sum] = "20d52d20c4834158e956ae8e1d42a61d22330062052116d5422daa2d3b1d433b"
SRC_URI[deb1.sha512sum] = "0235b5ca57bc99f8f36bc3b5e6734f127aeffdbc59739959f9e268617300a586ded04e60cf6428866454960a55ff162c8c5917d9386d9c71c29893278d95be86"

RDEPENDS = " \
    libc6 \
    libgmp10 \
    libgnutls30t64 \
    libhogweed6t64 \
    libnettle8t64 \
    zlib1g \
"

