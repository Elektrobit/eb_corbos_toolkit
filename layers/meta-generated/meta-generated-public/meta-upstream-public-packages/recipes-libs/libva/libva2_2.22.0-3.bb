# This was autogenerated! Do not modify
SUMMARY = "Video Acceleration (VA) API for Linux -- runtime"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libva"
HOMEPAGE = "https://github.com/intel/libva"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libv/libva/libva2_2.22.0-3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libv/libva/libva2_2.22.0-3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "216ae5c39da66072d93a3c5eae1b1fb4"
SRC_URI[deb0.sha1sum] = "c5b976a61cf1857d1fde4c8efbf67e9fd7e2aed4"
SRC_URI[deb0.sha256sum] = "b76bdd330de47a826698aaed10f53435b703e9a7d4415dd68269c97709f46a9b"
SRC_URI[deb0.sha512sum] = "78111c8173f7a7d5f4cad17dba88e1f29681ac6e031f9054a186ecac74ac19e12556f743d576f1c77ed5db616294a1ce33c41162623db37f1f557c91dfe9a00f"
SRC_URI[deb1.md5sum] = "abe295f018bc24d0a51d435e05dd11a8"
SRC_URI[deb1.sha1sum] = "8632b4e2968a41f0891e9b8f4e45917f19c9aff1"
SRC_URI[deb1.sha256sum] = "7a5e7cbaaddf1f39973c10f9daae6769b704e0d6d72fe752d64003929272cbcf"
SRC_URI[deb1.sha512sum] = "66b3ab7f34e6f0549fe329d7374b2643aef7564514e8fc7c6357d425120e8eb6711068673b69a5bf628e73ab749b9da4c24bc54db8cf4aecbda5ab7ca64eadf3"

RDEPENDS = " \
    libc6 \
"

RPROVIDES = " \
    libva-driver-abi-1.0 \
    libva-driver-abi-1.17 \
    libva-driver-abi-1.18 \
    libva-driver-abi-1.19 \
    libva-driver-abi-1.20 \
    libva-driver-abi-1.21 \
    libva-driver-abi-1.22 \
    libva-driver-abi-1.8 \
"
