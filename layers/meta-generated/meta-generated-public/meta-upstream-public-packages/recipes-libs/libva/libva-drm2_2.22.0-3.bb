# This was autogenerated! Do not modify
SUMMARY = "Video Acceleration (VA) API for Linux -- DRM runtime"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libva"
HOMEPAGE = "https://github.com/intel/libva"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libv/libva/libva-drm2_2.22.0-3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libv/libva/libva-drm2_2.22.0-3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "d88a961711ddb6fd0af0fde3a5e0f0e1"
SRC_URI[deb0.sha1sum] = "2a6e89bd7812649824f83a53385a3dbeb0ff54f1"
SRC_URI[deb0.sha256sum] = "5dce5007ddc0ce87a61db4d71476ce1a5a135737b5185ce2e8b7067342fcafc6"
SRC_URI[deb0.sha512sum] = "a03b09099d927b026a49e08d123accce3cf07633dae8eee5283d750fd9d2e542a4111c7b574721ace9a9c56ba15ba972b72f216e8b7b91e724707b31634844f2"
SRC_URI[deb1.md5sum] = "fdcc048ba39df6d2080f7ca13f2abbdd"
SRC_URI[deb1.sha1sum] = "232c0c99171658ed064bb3fa8704ff5b1a4c7f18"
SRC_URI[deb1.sha256sum] = "18e556968a0f4bffd321d67b01fa5e445177c0849bef96a741aa7ed3a11dcc8b"
SRC_URI[deb1.sha512sum] = "36fb164ce51467b9aee6c68c694edbf90f6683acce209ddef2c82af764cc0ea861f71f34196f10ac6762fb16af04614e487103095f9effcc71619e29e3e329e9"

RDEPENDS = " \
    libc6 \
    libdrm2 \
    libva2 \
"

