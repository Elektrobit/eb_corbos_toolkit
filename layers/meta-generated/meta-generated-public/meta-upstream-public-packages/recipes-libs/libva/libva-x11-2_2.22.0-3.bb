# This was autogenerated! Do not modify
SUMMARY = "Video Acceleration (VA) API for Linux -- X11 runtime"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libva"
HOMEPAGE = "https://github.com/intel/libva"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libv/libva/libva-x11-2_2.22.0-3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libv/libva/libva-x11-2_2.22.0-3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "57b01729ed5de118c28755da466921ac"
SRC_URI[deb0.sha1sum] = "9b729dbc80e715a9807ea0ac0332f8e84e2bfacc"
SRC_URI[deb0.sha256sum] = "97baabc9ae8dfbe718ca80543dc7337d330dd17e2a59138bf42a66a35d59309b"
SRC_URI[deb0.sha512sum] = "83cdc032b99986c5bc4b06e71b3aacd58d3dea018a5f2d46a6a83162264f0cad8f08eef88d88b9a83f5bfc27a8841453a47a3ac434f67a9a4e86af7856dc2ebd"
SRC_URI[deb1.md5sum] = "21c0f2a52e26838dcc65ffcb7d6f98cb"
SRC_URI[deb1.sha1sum] = "832a1539c07cb1da04f66d9e165e8ffd73d8b1d1"
SRC_URI[deb1.sha256sum] = "a2c63e408e4adaa0ee8da79e2c439cc2b0b644460dba84637e8cef466ed6c884"
SRC_URI[deb1.sha512sum] = "896c6525e318b686b74e4211937777d464737ea5e088b138551f4311eb05e772ec5e9f2e1bffa1a6844029b288b74cbcadfd595db6a91925ffb214900da1d82f"

RDEPENDS = " \
    libc6 \
    libdrm2 \
    libva2 \
    libx11-6 \
    libx11-xcb1 \
    libxcb-dri3-0 \
    libxcb1 \
    libxext6 \
    libxfixes3 \
"

