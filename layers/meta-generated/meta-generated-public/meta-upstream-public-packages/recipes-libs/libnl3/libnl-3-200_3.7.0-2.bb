# This was autogenerated! Do not modify
SUMMARY = "library for dealing with netlink sockets"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libnl3"
HOMEPAGE = "https://github.com/thom311/libnl"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libn/libnl3/libnl-3-200_3.7.0-2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libn/libnl3/libnl-3-200_3.7.0-2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "315bd524081101b3723d5d46cf8162d2"
SRC_URI[deb0.sha1sum] = "4634bfe374a284d489b00a85588d6126113a3983"
SRC_URI[deb0.sha256sum] = "ce5c153953016be42def7b105f37d55eae07a9608d1dfe6bcb03cc017fc384cb"
SRC_URI[deb0.sha512sum] = "b2fe7ebfc64ed534e46f25bf805b7269e43e14d78497d359d80c13502ec36875b536a9c373fe6bf5ea83287fa82c3ba869c9f0f8267897dac897301002021055"
SRC_URI[deb1.md5sum] = "51f849bebd1a55a39f8b9d50151bd334"
SRC_URI[deb1.sha1sum] = "57b84a2618848dc5ca7bf86ca32e8ba2ccc2ae09"
SRC_URI[deb1.sha256sum] = "0489548a052d64b1acf7f61b0f08fd2da954b6fd6b9c729a4e740d7d39652d00"
SRC_URI[deb1.sha512sum] = "54304613c63f81c77e253ca3fe0f9e6b6b324b1f4f37e7b3e9aae955a83d028c7d4c47ca664cf2fac2fd164bc454d7588130a32e6b6d23ea185f895d4ae5af3d"

RDEPENDS = " \
    libc6 \
"

