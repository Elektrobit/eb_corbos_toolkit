# This was autogenerated! Do not modify
SUMMARY = "library for dealing with netlink sockets - route interface"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libnl3"
HOMEPAGE = "https://github.com/thom311/libnl"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libn/libnl3/libnl-route-3-200_3.7.0-2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libn/libnl3/libnl-route-3-200_3.7.0-2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "74255031a54b9a8c31107ee63c21c8f0"
SRC_URI[deb0.sha1sum] = "618fe3526ee1c18ef39f1214b5de3223c151adb5"
SRC_URI[deb0.sha256sum] = "1c8c95542688996cff8e954583642b10a3bd78b69954f565fda62144c2bc3897"
SRC_URI[deb0.sha512sum] = "af2724ecfb8ec16edd2bde18c5e96b58fc3f5af546fab601b96da0449c062c86c670d63fd1cf6f7bded3df834b4d4270157b295e6620d955f3894362f2edb460"
SRC_URI[deb1.md5sum] = "3706efb36bd373aa76ccdaa9219f0b48"
SRC_URI[deb1.sha1sum] = "c88f58977874f505378739f8b129fdded25aa154"
SRC_URI[deb1.sha256sum] = "86cd5b58c83cd70a834625f112a6c30da249bb842c4ac4daa44fd4c08298b7be"
SRC_URI[deb1.sha512sum] = "b8d6da2c0c2649d4451b41469f0d8a480f422f258af121ed78ff74bdc61472a25899aba211f5e0eaa6d05190ce1b3be9473c7424d64bfc00864c4a4dd3b03c8c"

RDEPENDS = " \
    libc6 \
    libnl-3-200 \
"

