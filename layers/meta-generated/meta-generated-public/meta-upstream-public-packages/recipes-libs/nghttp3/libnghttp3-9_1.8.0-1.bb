# This was autogenerated! Do not modify
SUMMARY = "HTTP/3 library with QUIC and QPACK (library)"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "nghttp3"
HOMEPAGE = "https://github.com/ngtcp2/nghttp3"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/n/nghttp3/libnghttp3-9_1.8.0-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/n/nghttp3/libnghttp3-9_1.8.0-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "6b1f90e4153530a76878e9fde0244c66"
SRC_URI[deb0.sha1sum] = "ec2a18da55b53e48472fc88c9893b0c574d4fc3b"
SRC_URI[deb0.sha256sum] = "388e4c33b72829cbf0d098afdc8539fa5ba7458eddb077f5538fdb4d5538716b"
SRC_URI[deb0.sha512sum] = "1194b6ec1e16b0c65ebca3c9ea46a6d52b060939f62c6c04112689de730e9b0673d6f511cf10874c1e86781ed2f6702b237371639e7a1a4749408129c0ff9dbf"
SRC_URI[deb1.md5sum] = "ee778e22addaf498d648a1b647370ebd"
SRC_URI[deb1.sha1sum] = "49fc3e3b40589d073a3ff868bb451efd40b45562"
SRC_URI[deb1.sha256sum] = "26bfb8d1bead043f57d95663bab02f7611e7078fb7cf71383fa480c4b4c24d81"
SRC_URI[deb1.sha512sum] = "360668552db05829674bca13f42aac19725b704552b111782dd729afb0b8fbdfa1ddf2758e93c5c4f5817bbc4545f27b8dd431c23967188c78e6b20bed56494c"

RDEPENDS = " \
    libc6 \
"

