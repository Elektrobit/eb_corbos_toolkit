# This was autogenerated! Do not modify
SUMMARY = "S-Lang programming library - runtime version"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "slang2"
HOMEPAGE = "http://www.jedsoft.org/slang/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/slang2/libslang2_2.3.3-5+b2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/slang2/libslang2_2.3.3-5+b2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "769716d4335732c16befbeb31942e293"
SRC_URI[deb0.sha1sum] = "a7096d1e5440a693d685a8e92407196c6356a4d5"
SRC_URI[deb0.sha256sum] = "49b52a2cbe0f2257f4f7c68a0eaecd90962edabf08097611548b3ea4bd73292e"
SRC_URI[deb0.sha512sum] = "ae030ca1899b7ddaebc4959cb8ca5b1764f612071cf5558f9c92397d81ff74f1eb24100ac46814dd0dfa941a842643121d665cc09e3e845d6f628773f24c0382"
SRC_URI[deb1.md5sum] = "c63da67c7ed2557d9bd41697ee2b0fbe"
SRC_URI[deb1.sha1sum] = "1a244aa16bea58c6e55f7c24950dd9d52691f6f0"
SRC_URI[deb1.sha256sum] = "ac285fde2e049ef3397c427d93d9fc7c08c688ef2643e4a6b2d5468957ca9100"
SRC_URI[deb1.sha512sum] = "eda6b3ba53a732fa4fd7eccb27b3e11a4dcda4ad1316a2411978f02c9cf6012d2157d238961e028274fe5f34b55276021a3dfe4940b294b520108bc8018bbe72"

RDEPENDS = " \
    libc6 \
"

