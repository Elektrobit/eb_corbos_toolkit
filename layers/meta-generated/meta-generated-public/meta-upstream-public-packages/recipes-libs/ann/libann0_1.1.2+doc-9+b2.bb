# This was autogenerated! Do not modify
SUMMARY = "Approximate Nearest Neighbor Searching library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "ann"
HOMEPAGE = "https://www.cs.umd.edu/~mount/ANN/"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/a/ann/libann0_1.1.2+doc-9+b2_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "ba60cb22d1f6dc73bb711fe18ade6803"
SRC_URI[deb0.sha1sum] = "a666804e333cc6da0b0543d0e5e3beed9a41c65f"
SRC_URI[deb0.sha256sum] = "06cd412d1bf38697d4d79e6a665e76b9a9e2d7a192f78cdb31d8370bfe3332fe"
SRC_URI[deb0.sha512sum] = "e8f9c4cb1448cdea28abb6bf18c27749930cf1282db0240d1897e0ec75206131d4502efa71cfb4dd73f5923f260a2c69e6cd423179946027c3cbe8cb48c18e2d"

RDEPENDS = " \
    libc6 \
    libgcc-s1 \
    libstdc++6 \
"

