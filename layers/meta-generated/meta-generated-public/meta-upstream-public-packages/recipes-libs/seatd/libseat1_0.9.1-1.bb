# This was autogenerated! Do not modify
SUMMARY = "flexible user, seat and session management library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "seatd"
HOMEPAGE = "https://sr.ht/~kennylevinsen/seatd/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/seatd/libseat1_0.9.1-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/seatd/libseat1_0.9.1-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "87cf9a6b8aba25930750a2250ee06437"
SRC_URI[deb0.sha1sum] = "bf72bbe9e775755c222d18bec3cc8f410d76184c"
SRC_URI[deb0.sha256sum] = "20c08d9460b87f98f36ffe200ef9ac074c3ca23961cb5fd47399f20946f5b185"
SRC_URI[deb0.sha512sum] = "8e9bf63dcf4536dfb404471e21ae36779ffee84c1014194ccb39b0388156b466846e05c26224010339f8ecfd45302ddcd42a412332787a594d4a39cac7738f1c"
SRC_URI[deb1.md5sum] = "b316b5551c51a81a0810de98c6cd8364"
SRC_URI[deb1.sha1sum] = "472f961994c6032027b3070e236146ab795176eb"
SRC_URI[deb1.sha256sum] = "1e079a0d7f31220014abb24717d29e54f829d3c057a34647ca0ee9368922c63b"
SRC_URI[deb1.sha512sum] = "9024bd2fd8875cbbfd1ebfde145baa2078fabdd28f378d9f78de375c9f23b48eb5f72d51739a5da6f7e839c8ca742d90027309b0255666aa746d78846991cabb"

RDEPENDS = " \
    libc6 \
    libsystemd0 \
    seatd \
"

