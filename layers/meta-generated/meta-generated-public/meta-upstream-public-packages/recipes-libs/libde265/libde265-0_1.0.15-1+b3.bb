# This was autogenerated! Do not modify
SUMMARY = "Open H.265 video codec implementation"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libde265"
HOMEPAGE = "https://github.com/strukturag/libde265"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libd/libde265/libde265-0_1.0.15-1+b3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libd/libde265/libde265-0_1.0.15-1+b3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "0c323aaaf6ea41343412aa9da949ef36"
SRC_URI[deb0.sha1sum] = "ec0ded8276cfdb68db5f5daad1469dc59d440627"
SRC_URI[deb0.sha256sum] = "d80d262c7a323fb594712354e4080c1ffe0c25e6cfbbd1192cda82536be123d4"
SRC_URI[deb0.sha512sum] = "e022cb7e2244704e3ea51b3f2bed8a47bbf379cc27f294a0d78b902733911ddec329113526990a25fbb8d0d2e61f3b870d768b97e8e5204957eb3f7f9f96bfeb"
SRC_URI[deb1.md5sum] = "0858e8202b90359b158f5ee4ff82b571"
SRC_URI[deb1.sha1sum] = "625a3d71778a7e77bd544b73f22b7e4b46cfffb0"
SRC_URI[deb1.sha256sum] = "4ceabc2588577865d149dd902625024e7f809cab10b5bccb3c5e9987f9becbb9"
SRC_URI[deb1.sha512sum] = "d5c204d677b1907282834276640732f2547be27b0e20d3cbbabf88a2b5634c4d1417ca75017a57b4652428058ac0704364eaddfdb12fbdd4d279f761d91ffaae"

RDEPENDS = " \
    libc6 \
    libgcc-s1 \
    libstdc++6 \
"

