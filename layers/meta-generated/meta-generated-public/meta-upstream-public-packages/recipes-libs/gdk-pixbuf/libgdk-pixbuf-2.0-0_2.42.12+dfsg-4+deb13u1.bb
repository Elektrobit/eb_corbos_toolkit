# This was autogenerated! Do not modify
SUMMARY = "GDK Pixbuf library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "gdk-pixbuf"
HOMEPAGE = "https://www.gtk.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gdk-pixbuf/libgdk-pixbuf-2.0-0_2.42.12+dfsg-4+deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gdk-pixbuf/libgdk-pixbuf-2.0-0_2.42.12+dfsg-4+deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "14e598056707edd1144af24ceae616f1"
SRC_URI[deb0.sha1sum] = "cd4c767aff5481aa19910984d526bd2718d3d5b2"
SRC_URI[deb0.sha256sum] = "94150fb955b2d3a9a5e054e31c5a4b048bad4a479207e86cde46fbc975c838b4"
SRC_URI[deb0.sha512sum] = "ed7ab5e93d853235296f2ce3dae265db4bdd27c7c5f0d6c2cb19ec36f71dd0c93420dd49b6ce40d4e4c17cbd8f68ca1b1e77f4adc5491009bb0838a99180cccb"
SRC_URI[deb1.md5sum] = "1d0c3eb2e6004571c8e9620ad34b720a"
SRC_URI[deb1.sha1sum] = "b348a9efba55e63f0113e0c240c71b323d89f5c0"
SRC_URI[deb1.sha256sum] = "2090d2ee768d27c3bfad89d34b6915453d3034fa778d4bf15f5144a3fb4a0c78"
SRC_URI[deb1.sha512sum] = "62c3a1e51e290a80fe130a7bf111302cee205c52b0ad25d5e8c0f3d54c78c2781a6f7c388a26e49922b6618b580dfefbd1d5a88b216d9223762fbc204e0af247"

RDEPENDS = " \
    libc6 \
    libgdk-pixbuf2.0-common \
    libglib2.0-0t64 \
    libjpeg62-turbo \
    libpng16-16t64 \
    libtiff6 \
    shared-mime-info \
"

