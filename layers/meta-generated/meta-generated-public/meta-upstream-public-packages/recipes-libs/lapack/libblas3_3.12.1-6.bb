# This was autogenerated! Do not modify
SUMMARY = "Basic Linear Algebra Reference implementations, shared library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "lapack"
HOMEPAGE = "https://www.netlib.org/lapack/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/l/lapack/libblas3_3.12.1-6_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/l/lapack/libblas3_3.12.1-6_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "009269addf607682ff0a0def1acfbafe"
SRC_URI[deb0.sha1sum] = "a5895e0869814298c2b516a15b3d101dcb147b87"
SRC_URI[deb0.sha256sum] = "4af245ecafc30bfa1de9d20af02fec96654ead2f06b1dac40cb03fc9eb0bfbe6"
SRC_URI[deb0.sha512sum] = "5cca790c12fc10d0158997bf31740d270f26ec186d2ffb611c3c9d41b160d3b7f9ef4ac5891033ad3bc40f480bb8109214920a96a029c82e09a2ea528f63a53d"
SRC_URI[deb1.md5sum] = "f7db761211eb526c5c87cbeaee2e57fb"
SRC_URI[deb1.sha1sum] = "d052a2357ef767d5c90335e3cd0d2d31d27fbb19"
SRC_URI[deb1.sha256sum] = "33ed1d0770978f11493d24e0416a51ea7de77ede8c23d179a8ad88802a167be2"
SRC_URI[deb1.sha512sum] = "cd00e26209c2f1baf4893f2e53e3b74b9d39b5c20acbe3a881928d67e16109cd084aba7d2fd8c573ab71277f87b84f197134b6b1a1abdc9fb2d983100d51d564"

RDEPENDS = " \
    libc6 \
"
RDEPENDS:append:amd64 = " \
    libgcc-s1 \
"

RPROVIDES = " \
    libblas.so.3 \
"
