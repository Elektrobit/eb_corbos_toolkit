# This was autogenerated! Do not modify
SUMMARY = "utility libraries for X C Binding -- image"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "xcb-util-image"
HOMEPAGE = "https://xcb.freedesktop.org"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/x/xcb-util-image/libxcb-image0_0.4.0-2+b2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/x/xcb-util-image/libxcb-image0_0.4.0-2+b2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "21b57ac01f7026c0971d1188514e203d"
SRC_URI[deb0.sha1sum] = "088d52669e858425a5af10b2b74e82acbed41953"
SRC_URI[deb0.sha256sum] = "81e2654e1b1da5cff9ea2bf46970a46eb5c81f1e35b1356691705e8cd6ab3ed6"
SRC_URI[deb0.sha512sum] = "980bdb60a36a19652c351460142db30e89b9c537a243980f270291d0c0840c5215fc083498ee8910003a54c2234950d3e2e6128fcd684a11e917c028546b2dad"
SRC_URI[deb1.md5sum] = "3d70849c5e6ec854458cba4d13df8269"
SRC_URI[deb1.sha1sum] = "f8ece0b5255505df045e74da367f153aac39b027"
SRC_URI[deb1.sha256sum] = "25ea3790081635a5f69c96afa2d44efbd04ad4e4c02d0357bf98ff000f12702a"
SRC_URI[deb1.sha512sum] = "df723b89055ee20137071538e934e218d2f80b86d065058eb1e91e3c9836f5ac6849c2dba32d0c668e595a1eb29dabe571c243b017c9748066e3cc2d7786567a"

RDEPENDS = " \
    libc6 \
    libxcb-shm0 \
    libxcb-util1 \
    libxcb1 \
"

