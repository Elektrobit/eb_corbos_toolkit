# This was autogenerated! Do not modify
SUMMARY = "Andri's Main Loop library (shared library)"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "aml"
HOMEPAGE = "https://github.com/any1/aml/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/a/aml/libaml0t64_0.3.0-3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/a/aml/libaml0t64_0.3.0-3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "a984698a0a7de8db3c335f10f8a4fc38"
SRC_URI[deb0.sha1sum] = "395abb06ff2edea8b4f476bf7cd4b2de334c4893"
SRC_URI[deb0.sha256sum] = "06c7b1107490f4809e721f1d1acd9850c1e363ccc15c41fc66ca1068ca730e7e"
SRC_URI[deb0.sha512sum] = "49607ee53259ef6f075cf1c872e4789fa70b056ca6d1d6e21e79c4d5ad42f705951c60b560d288c9ca9809cd40dca661bad9bb3a248a608aff142162de3bca23"
SRC_URI[deb1.md5sum] = "9f887ff2701506b87a3c9a737d0f76ce"
SRC_URI[deb1.sha1sum] = "999a467642c984b1c4d37ede983293bdfc66b59e"
SRC_URI[deb1.sha256sum] = "39c4b5e92ea0000b45ff77061d440937c91b55ae736df4a318f4e95d362d8b98"
SRC_URI[deb1.sha512sum] = "3533c31f2001275f23c66af1b27c592023ea58ee47881494635aaacc16d6a560a9219a4eb319c56e52dbaada64ecabf35d152a34d57b55201c671c8558ae1158"

RDEPENDS = " \
    libc6 \
"

RPROVIDES = " \
    libaml0 \
"
