# This was autogenerated! Do not modify
SUMMARY = "GNU TLS library - DANE security support"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "gnutls28"
HOMEPAGE = "https://www.gnutls.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gnutls28/libgnutls-dane0t64_3.8.9-3+deb13u4_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gnutls28/libgnutls-dane0t64_3.8.9-3+deb13u4_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "9b85ff012ad557685113e186602c8fd9"
SRC_URI[deb0.sha1sum] = "c575119959260b26989ae30b91ec7a8303c80efd"
SRC_URI[deb0.sha256sum] = "119a357b321614be7e17655cccbf767bd55b136d1ad722d3e80fb99d862fe2f4"
SRC_URI[deb0.sha512sum] = "c7d3e1f14de510f5df3094fc29a23c3010c0677fe68e96eecaa95cbe46b7174d19b3c94807a846c8fcd77dbc18451a207e25acd250a13d1b05145dc0becd2e96"
SRC_URI[deb1.md5sum] = "6533300a8ed627a70a4cdf1228886bf6"
SRC_URI[deb1.sha1sum] = "ab390921541cda1cc2f513c9d4ca2a7ed89d0afe"
SRC_URI[deb1.sha256sum] = "33773a36329f94ffa78a40a0c6bca887747be84771765d3af40455e7c7be1fc4"
SRC_URI[deb1.sha512sum] = "6c5af5b8b3518743ce7401bb979acfce91a0f58d9bf8bc7ad29476c773bed67a54328e65a13eea795a17bdce45309c1820f878dacceb40b57e4ac13287f9484d"

RDEPENDS = " \
    libc6 \
    libgnutls30t64 \
    libunbound8 \
"

RPROVIDES = " \
    libgnutls-dane0 \
"
