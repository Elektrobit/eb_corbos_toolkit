# This was autogenerated! Do not modify
SUMMARY = "GNU TLS library - OpenSSL wrapper"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "gnutls28"
HOMEPAGE = "https://www.gnutls.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gnutls28/libgnutls-openssl27t64_3.8.9-3+deb13u4_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gnutls28/libgnutls-openssl27t64_3.8.9-3+deb13u4_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "2bf370541ab0893c87364c8cc8b69a5b"
SRC_URI[deb0.sha1sum] = "bfc49d91aa0199d798c5bdfa2e0d0878c1876d66"
SRC_URI[deb0.sha256sum] = "b7d1252b21d4e10bb46dcd97b5f8dd5a6412f166e945f386bc908c9b2cb82b44"
SRC_URI[deb0.sha512sum] = "8a128d170a98c25d9e01434bab504c93834e393d3286607a92e5da4b11a8fe6e74553432e84a043e012734846d148c86403c0e1f308f891f40aa2813ea2c03b5"
SRC_URI[deb1.md5sum] = "f0d0069cdc9a8e3944713623e6966d42"
SRC_URI[deb1.sha1sum] = "6c0cd4684a3d7073d9ca1668545a98af64ac408e"
SRC_URI[deb1.sha256sum] = "0022777e39fa7eb0998518fe90a783ed88e9a330f54fdb60f5fd9abc4b98cc00"
SRC_URI[deb1.sha512sum] = "2bbf772de78cff4a67e5b74f0528e5054a0f483d3a5b2486afcac6cdc6d89abdfe5a1ab799b13bf7f4d64b2082fc1500c07a4399f3c632f0e3fc712adf6300c9"

RDEPENDS = " \
    libc6 \
    libgnutls30t64 \
"

RPROVIDES = " \
    libgnutls-openssl27 \
"
