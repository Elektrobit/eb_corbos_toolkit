# This was autogenerated! Do not modify
SUMMARY = "JSON manipulation library - shared library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "json-c"
HOMEPAGE = "https://github.com/json-c/json-c/wiki"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/j/json-c/libjson-c5_0.18+ds-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/j/json-c/libjson-c5_0.18+ds-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "2afaa0abf1f11e7f2d5aa1e789148632"
SRC_URI[deb0.sha1sum] = "748b3f2033851aab07d1501f91a7ce3d1e87bc75"
SRC_URI[deb0.sha256sum] = "4fbd5fb4d54c626f05d68abf38a31533fbf1bf4a87068696abe041ee9c974fe0"
SRC_URI[deb0.sha512sum] = "cb3a691a91bea2e384960eb04c90dae28bc45105e90a740addea6986936027038274de93b2698c94ab9c276439ea25584851805e0449c83d338bc52fad673b13"
SRC_URI[deb1.md5sum] = "65dc5179be093a6a44f23c2407aa46ab"
SRC_URI[deb1.sha1sum] = "a0a906418ab25385b9ba43d04e5325310484daf5"
SRC_URI[deb1.sha256sum] = "f631829107005b15c2ca5c48ac74bc2df437c7eb608756eb865b147985f7bb45"
SRC_URI[deb1.sha512sum] = "6d392c5fefd8505ac7e1fc18a6b7813f495f3e7a2b931cb131d1ba321db7ceb3d4a20c191de4c1089891d1d390be4ef32f9b85f300a0649dea51e98929e1a6a0"

RDEPENDS = " \
    libc6 \
"

