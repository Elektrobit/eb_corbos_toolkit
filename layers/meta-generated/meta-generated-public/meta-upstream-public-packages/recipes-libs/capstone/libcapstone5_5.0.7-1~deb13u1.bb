# This was autogenerated! Do not modify
SUMMARY = "lightweight multi-architecture disassembly framework - library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "capstone"
HOMEPAGE = "https://www.capstone-engine.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/c/capstone/libcapstone5_5.0.7-1~deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/c/capstone/libcapstone5_5.0.7-1~deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "02c62a3eeaf26919a24024e15e3dcdaf"
SRC_URI[deb0.sha1sum] = "ad2ecde7c09005b80ae947ae4fc845e0d1b7fd30"
SRC_URI[deb0.sha256sum] = "775187a7be26bb0b076d1979a02163b943dbc13eb4adb0efc503223a03c75422"
SRC_URI[deb0.sha512sum] = "25e95c4c5fbf203e527d78c1261dcf3cb20142527af8bed7dd8ab318271422af4c7468aa6d5f53aac9ae9a1e17eb2de36c4c02daf8ab03e65792acb18499ae05"
SRC_URI[deb1.md5sum] = "9891a52674fe530c9871708d113f842d"
SRC_URI[deb1.sha1sum] = "2f5c67445da9b3d63c98575a97da55c1a30fe0af"
SRC_URI[deb1.sha256sum] = "de12f48b02fdbfe33793fd5c47cf97f413e934fe0b303fa162c388958a3c6f36"
SRC_URI[deb1.sha512sum] = "b3c4378ddabde090f7a4a50aa8fcd87e2fa831f0e0f849df15fa1cebbbd32af074b2c688947f83981ff83672272c568576e940e262e9af6fdf32c8e871aae68c"

RDEPENDS = " \
    libc6 \
"

