# This was autogenerated! Do not modify
SUMMARY = "Shared libraries for GSM speech compressor"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libgsm"
HOMEPAGE = "http://www.quut.com/gsm/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libg/libgsm/libgsm1_1.0.22-1+b2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libg/libgsm/libgsm1_1.0.22-1+b2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "34b3a68e98bf9b2831f9d52ba9b266e6"
SRC_URI[deb0.sha1sum] = "d2f65c4b53f6d57d549d70c4199d09bd9ca7e5fb"
SRC_URI[deb0.sha256sum] = "388909810b0133b0dd8ea84884cd34db7bcbbd0f2643a7a65296a34644704a5e"
SRC_URI[deb0.sha512sum] = "a5ddab64428024fcdf774b026252cdf34695dc5616a1027812b13fed91012c57b373330544ce6ed1627eb445bde7de44d2110ec16642d566ba2db42a982030b6"
SRC_URI[deb1.md5sum] = "953da9b5d58a703f4d7b7c36cb442092"
SRC_URI[deb1.sha1sum] = "b6f2fe5f53cd7d163b122dcf0d2f550ccfdfaec7"
SRC_URI[deb1.sha256sum] = "dc9a761c9cca7d886db0474fe28b9697e72d376fa2112590cf5f7ed737944f6c"
SRC_URI[deb1.sha512sum] = "3781dc9dc75fa3d3f37e00d8f911f0409293d35b10beac9b82e059c954f81aea4dc169bf2e065a74b630c6aff8cc7b7055fe8d3d141072a4ad2cac0f5fe2ead5"

RDEPENDS = " \
    libc6 \
"

