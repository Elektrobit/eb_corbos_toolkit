# This was autogenerated! Do not modify
SUMMARY = "X11 XFree86 video mode extension library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libxxf86vm"
HOMEPAGE = ""

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libx/libxxf86vm/libxxf86vm1_1.1.4-1+b4_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libx/libxxf86vm/libxxf86vm1_1.1.4-1+b4_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "db85cd6bd42d89ccc1027b4846c10295"
SRC_URI[deb0.sha1sum] = "386eb076b0af456a69c1a10a40eea54cb4c4eb4d"
SRC_URI[deb0.sha256sum] = "f9f8487e536293e7ecf91fe7feb14e97e02a3aa652e207c661442dce775d3b14"
SRC_URI[deb0.sha512sum] = "c47fab513b53504fcb643bfd4a060b6b2fdc8ebc5ce206ce0abc3a3ea2f481efb474dd07b886a683d66e642cb45bb57f695aed3cb8a9d843db0ccd235de9d367"
SRC_URI[deb1.md5sum] = "aec572da81306ec202cc66dbeb2da3d9"
SRC_URI[deb1.sha1sum] = "4277c24c86ec041775d5bcf430e1ea774e18747f"
SRC_URI[deb1.sha256sum] = "9ed4bb25e311486207eeaa609decc3905aa9071c4c7f2a605829e3a79ec88b83"
SRC_URI[deb1.sha512sum] = "fa02f4b041f8e67ddc32afcaf96713cebd45dd3688833cff1dc73c05601036ca19d81395fe25c0b90527e3cee21e243e3a7c3c48b8e87f975284e2a20fbefb2d"

RDEPENDS = " \
    libc6 \
    libx11-6 \
    libxext6 \
"

