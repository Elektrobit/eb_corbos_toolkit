# This was autogenerated! Do not modify
SUMMARY = "GNU bc arbitrary precision calculator language"
DESCRIPTION = ""
SECTION = "math"
SOURCE_PACKAGE = "bc"
HOMEPAGE = "https://www.gnu.org/software/bc/"

inherit dpkg-prebuilt

DPKG_ARCH = "amd64"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/b/bc/bc_1.07.1-4_amd64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "f2dc0d6416600d680c32c1bedddd8c8d"
SRC_URI[deb0.sha1sum] = "3a6da630d418b7d971f0025c0a1e00ccb4375843"
SRC_URI[deb0.sha256sum] = "d055a11f0f9c5f8fe78b31d502c01dfe46ddf9c24f753aaddadaaff95fcc75ad"
SRC_URI[deb0.sha512sum] = "b2f3f04c7248b1db80e11e002b323844bf63993814d40cb413ce49114ad6bdeccd24983e1554284091d3ae68fba683de9cf5c5b9421a9eee9daf8f00f64390cc"

RDEPENDS = " \
    libc6 \
    libreadline8t64 \
"

