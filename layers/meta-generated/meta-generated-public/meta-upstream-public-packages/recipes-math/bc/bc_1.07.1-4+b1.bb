# This was autogenerated! Do not modify
SUMMARY = "GNU bc arbitrary precision calculator language"
DESCRIPTION = ""
SECTION = "math"
SOURCE_PACKAGE = "bc"
HOMEPAGE = "https://www.gnu.org/software/bc/"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/b/bc/bc_1.07.1-4+b1_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "8bbe60d7d9da606efe3aec1d536a83ca"
SRC_URI[deb0.sha1sum] = "44be1b55a9e44900eeee9a7d423edaf7b97bf4d5"
SRC_URI[deb0.sha256sum] = "efd37aaf7324f2342eeae38c30009b7ebb2055ecabf1a5f7b22170360fd2bc7a"
SRC_URI[deb0.sha512sum] = "17e75f6a306de76867f65628324461ab768464efb4d800ebd1bd2d2366cd338efa641dd1e4c975e6263d0f5d517b39f0da47372737bf5308e0acfee76ddc5d7d"

RDEPENDS = " \
    libc6 \
    libreadline8t64 \
"

