# This was autogenerated! Do not modify
SUMMARY = "Apply a diff file to an original"
DESCRIPTION = ""
SECTION = "vcs"
SOURCE_PACKAGE = "patch"
HOMEPAGE = "https://savannah.gnu.org/projects/patch/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/patch/patch_2.8-2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/patch/patch_2.8-2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "7c3af69c5e164a29a7a4261bfc26a21c"
SRC_URI[deb0.sha1sum] = "c2ef3be7b58282247f219cc21a518e4eda6cbd90"
SRC_URI[deb0.sha256sum] = "80c46a0085b33acc74bf451fddb6a70cb43d4ebcc4a873aec04d8d0a63ffc630"
SRC_URI[deb0.sha512sum] = "5601deeefb362f718f01cd42e7ab98433aa530155f5b81231efe5eb27b720e1ec2a2d71e66ef9ed9e9519c94fcb959e1863d59c50dcc408717989a2dff3215d9"
SRC_URI[deb1.md5sum] = "e4cf3213612754b6fd2aa1ab2ddd8883"
SRC_URI[deb1.sha1sum] = "cf36d9c6c15ec087cf1965a09ce94c168cfd5850"
SRC_URI[deb1.sha256sum] = "182ad723623dcd02dfe5054f3515a26d8bf4a9cce717f03e3e514c02cb9e59e8"
SRC_URI[deb1.sha512sum] = "e00f52eddecf353ead0ab1de36b486c5974bfa7a66a10a22c6456db696a2a8f6e6df8f1799844218da0b244f9770b3c15edd8000badbebf947f2ff3b77045290"

RDEPENDS = " \
    libc6 \
"

