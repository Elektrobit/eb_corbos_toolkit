# This was autogenerated! Do not modify
SUMMARY = "Tool to work with series of patches"
DESCRIPTION = ""
SECTION = "vcs"
SOURCE_PACKAGE = "quilt"
HOMEPAGE = "https://savannah.nongnu.org/projects/quilt"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/q/quilt/quilt_0.68-1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "b98e7f68004c4d0f301784c93a90901c"
SRC_URI[deb0.sha1sum] = "3e76584127de24f816c5fc1f7afc54ed3146176d"
SRC_URI[deb0.sha256sum] = "2016eaf89f6624e6a122e5ca1d7409ddd808a014fc086b42306f590604fb39e7"
SRC_URI[deb0.sha512sum] = "fe6cc7d045e356338e7b9bff4f3976b2fb1fc2c5af48d34951d24e62adca4104615196377c4226eeeae4d372da6b3d2b0bb7fca8f19dd756136e62a3315b59f8"

RDEPENDS = " \
    bsdextrautils \
    bzip2 \
    diffstat \
    ed \
    gettext \
    patch \
    perl \
    sensible-utils \
"

