# This was autogenerated! Do not modify
SUMMARY = "easy-to-use, scalable distributed version control system (common files)"
DESCRIPTION = ""
SECTION = "vcs"
SOURCE_PACKAGE = "mercurial"
HOMEPAGE = "https://www.mercurial-scm.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/m/mercurial/mercurial-common_7.0.1-2_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "993e19fdb421088c1370b8813f66bb97"
SRC_URI[deb0.sha1sum] = "54c2530927272d2f3aab1eb0d2f06176bfd9efa7"
SRC_URI[deb0.sha256sum] = "683fb52334036470dd59ce4c5d196f8654478387b10d4d9acee6e9daa07d03b6"
SRC_URI[deb0.sha512sum] = "a3972e23965b4d44baac35a0dacd67ef473963197736533f3971411b7ae29dfff24503ccca63247a79c71632bf30b5acf2da79146951ea9d8a902d7faa07b129"

RDEPENDS = " \
    python3 \
"

