# This was autogenerated! Do not modify
SUMMARY = "easy-to-use, scalable distributed version control system"
DESCRIPTION = ""
SECTION = "vcs"
SOURCE_PACKAGE = "mercurial"
HOMEPAGE = "https://www.mercurial-scm.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/m/mercurial/mercurial_7.0.1-2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/m/mercurial/mercurial_7.0.1-2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "7d5bced964d2fa6f407c5d79c30e5def"
SRC_URI[deb0.sha1sum] = "f1df84470672c6c5668e3eccce67450ce2a0960e"
SRC_URI[deb0.sha256sum] = "72c6b846e6337097cd93d10a85369cba73d977086570f81b4f46f358b8b228e5"
SRC_URI[deb0.sha512sum] = "4388b3b178596a08499fb47b12e35314a786b8cb3ee5b5f8e45baa8162bad9bd291d860802981eee984638bc1aa20e0b6969d8d3cc329253f904334b76f80bf5"
SRC_URI[deb1.md5sum] = "82a1ff3e6729804d1116cf202532e6fe"
SRC_URI[deb1.sha1sum] = "ffa9fd21d28b17496113d6e0ab455e6d066055cb"
SRC_URI[deb1.sha256sum] = "56e21c7f96dc342adc728796998cdb2dd73c6962215212aa9fda48895aa61a93"
SRC_URI[deb1.sha512sum] = "a85e0a7d149d3441eadfb7440e7ce4dc9576f7d39ee57dec9fc1afea09e8e9640040675f9b3b06dade47302a7328efb9247ed02ae91ec37608a3e0646adfa62a"

RDEPENDS = " \
    libc6 \
    mercurial-common \
    python3 \
    ucf \
"

RPROVIDES = " \
    python3-mercurial \
"
