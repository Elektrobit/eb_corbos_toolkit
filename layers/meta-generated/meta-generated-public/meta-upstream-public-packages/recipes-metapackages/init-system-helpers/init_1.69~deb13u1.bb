# This was autogenerated! Do not modify
SUMMARY = "metapackage ensuring an init system is installed"
DESCRIPTION = ""
SECTION = "metapackages"
SOURCE_PACKAGE = "init-system-helpers"
HOMEPAGE = ""

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/i/init-system-helpers/init_1.69~deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/i/init-system-helpers/init_1.69~deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "9f34c12bd5590c2b28a372910002e75d"
SRC_URI[deb0.sha1sum] = "8d282a20de3b4703904b9d75ff235d140452cf3f"
SRC_URI[deb0.sha256sum] = "159ed19fb67055f2337c23cf92d6e29040dc969742e8b52fb5fd1b9033a6cce6"
SRC_URI[deb0.sha512sum] = "f0bd72c472fe78608878745c3db81ce04bbcc7605c4b40e3ddf105fe47d8005d0098676981862ed5de2d8c94e67d694a689c2720bb56a62bf6594e2b4c6a3ab8"
SRC_URI[deb1.md5sum] = "e68d4f3c519c81ce5f85310a63ff5b2a"
SRC_URI[deb1.sha1sum] = "fb574b1e59ca0ac930917f3cd7edec0452169574"
SRC_URI[deb1.sha256sum] = "b624fe231af5179c63d06a0b53580647e72620fbf4e3f36c49ebcedcdc27a116"
SRC_URI[deb1.sha512sum] = "ffd6206b776ff5685e6632f9b20f619166ab6c4d451edf20c47d43dfcb7c37d230560121bc22f0171f7874f896d3c99373a70e2c8c4ee9bef4b235e68ba88f01"

RDEPENDS = " \
    systemd-sysv \
"

