# This was autogenerated! Do not modify
SUMMARY = "rich set of graph drawing tools"
DESCRIPTION = ""
SECTION = "graphics"
SOURCE_PACKAGE = "graphviz"
HOMEPAGE = "https://www.graphviz.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/graphviz/graphviz_2.42.4-3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/graphviz/graphviz_2.42.4-3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "061d137f40eeb49fe048b39732d4e55c"
SRC_URI[deb0.sha1sum] = "bb6fe1922c9fec7d2c1c5202294b576d2676cfd1"
SRC_URI[deb0.sha256sum] = "21cb13d6e9b514edde8d8a8efee9e3b350bb1c9d9c87ab60b4592ff69f23e625"
SRC_URI[deb0.sha512sum] = "c361ea9aa425e228fbca34f6efa020a9ec71308dc99e966f1deba6acd39cc22ae12c2a684313537ff40cc2329f33483660853959d0c5595b7243f8be36b96809"
SRC_URI[deb1.md5sum] = "9c7db6fee3e56859a7316be29125f120"
SRC_URI[deb1.sha1sum] = "509f837279a844e0104398be99bc3c308d55c5c6"
SRC_URI[deb1.sha256sum] = "97cbbf49830f93547da9af72bb62bef863184863d14ebcd738e578cb7ad92c5d"
SRC_URI[deb1.sha512sum] = "9790b881f906208b89844f7d74bef0f316e222390ad32d686ff0c9692cb2b82e5b9cf09f08e914a1a7a74dcf47b93461452825008e2703f529d7e390c4acd7c5"

RDEPENDS = " \
    libann0 \
    libc6 \
    libcdt5 \
    libcgraph6 \
    libexpat1 \
    libgcc-s1 \
    libgd3 \
    libglib2.0-0t64 \
    libgts-0.7-5t64 \
    libgvc6 \
    libgvpr2 \
    liblab-gamut1 \
    libstdc++6 \
    libx11-6 \
    libxaw7 \
    libxmu6 \
    libxt6t64 \
"

