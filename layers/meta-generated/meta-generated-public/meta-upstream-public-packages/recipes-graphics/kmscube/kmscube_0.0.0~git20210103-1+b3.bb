# This was autogenerated! Do not modify
SUMMARY = "Example KMS/GBM/EGL application"
DESCRIPTION = ""
SECTION = "graphics"
SOURCE_PACKAGE = "kmscube"
HOMEPAGE = "https://cgit.freedesktop.org/mesa/kmscube/"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/k/kmscube/kmscube_0.0.0~git20210103-1+b3_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "a5e38143ba34018815185d27df1b6855"
SRC_URI[deb0.sha1sum] = "6e72150e3a3dfdc5362016590bd300ddc50553bf"
SRC_URI[deb0.sha256sum] = "5a3549ae3a3b24ed0307b7b8e5ac05878447ae4053d25941bc224fa43b4cdab1"
SRC_URI[deb0.sha512sum] = "ebadf95cc8b1df49c335288253a26c0f0bea2561366dfffb37b74c08d63a5f9302e9751789006d08f2b7d0d58405c2d64d009e5a440bc814b8acd621afb2bc16"

RDEPENDS = " \
    libc6 \
    libdrm2 \
    libegl1 \
    libgbm1 \
    libgles2 \
    libglib2.0-0t64 \
    libgstreamer-plugins-base1.0-0 \
    libgstreamer1.0-0 \
    libpng16-16t64 \
"

