# This was autogenerated! Do not modify
SUMMARY = "ntpdig SNTP client"
DESCRIPTION = ""
SECTION = "net"
SOURCE_PACKAGE = "ntpsec"
HOMEPAGE = "https://www.ntpsec.org"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/n/ntpsec/ntpsec-ntpdig_1.2.3+dfsg1-8_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/n/ntpsec/ntpsec-ntpdig_1.2.3+dfsg1-8_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "518986e399327c8a69f31c24666e88f3"
SRC_URI[deb0.sha1sum] = "9206d6246b6465827ea08461b5a0762d8910e7a7"
SRC_URI[deb0.sha256sum] = "4c6329cc403643d25a2eeaf1e316210d9dbb63baf6ab628421b6359fca1b0a01"
SRC_URI[deb0.sha512sum] = "d4b5ffde27f2d550f81cf3e3f735b8e3f3e4fa982c85480e223c5e03b728e7cd62a4cbb29c18b96b32c83fbd373a64e91d67bde658e1ecca02b48da5fde692cc"
SRC_URI[deb1.md5sum] = "68449ed49fb268797691999a7717b5c2"
SRC_URI[deb1.sha1sum] = "995fb5d6d40b2d980d067cdda5db3ace5403f90c"
SRC_URI[deb1.sha256sum] = "3be12391c5773daa975354adbd9876f40e8d4649d4d00ad492504d89e9e7e2b0"
SRC_URI[deb1.sha512sum] = "81438717e8a87eef0cdb0cb9c446708c807e2a663426a0960fc65899c4294348010e728d12a3bd6db382dc673fedfdad801220b3ee990ce76a0a85477e7178e2"

RDEPENDS = " \
    python3 \
    python3-ntp \
"

