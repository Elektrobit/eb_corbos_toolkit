# This was autogenerated! Do not modify
SUMMARY = "Rust based network stack for containers"
DESCRIPTION = ""
SECTION = "net"
SOURCE_PACKAGE = "netavark"
HOMEPAGE = "https://github.com/containers/netavark"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/n/netavark/netavark_1.14.0-2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/n/netavark/netavark_1.14.0-2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "328fc64b26ef7cf4a973bfa14ea2b86c"
SRC_URI[deb0.sha1sum] = "92ca7a9b62f94e4cff71697562a3d0b5fd7770f4"
SRC_URI[deb0.sha256sum] = "34820688e7c671e746d88d109d4f7a34ffbb4a013b7dd2035d2762baf8e50a79"
SRC_URI[deb0.sha512sum] = "b9219e1d3005f0f42d5cf98066aa8a83fbd52b38b32ba97f6d68dc983cf8e75f47829bc1f9ff5a00ca47accb709f6e60a8dadb9545e469ec063e437ffd9de0b4"
SRC_URI[deb1.md5sum] = "fc2fbd453b7e7f3ccb8da5ba11f1d5f4"
SRC_URI[deb1.sha1sum] = "cb09099b14c18a6a82f3e75960c0eca0c3051d06"
SRC_URI[deb1.sha256sum] = "6bb2cbfe72e21168033b561b14fae0eeb60c746ea29c497f5e4d276d5654a6e4"
SRC_URI[deb1.sha512sum] = "ebcfda7374ceefdd8dc8d1914938a020aabb18f2fb7a31ec50cc39fd7a681cf1db6d6d1998dd9b868cc7667abefeef2f1c2d4de9664984ee0bdd126c7197ce33"

RDEPENDS = " \
    libc6 \
    libgcc-s1 \
"

RPROVIDES = " \
    container-network-stack \
"
