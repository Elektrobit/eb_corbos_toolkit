# This was autogenerated! Do not modify
SUMMARY = "telnet client"
DESCRIPTION = ""
SECTION = "net"
SOURCE_PACKAGE = "inetutils"
HOMEPAGE = "https://www.gnu.org/software/inetutils/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/i/inetutils/inetutils-telnet_2.6-3+deb13u3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/i/inetutils/inetutils-telnet_2.6-3+deb13u3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "235716be3869b62bc2c2162582e31837"
SRC_URI[deb0.sha1sum] = "b87884dcd2d6dfcbef9110cbc307fee22c77d72d"
SRC_URI[deb0.sha256sum] = "9b608258e9695c71392f41b19f416de0733cb2d75c2282ffb9c7eb165676c97a"
SRC_URI[deb0.sha512sum] = "d5a24ce3ba5ce9a07a22f6aec363da32469c0ff0e40f6abf412031049e75622936fa2035bdd2c877ceccc690459ef049513ae78269515bf130d5f90a2e8a6a8a"
SRC_URI[deb1.md5sum] = "fda360a935e01c253e03fcf705faf7a2"
SRC_URI[deb1.sha1sum] = "69cdfd74e381a17079def1ae7be177f3cb8f446b"
SRC_URI[deb1.sha256sum] = "e5a96398f54b55f1aaed9ff143084580c8e08099046a1f21cd02cfc5bec79af2"
SRC_URI[deb1.sha512sum] = "7c61cf4c2f9e576b5fc24c964b9a566b1865fb8d79539c1d7109ce441d2c971520e25dcad55c00883d051588353be56e517d49865c62ee946d9acd84f292f4dd"

RDEPENDS = " \
    libc6 \
    libcom-err2 \
    libk5crypto3 \
    libkrb5-3 \
    libtinfo6 \
    netbase \
"

RPROVIDES = " \
    telnet \
    telnet-client \
"
