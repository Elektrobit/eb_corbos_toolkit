# This was autogenerated! Do not modify
SUMMARY = "multipurpose relay for bidirectional data transfer"
DESCRIPTION = ""
SECTION = "net"
SOURCE_PACKAGE = "socat"
HOMEPAGE = "https://www.dest-unreach.org/socat/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/socat/socat_1.8.0.3-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/socat/socat_1.8.0.3-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "37e75fbd86bc90c4c908bf9aedc4cd8c"
SRC_URI[deb0.sha1sum] = "37c6de3f1d589800dcaf20979c2e209ab65975ef"
SRC_URI[deb0.sha256sum] = "6ad18d699071c1e0e3b1e9acd020368544369d339607e80b7eca97bcf4f97017"
SRC_URI[deb0.sha512sum] = "f0555412264f16308cf497dccb5db16118bdd82a3dada4bf865c7e4681b9ee1abb16db84598da498e26f7fa3ecf11388c5a3aaaf16476e4f0f97865e70ef681f"
SRC_URI[deb1.md5sum] = "26546e912046027b297d88494f18a1ba"
SRC_URI[deb1.sha1sum] = "493b336ad97e9592797bd9cdd3aa5365ec5c5ab6"
SRC_URI[deb1.sha256sum] = "935b5ea942807ed82507bf585ae4e666937ebf5c910c5bbe6887ea2b22f19a44"
SRC_URI[deb1.sha512sum] = "6713e0f580e40bc72b3c6961d42fa29d30ef6cf8b3dcfe898ee33d704767763211cb7d629e2dea5116e30f0dc0296370b3fb3ee51edaa2bf94da26f6f73a898e"

RDEPENDS = " \
    libc6 \
    libssl3t64 \
    libwrap0 \
"

