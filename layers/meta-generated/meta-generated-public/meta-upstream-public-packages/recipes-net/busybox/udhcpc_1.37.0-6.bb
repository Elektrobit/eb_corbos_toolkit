# This was autogenerated! Do not modify
SUMMARY = "Provides the busybox DHCP client implementation"
DESCRIPTION = ""
SECTION = "net"
SOURCE_PACKAGE = "busybox"
HOMEPAGE = "http://www.busybox.net"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/b/busybox/udhcpc_1.37.0-6_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "4025d584f037e81b1a6963de127580f3"
SRC_URI[deb0.sha1sum] = "3de7b45152a160ccd046d121c1ccdce2dcfae5f7"
SRC_URI[deb0.sha256sum] = "4a3c3460cc33120d872d6d9a181a30b35a8615e2335949ba021dd367fa52b8f2"
SRC_URI[deb0.sha512sum] = "7af07b06da1ae7b84e80dc978afde89295193044829b4e86e0eae41e8dda397820523a85335f323128a6f7e46301bdaded4a5fcfddf7c9039a4208511b658924"

RDEPENDS = " \
    busybox \
"

