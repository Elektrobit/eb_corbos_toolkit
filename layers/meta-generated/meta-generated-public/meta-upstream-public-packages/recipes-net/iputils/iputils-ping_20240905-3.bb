# This was autogenerated! Do not modify
SUMMARY = "Tools to test the reachability of network hosts"
DESCRIPTION = ""
SECTION = "net"
SOURCE_PACKAGE = "iputils"
HOMEPAGE = "https://github.com/iputils/iputils/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/i/iputils/iputils-ping_20240905-3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/i/iputils/iputils-ping_20240905-3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "01696d672a1a8cfb1f833fad31f2ef26"
SRC_URI[deb0.sha1sum] = "0d3c6b7145cafb895824363a0a21451786cb9311"
SRC_URI[deb0.sha256sum] = "a78f6118527796bde8c34d410dda1e5457f4e4e2de080a0b852cd59d7058ef6f"
SRC_URI[deb0.sha512sum] = "a9edd1b6d53ed92ce22b730315b911636e326760574f8cd21a48a0647fec2680c64c8b71db3c1628e510cce906ff4b27ee92a49c5beab10ed6add0c7902cf971"
SRC_URI[deb1.md5sum] = "33692dc20ec6ff3ed5c740678bd58884"
SRC_URI[deb1.sha1sum] = "f8c2f0e963bf8561f13915d3653f64cfd797d3bd"
SRC_URI[deb1.sha256sum] = "b3072df313074159ad7a22f46043d4bac7c36a452a45194fa320574704da5c85"
SRC_URI[deb1.sha512sum] = "f8b41f79a610787313f9d62cc28c72eeaac7ff43e99468545d085481f9c7afeaff2b3a276e06e14722deaef1eab200ce373da22043f6218e75d9577cba4f2cd9"

RDEPENDS = " \
    libc6 \
    libcap2 \
    libidn2-0 \
"

RPROVIDES = " \
    ping \
"
