# This was autogenerated! Do not modify
SUMMARY = "Program to control packet filtering rules by Netfilter project"
DESCRIPTION = ""
SECTION = "net"
SOURCE_PACKAGE = "nftables"
HOMEPAGE = "https://www.netfilter.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/n/nftables/nftables_1.1.3-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/n/nftables/nftables_1.1.3-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "f0359d3369fdf2456a66e702b54af37d"
SRC_URI[deb0.sha1sum] = "56d70bf0da71c8b307fc08a1d38053bb3f325a12"
SRC_URI[deb0.sha256sum] = "2ddfa61baaf3a76e2c499db9e521ba6affb226f85af0b6fef739f346ac5f0c39"
SRC_URI[deb0.sha512sum] = "d0f88259acc2dd2e2f525885872abe8e41d99504cf82147cdd2dfd914df2edc1422dfe3a44d76df482ee2418bee7c1c49e97e299586a69b1e6c2ed720e149bb0"
SRC_URI[deb1.md5sum] = "9355c9e116a1d555b10ed641be29ed4e"
SRC_URI[deb1.sha1sum] = "9eb0614050a2913ae4d9794f4c10a9c2b70f5d5b"
SRC_URI[deb1.sha256sum] = "6cced5fccfbd80a25dfbd4bd17cc16372d08cb76c9d1159532ba0f668aa77c37"
SRC_URI[deb1.sha512sum] = "d50229cfb09d0dc7467ea40e28d1c83a32f4a36c3b92ccbc587cc4e92b8e48ea71a5e5f2a11910639ad33d59d5590d9c15b8f6b4ce4634bab3d37b2583949c63"

RDEPENDS = " \
    libc6 \
    libedit2 \
    libnftables1 \
"

