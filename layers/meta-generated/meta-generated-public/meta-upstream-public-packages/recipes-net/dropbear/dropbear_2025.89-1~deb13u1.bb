# This was autogenerated! Do not modify
SUMMARY = "lightweight SSH2 server and client - startup scripts"
DESCRIPTION = ""
SECTION = "net"
SOURCE_PACKAGE = "dropbear"
HOMEPAGE = "https://matt.ucc.asn.au/dropbear/dropbear.html"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/d/dropbear/dropbear_2025.89-1~deb13u1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "4b2b6e5012fca55846a7f2c9c5775347"
SRC_URI[deb0.sha1sum] = "bcb13c20126bd01b51d73b1cd182a191c7acf136"
SRC_URI[deb0.sha256sum] = "b0cc12d4b93239dc0d41ca34b4a023c0ee3daf1f368b647e04815b36318b8c50"
SRC_URI[deb0.sha512sum] = "ed272356661f09cfca7ba5d411b90194c06fb45607cadcf867caa0ce645c444c145ea76d08caa6405fd1354272cf5513b6bac920fc4a8c09e3eeac242194f2c7"

RDEPENDS = " \
    dropbear-bin \
    init-system-helpers \
"

