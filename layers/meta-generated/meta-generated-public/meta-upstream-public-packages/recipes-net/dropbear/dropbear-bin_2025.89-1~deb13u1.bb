# This was autogenerated! Do not modify
SUMMARY = "lightweight SSH2 server and client - command line tools"
DESCRIPTION = ""
SECTION = "net"
SOURCE_PACKAGE = "dropbear"
HOMEPAGE = "https://matt.ucc.asn.au/dropbear/dropbear.html"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/d/dropbear/dropbear-bin_2025.89-1~deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/d/dropbear/dropbear-bin_2025.89-1~deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "bc7286cc3cf37a6f90ec818d7ced5cb7"
SRC_URI[deb0.sha1sum] = "db8f3df431c441b24e398fa60d95b90b82428d5f"
SRC_URI[deb0.sha256sum] = "1ddbd76749c7076097fb899eaf55f0a398d6f62799a6000501b32ed7b5d9257b"
SRC_URI[deb0.sha512sum] = "1dee67f4d57a1639960139e63475dd56eab99cbc729a573298340049a38b4d8dd8c982e397fde03d1e4665a5c9928e6b94ab6c3827716956f37d8ec1d8e9a88e"
SRC_URI[deb1.md5sum] = "155f8d5848a468ec0ee38d4b6f3b97d9"
SRC_URI[deb1.sha1sum] = "9d99b0647f4c8c08bff04212e26387e2f2960edf"
SRC_URI[deb1.sha256sum] = "1cfab9f1d5dbf89a8ad790cafe5585a8e08a7c0e0ce098c7a89f957a6428976e"
SRC_URI[deb1.sha512sum] = "877ee15bcf783915dfdf844a8b5142f47d2d5a92f6194b57b17abea1318692947b1ab27284a40624278ee2959887d944c007e77bc84ba9746e84fbc77c629e81"

RDEPENDS = " \
    libc6 \
    libcrypt1 \
    libtomcrypt1 \
    libtommath1 \
    zlib1g \
"

RPROVIDES = " \
    ssh-server \
"
