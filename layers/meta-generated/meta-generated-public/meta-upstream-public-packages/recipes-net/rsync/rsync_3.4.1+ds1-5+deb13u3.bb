# This was autogenerated! Do not modify
SUMMARY = "fast, versatile, remote (and local) file-copying tool"
DESCRIPTION = ""
SECTION = "net"
SOURCE_PACKAGE = "rsync"
HOMEPAGE = "https://rsync.samba.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/r/rsync/rsync_3.4.1+ds1-5+deb13u3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/r/rsync/rsync_3.4.1+ds1-5+deb13u3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "ae38ddc1d451d5b6fc746bfad0f2cc12"
SRC_URI[deb0.sha1sum] = "7cb1fc9b7fed9a2b1ac949a8a3a0789f1ba7f595"
SRC_URI[deb0.sha256sum] = "fee3fa3b5924cc7e0964603945e0edfd63b7f29fc3cd4cf7613ad970e05a55be"
SRC_URI[deb0.sha512sum] = "531d663a354d4d15bdd3f9330ca866da8369136608e9236f14bb857c2120816708cc545606cea129c002cd79f5eb45115097d4b513b55e360b11029988104b65"
SRC_URI[deb1.md5sum] = "9614695e969174eba14a76dc0ad99605"
SRC_URI[deb1.sha1sum] = "71dfae506ceab835060660fa56eeff819f008a57"
SRC_URI[deb1.sha256sum] = "172d2fdf663842132654c866ce7863277c79486cd81766fa855ff9581c85f806"
SRC_URI[deb1.sha512sum] = "c873cd8a72e31c92eed742ea8c1a3419e42b2fa7a19027de762565596ca6e08263e14cd664da80be1b2d7452774e2b3c31408c8ee983d03f18510c74c6ee3af3"

RDEPENDS = " \
    init-system-helpers \
    libacl1 \
    libc6 \
    liblz4-1 \
    libpopt0 \
    libssl3t64 \
    libxxhash0 \
    libzstd1 \
    zlib1g \
"

