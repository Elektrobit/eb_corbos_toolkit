# This was autogenerated! Do not modify
SUMMARY = "secure shell (SSH) sftp server module, for SFTP access from remote machines"
DESCRIPTION = ""
SECTION = "net"
SOURCE_PACKAGE = "openssh"
HOMEPAGE = "https://www.openssh.com/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/o/openssh/openssh-sftp-server_10.0p1-7+deb13u2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/o/openssh/openssh-sftp-server_10.0p1-7+deb13u2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "9634eafa552773f2de8b69f06ef1778d"
SRC_URI[deb0.sha1sum] = "e8f5d8a5a9bfe1bcde39a451fc7dbeb6e29d6470"
SRC_URI[deb0.sha256sum] = "ceafc87f74e71d2b8346f7715064bfee197bdf2848e0a425e370e5cc4317d1f4"
SRC_URI[deb0.sha512sum] = "255ae734ff48866c0442852bbfc72dbc55fee1d83574148c2cf52dfb310f70b5c57e33462c1704ecb042f8f0444424fe1a1e7e68387d63cb36a3cb64da8bbb15"
SRC_URI[deb1.md5sum] = "a08d16464f0a3fb6c4b0f41cdb24051b"
SRC_URI[deb1.sha1sum] = "c6461602dd8f0474e7955f4f4ebe8607091130ad"
SRC_URI[deb1.sha256sum] = "92456a2b0a0d71168e016c4d01fad2758c11d40ba941ebec7c084d89d205d40d"
SRC_URI[deb1.sha512sum] = "aaa63afcde407af04198a43c6ebd5a099ac6292e85fa50e5076e6a62dd295527975a545e3c3af75505a6b11d9c2339e9d02c0d5f4812db238971a8003e39e455"

RDEPENDS = " \
    libc6 \
    openssh-client \
"

