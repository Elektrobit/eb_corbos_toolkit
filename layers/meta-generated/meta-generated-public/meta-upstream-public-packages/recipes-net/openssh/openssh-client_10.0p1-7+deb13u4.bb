# This was autogenerated! Do not modify
SUMMARY = "secure shell (SSH) client, for secure access to remote machines"
DESCRIPTION = ""
SECTION = "net"
SOURCE_PACKAGE = "openssh"
HOMEPAGE = "https://www.openssh.com/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/o/openssh/openssh-client_10.0p1-7+deb13u4_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/o/openssh/openssh-client_10.0p1-7+deb13u4_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "fa3bfa5bb344f08c54873de520c80b3b"
SRC_URI[deb0.sha1sum] = "709e2f6d3d83445285e5ae02d89695c644dcb6e7"
SRC_URI[deb0.sha256sum] = "8fff343654f86c3b3266f94cd338c7b4da2e386da029327815118ea00bce03b9"
SRC_URI[deb0.sha512sum] = "d6bdfc80231e3745b943fba931ea626736f3c7db3d6785227a902e8ad737ab4947bb7a55b6355358d0a01626b3126ccc36ccb91c61884d0aace18518c7e9e0e5"
SRC_URI[deb1.md5sum] = "40b1983eacc2be439888e235b39e5658"
SRC_URI[deb1.sha1sum] = "a11a3a99492a69b6cfa862dfb1197334ca08bce3"
SRC_URI[deb1.sha256sum] = "e900c13c9a5267714fc2c2c1f369fe4a667c7dd4031266b1480250320f0bfcfb"
SRC_URI[deb1.sha512sum] = "95525e8cebe79681412760c88cd18dc8cad3140db0db2d95397e784de4718cd6d82257677037f017456fee562f4b95ba639762a11eeb1483fafb2e47b9c81f2e"

RDEPENDS = " \
    adduser \
    init-system-helpers \
    libc6 \
    libedit2 \
    libfido2-1 \
    libgssapi-krb5-2 \
    libselinux1 \
    libssl3t64 \
    passwd \
    zlib1g \
"

RPROVIDES = " \
    ssh-client \
"
