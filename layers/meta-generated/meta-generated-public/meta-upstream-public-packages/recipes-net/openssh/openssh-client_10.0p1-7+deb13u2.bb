# This was autogenerated! Do not modify
SUMMARY = "secure shell (SSH) client, for secure access to remote machines"
DESCRIPTION = ""
SECTION = "net"
SOURCE_PACKAGE = "openssh"
HOMEPAGE = "https://www.openssh.com/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/o/openssh/openssh-client_10.0p1-7+deb13u2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/o/openssh/openssh-client_10.0p1-7+deb13u2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "2cf37c18d452937e9f6e96d21214214d"
SRC_URI[deb0.sha1sum] = "81ee5403559c692363d565aad95d8269b99847ed"
SRC_URI[deb0.sha256sum] = "e6bbb079e06539ecebd598b74f7725299ba61cebd64a2cfb09f2bab8fbe25d18"
SRC_URI[deb0.sha512sum] = "477564342352a7226ad7ee595c65ca93c4041b7706578fd68573f6ac6da36fcc997af69f2f8370b3594e3c97549c11d763d0692bd02a465be1a9cfa0c61c7767"
SRC_URI[deb1.md5sum] = "766a83bdd1ee364496199ef23db5ccba"
SRC_URI[deb1.sha1sum] = "09447282ec3c6c5a02e218e7681bb636c6754582"
SRC_URI[deb1.sha256sum] = "d593a6b189b10109fce7804229e8649c11d4d1918824a0ba5ef256739ebee470"
SRC_URI[deb1.sha512sum] = "1d779bf38d766718fba9d0fae7cfd3e76b820d1ea33b162022e5ae539b232178667d4cbb5636538982b546fca7216691bec1d805e4c8edaf22eaef54808306bd"

RDEPENDS = " \
    adduser \
    init-system-helpers \
    libc6 \
    libedit2 \
    libfido2-1 \
    libgssapi-krb5-2 \
    libselinux1 \
    libssl3t64 \
    passwd \
    zlib1g \
"

RPROVIDES = " \
    ssh-client \
"
