# This was autogenerated! Do not modify
SUMMARY = "secure shell (SSH) server, for secure access from remote machines"
DESCRIPTION = ""
SECTION = "net"
SOURCE_PACKAGE = "openssh"
HOMEPAGE = "https://www.openssh.com/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/o/openssh/openssh-server_10.0p1-7+deb13u4_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/o/openssh/openssh-server_10.0p1-7+deb13u4_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "5de34f9768b5d34fb54eebafbd94bdba"
SRC_URI[deb0.sha1sum] = "285796817a5bbd0a69465876cf7dec2f367d9f27"
SRC_URI[deb0.sha256sum] = "b4a02524fd2be375624d917ee8102a16567e9e8dd786b41c35e22360cdd37f9d"
SRC_URI[deb0.sha512sum] = "844cfa5ef7e4c1301a56304eff144186d82ebeabdf1f3522001907c2d9860b3ee84103aee39bf12b9365dc41c976e2c9d0fca50e73cd9a2b9a7a52d97bc1419e"
SRC_URI[deb1.md5sum] = "40ecc8867769b27520b4f0d6f525116e"
SRC_URI[deb1.sha1sum] = "9e387c1f81a8f337adf1ce6fc77805db5910a675"
SRC_URI[deb1.sha256sum] = "6da10564d3747e5f8fcca9595e154d863fdef786c3384ccd24e518c1fc45e41d"
SRC_URI[deb1.sha512sum] = "08bc65907ad8060b36f28789b5757d00e70156cc597e7552356baf744cb540b5be106bc07be17320bf661d89ac8e595bbe9e446106bf027eeca4eae908b36c2c"

RDEPENDS = " \
    debconf \
    init-system-helpers \
    libaudit1 \
    libc6 \
    libcom-err2 \
    libcrypt1 \
    libgssapi-krb5-2 \
    libkrb5-3 \
    libpam-modules \
    libpam-runtime \
    libpam0g \
    libselinux1 \
    libssl3t64 \
    libwrap0 \
    libwtmpdb0 \
    lsb-base \
    openssh-client \
    openssh-sftp-server \
    procps \
    runit-helper \
    systemd \
    ucf \
    zlib1g \
"

RPROVIDES = " \
    ssh-server \
"
