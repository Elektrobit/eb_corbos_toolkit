# This was autogenerated! Do not modify
SUMMARY = "secure shell (SSH) sftp server module, for SFTP access from remote machines"
DESCRIPTION = ""
SECTION = "net"
SOURCE_PACKAGE = "openssh"
HOMEPAGE = "https://www.openssh.com/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/o/openssh/openssh-sftp-server_10.0p1-7+deb13u4_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/o/openssh/openssh-sftp-server_10.0p1-7+deb13u4_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "157439ae5ee470e0c8026d31f8df7a95"
SRC_URI[deb0.sha1sum] = "22e35118a8bf3c69353bfa6728406b32dbe7f58a"
SRC_URI[deb0.sha256sum] = "28a82485438fafc8d6a7552ab61cac827338c16f39e3790d6ebcc146d452e542"
SRC_URI[deb0.sha512sum] = "25e572ddc8c9547308e1a89ac3f7edc761ba5c0947a2265e46df377e917a85b83e6f4396c286287c92fba85b5e265256465eff6d50af43e8bf6004be6ef06bc8"
SRC_URI[deb1.md5sum] = "af79876b8c4865c81409de8e0d4b3d2f"
SRC_URI[deb1.sha1sum] = "43bce85afefc6667077ee4bac37d0c2a24ce8cca"
SRC_URI[deb1.sha256sum] = "c949831340f9af9e70a6dab740fc9cdff6dd0b249bf9d7d640f6486036476e05"
SRC_URI[deb1.sha512sum] = "694c622cfa3b0e2eff27a4625b1fe277d1139aa0b246a7c2ffcbbc8646f401e82cea337e40f5e6dca1ad50fd5854e51306a1c891e99b3a2abdedaf136d0d8354"

RDEPENDS = " \
    libc6 \
    openssh-client \
"

