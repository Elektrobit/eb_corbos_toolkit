# This was autogenerated! Do not modify
SUMMARY = "secure shell (SSH) server, for secure access from remote machines"
DESCRIPTION = ""
SECTION = "net"
SOURCE_PACKAGE = "openssh"
HOMEPAGE = "https://www.openssh.com/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/o/openssh/openssh-server_10.0p1-7+deb13u2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/o/openssh/openssh-server_10.0p1-7+deb13u2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "cae7a8639e6a744765925b87a11aaf7d"
SRC_URI[deb0.sha1sum] = "cde7a0ac2f7608aa3d99f662209f274d3d199cd5"
SRC_URI[deb0.sha256sum] = "46e9d73149ba34744d17f5859e8e7f0277f3f7f2daf078dd4f477dd1798f7b78"
SRC_URI[deb0.sha512sum] = "eda0e0b135e37285e309ed76ad175b0fd0760149818bdfe64e45fbd551b1b4093d2c8be556a1618a543a5d19921b5047fbd52191a90e827afda9319706354e4a"
SRC_URI[deb1.md5sum] = "fc4e0e5f202eafe82963af3a44b3effd"
SRC_URI[deb1.sha1sum] = "276b8ee641af55364bc81bd48e75aa7ab335081f"
SRC_URI[deb1.sha256sum] = "3f27c087fe6c28e40a0bbc096f5289cd4afee34a9a3f4746e09a954dede23045"
SRC_URI[deb1.sha512sum] = "275eb12aa87e9c1e249a6d3b7124bd81ceb8ee3dc21cebaae48a69113c4c2ff2f94aae201402dec50a1aff41db56a7ab47a2591a330e2b8d204baf3cce19785d"

RDEPENDS = " \
    debconf \
    init-system-helpers \
    libaudit1 \
    libc6 \
    libcom-err2 \
    libcrypt1 \
    libgssapi-krb5-2 \
    libkrb5-3 \
    libpam-modules \
    libpam-runtime \
    libpam0g \
    libselinux1 \
    libssl3t64 \
    libwrap0 \
    libwtmpdb0 \
    lsb-base \
    openssh-client \
    openssh-sftp-server \
    procps \
    runit-helper \
    systemd \
    ucf \
    zlib1g \
"

RPROVIDES = " \
    ssh-server \
"
