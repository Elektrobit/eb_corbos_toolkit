# This was autogenerated! Do not modify
SUMMARY = "Miscellaneous Mesa utilities -- symlinks"
DESCRIPTION = ""
SECTION = "x11"
SOURCE_PACKAGE = "mesa-demos"
HOMEPAGE = "https://mesa3d.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/m/mesa-demos/mesa-utils_9.0.0-2+b2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/m/mesa-demos/mesa-utils_9.0.0-2+b2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "9893a7e049d6dc62740ef9757a4c11b4"
SRC_URI[deb0.sha1sum] = "2021f57850ff1150bea8bb78da68a69be7147029"
SRC_URI[deb0.sha256sum] = "c2566e84a65e630745a4341518ba40e03d903157a0a54bfcaf563954df1c125d"
SRC_URI[deb0.sha512sum] = "420be8fbfcc78342eb00f3074b6e4b7846e3fdbb20e091b51c0540cb615445bb5fd915ed031a55ef48b0b350925dc44cc58a8692fbab3eb7ccee3bc2a821119e"
SRC_URI[deb1.md5sum] = "fbaf45a88e34feeb09113490233ed0f0"
SRC_URI[deb1.sha1sum] = "23f138ba2347760c6c885877244a2b4be02eaaed"
SRC_URI[deb1.sha256sum] = "aaa2276c9e679c811fb980c98e20acbd5ea93403a8d92792315f05f82a2e2bee"
SRC_URI[deb1.sha512sum] = "f751d1f1608600b3baece1c177931ede208c13e1075f43115e480d2f9950456d0b1c8f891c6c222292c568f235eb2ad9b56205a32c46e67c5e94f9b739fdc389"

RDEPENDS = " \
    mesa-utils-bin \
"

RPROVIDES = " \
    mesa-utils-extra \
"
