# This was autogenerated! Do not modify
SUMMARY = "Miscellaneous Mesa utilities -- native applications"
DESCRIPTION = ""
SECTION = "x11"
SOURCE_PACKAGE = "mesa-demos"
HOMEPAGE = "https://mesa3d.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/m/mesa-demos/mesa-utils-bin_9.0.0-2+b2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/m/mesa-demos/mesa-utils-bin_9.0.0-2+b2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "c4881a65478d63a06a6919f47db3a5b2"
SRC_URI[deb0.sha1sum] = "0e3036c43be9428ac45d5e3beddd970f1d4654c0"
SRC_URI[deb0.sha256sum] = "26ab6bf7ff781cb903a6b1b3518a1926a799024289853cc3693ee0dd922e1e13"
SRC_URI[deb0.sha512sum] = "13c7a48f5d5930a29910b295b1d41dcee1c0612a45683b0cf15016890499b3bf4d4c05e58b4119bbe902f2fb567d4f254613b08d42a391b25b8f822ee03ecfaf"
SRC_URI[deb1.md5sum] = "a5ca109c08136047306e4fc12f0e6f99"
SRC_URI[deb1.sha1sum] = "c1e8f2396fc2b0d4c3bb8ea774ac9a7874c94eb7"
SRC_URI[deb1.sha256sum] = "e7906035da53770d63ff477f626c0c7209a799caf781714b229263a3d75ec03c"
SRC_URI[deb1.sha512sum] = "dcb431c6017e91dff9df919fb630d3862d706be6fbf4982a868390c0631ce50c1219ed859e9c65a98b72f5973e8999842ca6b8d53b7204f2c6aa5a1b114b94a6"

RDEPENDS = " \
    libc6 \
    libdecor-0-0 \
    libegl1 \
    libgl1 \
    libgles2 \
    libvulkan1 \
    libwayland-client0 \
    libwayland-egl1 \
    libx11-6 \
    libxcb1 \
    libxkbcommon-x11-0 \
    libxkbcommon0 \
"

