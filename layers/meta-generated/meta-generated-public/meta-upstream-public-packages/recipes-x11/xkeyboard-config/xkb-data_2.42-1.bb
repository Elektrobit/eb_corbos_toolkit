# This was autogenerated! Do not modify
SUMMARY = "X Keyboard Extension (XKB) configuration data"
DESCRIPTION = ""
SECTION = "x11"
SOURCE_PACKAGE = "xkeyboard-config"
HOMEPAGE = "https://www.freedesktop.org/Software/XKeyboardConfig"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/x/xkeyboard-config/xkb-data_2.42-1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "41cd184e1d171bc57537a464e50bf049"
SRC_URI[deb0.sha1sum] = "479c272cd4ccdd68bda778cc0bf2d3b45efc14d7"
SRC_URI[deb0.sha256sum] = "196ff18533382f64e057ea49df2bb486bd4275a4cc0917361edb560b8756dada"
SRC_URI[deb0.sha512sum] = "f5178e962ce7e2e6ee6358ba17279644a44a979b0a5d5e97ae1b8171ea6642c4f187937bf1baf1d2828bc13a3f44a248aec55000604f5889e8cb093df5ef6640"


