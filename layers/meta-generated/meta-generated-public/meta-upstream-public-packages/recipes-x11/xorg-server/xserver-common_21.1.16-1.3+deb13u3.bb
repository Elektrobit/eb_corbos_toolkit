# This was autogenerated! Do not modify
SUMMARY = "common files used by various X servers"
DESCRIPTION = ""
SECTION = "x11"
SOURCE_PACKAGE = "xorg-server"
HOMEPAGE = "https://www.x.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/x/xorg-server/xserver-common_21.1.16-1.3+deb13u3_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "4fb06dfe4008a0e40996408ddbd37153"
SRC_URI[deb0.sha1sum] = "9d0862098a3a832c261be3b859e6c25697cd4e63"
SRC_URI[deb0.sha256sum] = "dc1d37303c103b23c40cd1ea694c5c6561e0e8dc1734a73c7a0ae0ef080e7fcc"
SRC_URI[deb0.sha512sum] = "67579c1d032eee9368df4c4136e2903aed9662110a112d2c0ffa42e78679b037bb982ed53a166d9aaeff26609654c227d8e0d7d48a11f56c562c77bfde72f6dc"

RDEPENDS = " \
    x11-common \
    x11-xkb-utils \
    xkb-data \
"

