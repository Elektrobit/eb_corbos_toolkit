# This was autogenerated! Do not modify
SUMMARY = "X Window System (X.Org) infrastructure"
DESCRIPTION = ""
SECTION = "x11"
SOURCE_PACKAGE = "xorg"
HOMEPAGE = "https://www.x.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/x/xorg/x11-common_7.7+24+deb13u1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "42a54bbde764cb159b09a596ce8ac685"
SRC_URI[deb0.sha1sum] = "65af037a9c38f03be4b9d2c9a231b5808094e002"
SRC_URI[deb0.sha256sum] = "57a981938506b26dc552f19cafeaa8c04e9b59dc7508509151f8507a9d4e5f24"
SRC_URI[deb0.sha512sum] = "aefdc5297adee483a050596014ba21e30860a7d7970e1d82fc11670fe1c0391b2c5c0ce8b64bb499391bf5d82f6171ebb4dab593d4fec744168156abfc97c822"

RDEPENDS = " \
    lsb-base \
"

