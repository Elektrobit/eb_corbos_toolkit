# This was autogenerated! Do not modify
SUMMARY = "X server for running X clients under Wayland"
DESCRIPTION = ""
SECTION = "x11"
SOURCE_PACKAGE = "xwayland"
HOMEPAGE = "https://www.x.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/x/xwayland/xwayland_24.1.6-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/x/xwayland/xwayland_24.1.6-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "8547ebf95c34cc8098a15d30f1a73422"
SRC_URI[deb0.sha1sum] = "4e31c91efbee3a4cbaeae8c0962c19dba7c5176c"
SRC_URI[deb0.sha256sum] = "7e51a144e858d5be7e91d6644c2758a618e425c7222234d2e8f059e5aba6c1f5"
SRC_URI[deb0.sha512sum] = "1a5bc79ebaeabc3d38b3363c9fa20a877f87e2011d72f3410889f67eeb216dfa09ebfda24745e2d2e8fcde29d2e4cd04ff2421bcb46f8370607c7bc9b7bad275"
SRC_URI[deb1.md5sum] = "c916cee4bd91c110c69619b22ae9b7af"
SRC_URI[deb1.sha1sum] = "5f99ad27cf7287ee10cfe22d76e9a8cafb7a9f39"
SRC_URI[deb1.sha256sum] = "15d8ba1f5ddfab5872f61af5dfb383fab5862efaba30e330b0f276f485103363"
SRC_URI[deb1.sha512sum] = "378a1f256604d7571e669e87ca655e061fb50f95b1391becfe4a894bea1275168218d765189bc99d7ba720995ec625e47db2fa47b5107b3db23e0e5b3cc0ff8c"

RDEPENDS = " \
    libc6 \
    libdecor-0-0 \
    libdrm2 \
    libepoxy0 \
    libgbm1 \
    libgcrypt20 \
    libgl1 \
    libpixman-1-0 \
    libtirpc3t64 \
    libwayland-client0 \
    libxau6 \
    libxcvt0 \
    libxdmcp6 \
    libxfont2 \
    libxshmfence1 \
    xserver-common \
"

