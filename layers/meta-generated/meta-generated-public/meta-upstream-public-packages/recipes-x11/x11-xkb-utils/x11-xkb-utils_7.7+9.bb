# This was autogenerated! Do not modify
SUMMARY = "X11 XKB utilities"
DESCRIPTION = ""
SECTION = "x11"
SOURCE_PACKAGE = "x11-xkb-utils"
HOMEPAGE = ""

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/x/x11-xkb-utils/x11-xkb-utils_7.7+9_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/x/x11-xkb-utils/x11-xkb-utils_7.7+9_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "2f8d992c416a75831461d48021f22bb5"
SRC_URI[deb0.sha1sum] = "b6e83d3eb45f43f6fbfba610b680a4d79f4eca1e"
SRC_URI[deb0.sha256sum] = "745e29c79bb435d057cdbf8bb59a35fa33e818e566cb754674f44d381ccd4317"
SRC_URI[deb0.sha512sum] = "70fa2d5d26ee7755ec85f561b17412371b9c2dd3f0626b09e1d9869295b7b85fb2645da7d1bd37eeef992e0c98585b30674bd09aedf22dc962096e3946667608"
SRC_URI[deb1.md5sum] = "5977ddd90e43016c28d81fbd8e1b1d8e"
SRC_URI[deb1.sha1sum] = "043d3b88cea9486f2adc25c49c7070ef85204522"
SRC_URI[deb1.sha256sum] = "10ed52feb9520bddc6ecaa77fafb47e961b5f6310c539848ca478b31fe110cac"
SRC_URI[deb1.sha512sum] = "66b6c6a9bd5c54ab26926726450f6b49427196f60b72926af41bc34ea12ef189cd3e3c14bde54259558b3b107be56443ae89a6ae01aea594d911f6d172a5b24d"

RDEPENDS = " \
    libc6 \
    libx11-6 \
    libxaw7 \
    libxkbfile1 \
    libxrandr2 \
    libxt6t64 \
"

