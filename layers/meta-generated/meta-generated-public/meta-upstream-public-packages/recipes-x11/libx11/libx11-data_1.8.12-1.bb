# This was autogenerated! Do not modify
SUMMARY = "X11 client-side library"
DESCRIPTION = ""
SECTION = "x11"
SOURCE_PACKAGE = "libx11"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libx/libx11/libx11-data_1.8.12-1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "1c54a8670f2640f5cf999c5da9d5f88c"
SRC_URI[deb0.sha1sum] = "7791f7c6ff038c7fad4677f8ce9be34d80f25284"
SRC_URI[deb0.sha256sum] = "c54f87069888f80ba4da586da6147d74c7598ccdd8b90906dbc4271fa414c738"
SRC_URI[deb0.sha512sum] = "2e819871bbf95b9d3d8f414218bfd615329ec204cb5e8fb6e8ee13daa42dede42e8a458a0c7a7dfcec48cea368adf9b689bca70ab68a8ce8b74056d89189462c"


