# This was autogenerated! Do not modify
SUMMARY = "programmable completion for the bash shell"
DESCRIPTION = ""
SECTION = "shells"
SOURCE_PACKAGE = "bash-completion"
HOMEPAGE = "https://github.com/scop/bash-completion"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/b/bash-completion/bash-completion_2.16.0-7_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "06a418478e9eda6dab983720bfe0fd09"
SRC_URI[deb0.sha1sum] = "3d1fdb798fb62c3b24d71c84da85f7aa6348941e"
SRC_URI[deb0.sha256sum] = "e94b49cbfeccbf620effb20f4e9968bbbe6a5acbe0a5d7140ba394249060464a"
SRC_URI[deb0.sha512sum] = "0de1c101c052eb187574ce83b935cd772c6e4fd61dc2a7acb0d3d4e8d778aeefd2c3eb01b5c1a0a9d78c02b430a1ef807bf35fb0c0ce52d2b43c70894122a021"


RPROVIDES = " \
    dh-sequence-bash-completion \
"
