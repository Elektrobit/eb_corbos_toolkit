# This was autogenerated! Do not modify
SUMMARY = "GNU Bourne Again SHell"
DESCRIPTION = ""
SECTION = "shells"
SOURCE_PACKAGE = "bash"
HOMEPAGE = "http://tiswww.case.edu/php/chet/bash/bashtop.html"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/b/bash/bash_5.2.37-2+b9_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/b/bash/bash_5.2.37-2+b9_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "b46d92faeaa057561a5e202e650cf91b"
SRC_URI[deb0.sha1sum] = "90635a5ba6bb88221f8cb706aa07e4b23bd9a933"
SRC_URI[deb0.sha256sum] = "03571d298ed24c615641d54dec4eb023ef5710a2b8cb9304acb66e372cab9c46"
SRC_URI[deb0.sha512sum] = "796ba090bce7d41f889115599155828035bf99164738e83741cedf9e5773bcecb56143084c77861a598c30f1f3e4abed015b3380fea50631477a2ddeb3bfd3c4"
SRC_URI[deb1.md5sum] = "9da5bf6fd5608a17ccedd97794837be8"
SRC_URI[deb1.sha1sum] = "ea5ae8b4e9b17f985753870669e27d8e92818a9c"
SRC_URI[deb1.sha256sum] = "f9b0e4eb4ae81b3934a3211d755de26fa03881af3f159eb582437d3e8f55d9eb"
SRC_URI[deb1.sha512sum] = "b1f09e6715e4ef7d75ca14f2ca0b12d5faf7d353b1b05f5ff715457f6c927b2c03bd17dbd1d24f7b7e601d0094844c29192836145b2ca3f7e5fb364b81face40"

RDEPENDS = " \
    base-files \
    debianutils \
    libc6 \
    libtinfo6 \
"

