# This was autogenerated! Do not modify
SUMMARY = "POSIX-compliant shell"
DESCRIPTION = ""
SECTION = "shells"
SOURCE_PACKAGE = "dash"
HOMEPAGE = "http://gondor.apana.org.au/~herbert/dash/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/d/dash/dash_0.5.12-12_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/d/dash/dash_0.5.12-12_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "f7adc68081bf80c88b5517daeccc5d03"
SRC_URI[deb0.sha1sum] = "624913997e172c9a330940051c719c832d9517ac"
SRC_URI[deb0.sha256sum] = "a8902cb6d8650134764a25fb80aec8589d858ef71ece1680a62e84816c37bb04"
SRC_URI[deb0.sha512sum] = "bb860aae227bc37300174ca2c00281a34ae1a663ee7f0cc93de8fead56b190bcc724a217f0430e0948106c6214a2ac73de93b7944eb9a47e707e8773240991ef"
SRC_URI[deb1.md5sum] = "b2c040db45db062d2c48d0eb6e325c3e"
SRC_URI[deb1.sha1sum] = "65968266af76d9fb9fd731e64e9d1f5264778817"
SRC_URI[deb1.sha256sum] = "ce4c8688a1a3ea510186ba95aba74d4c49863094e47e1effc0b602839e840c04"
SRC_URI[deb1.sha512sum] = "9583afe382ec61e2fdc4a06b599c063ab6a9a490c2537d41ed3cba3bb69815c5d2e99fa2a4bf96487b230f96017f06d47653c2f70b2b1dcc2d9a9d31d2293b3d"

RDEPENDS = " \
    debianutils \
    libc6 \
"

