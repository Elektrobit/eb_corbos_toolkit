# This was autogenerated! Do not modify
SUMMARY = "OpenPGP archive certificates of the Debian archive"
DESCRIPTION = ""
SECTION = "misc"
SOURCE_PACKAGE = "debian-archive-keyring"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/d/debian-archive-keyring/debian-archive-keyring_2025.1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "292a328394db239d2cb6a476a7823e01"
SRC_URI[deb0.sha1sum] = "d9ece07d6610a9ef3b3048c302d70daffbf8c4cc"
SRC_URI[deb0.sha256sum] = "9ea7778e443144ca490668737a8ab22dd3e748bb99e805e22ec055abeb3c7fac"
SRC_URI[deb0.sha512sum] = "d99dafbe92c40468012d0a95fa4e4dedbdb96e6e96bcc8b8f0fb082eadcbad42f625303ba128257dc7f660d6ba536f5bb27f7d72ded33121bf4679ae60070397"


