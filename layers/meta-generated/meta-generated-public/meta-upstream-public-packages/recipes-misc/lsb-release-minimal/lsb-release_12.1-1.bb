# This was autogenerated! Do not modify
SUMMARY = "Linux Standard Base version reporting utility (minimal implementation)"
DESCRIPTION = ""
SECTION = "misc"
SOURCE_PACKAGE = "lsb-release-minimal"
HOMEPAGE = "https://gioele.io/lsb-release-minimal"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/l/lsb-release-minimal/lsb-release_12.1-1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "fac5d689ff18136160eafe69cae2b6f1"
SRC_URI[deb0.sha1sum] = "1ffa54dcc573b2337020d905ddd4fe29185d1595"
SRC_URI[deb0.sha256sum] = "f81c836ce58d50c37039567ee85bbd76c0b6048c0b8f207e55529433694338ae"
SRC_URI[deb0.sha512sum] = "93869e3c5eb47e52eee1901ef051ec70dc70cc6ebe3b09c0d843597a7712228448653986dda859df41807e3a0217cea5a610e58a5e0e3e43c5eefe0643f889a8"


