# This was autogenerated! Do not modify
SUMMARY = "Common CA certificates"
DESCRIPTION = ""
SECTION = "misc"
SOURCE_PACKAGE = "ca-certificates"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/c/ca-certificates/ca-certificates_20250419_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "ea04777e0779a9e36b0a13bac0e61b4b"
SRC_URI[deb0.sha1sum] = "3003d7ee20f8100b1c4064f06db3347479a45468"
SRC_URI[deb0.sha256sum] = "ef590f89563aa4b46c8260d49d1cea0fc1b181d19e8df3782694706adf05c184"
SRC_URI[deb0.sha512sum] = "3d25ccca2d2d40adf8d101684253d86961e4aa63f237c864d973b62360b9bffcdac5610f2b8c837defebfe63ba363d694a9d694f25cba56516c79df9c6e18d29"

RDEPENDS = " \
    debconf \
    openssl \
"

