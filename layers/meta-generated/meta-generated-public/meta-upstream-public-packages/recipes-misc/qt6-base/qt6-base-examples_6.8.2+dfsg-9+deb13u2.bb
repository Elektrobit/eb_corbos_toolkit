# This was autogenerated! Do not modify
SUMMARY = "Qt 6 base examples"
DESCRIPTION = ""
SECTION = "misc"
SOURCE_PACKAGE = "qt6-base"
HOMEPAGE = "https://www.qt.io/developers/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/q/qt6-base/qt6-base-examples_6.8.2+dfsg-9+deb13u2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/q/qt6-base/qt6-base-examples_6.8.2+dfsg-9+deb13u2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "f73f57cf3503aaf97dfb74059bd042f5"
SRC_URI[deb0.sha1sum] = "3da04646733d1e593a21d54694c31e99a9fca8ea"
SRC_URI[deb0.sha256sum] = "a8672621018d247beb128bf20b5a00f2e48c0bea05bec633f17183e2dedec2a2"
SRC_URI[deb0.sha512sum] = "a554608b80439751ff861aec94de8151467978a74268cd676a1aaeee550042b04eb127a0583e7546aaaeb2d4cd072e2e097c0e033fab8ba9a9dd0f846950297b"
SRC_URI[deb1.md5sum] = "3b14c00ca746b12ca5e41be88d712606"
SRC_URI[deb1.sha1sum] = "aa69a7c7f58ddc11fe78d956edfbb932e3aea386"
SRC_URI[deb1.sha256sum] = "87e3ac57765e09c75b32d6ea0c5b967da7da32112469dd0a2944709500857c87"
SRC_URI[deb1.sha512sum] = "3206000c2469239bca3c1d64e52b1c5bc9cf55b589926f150ecf64f88b20775bf1da313b9ccfac1f76b7da9703cda301cdedf8857b1816f0790bfb7d593b3ce3"

RDEPENDS = " \
    libc6 \
    libgcc-s1 \
    libqt6concurrent6 \
    libqt6core6t64 \
    libqt6dbus6 \
    libqt6gui6 \
    libqt6network6 \
    libqt6opengl6 \
    libqt6openglwidgets6 \
    libqt6printsupport6 \
    libqt6sql6 \
    libqt6test6 \
    libqt6widgets6 \
    libqt6xml6 \
    libstdc++6 \
    qt6-base-private-abi \
"

