# This was autogenerated! Do not modify
SUMMARY = "basic terminal type definitions"
DESCRIPTION = ""
SECTION = "misc"
SOURCE_PACKAGE = "ncurses"
HOMEPAGE = "https://invisible-island.net/ncurses/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/n/ncurses/ncurses-base_6.5+20250216-2_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "ee4d5cfcc6a5958ba8f87e907fcffa7e"
SRC_URI[deb0.sha1sum] = "c5ed25322e0e478f39823c821a1ec408486e6079"
SRC_URI[deb0.sha256sum] = "190e775260a38973c415a36ae99f33ad1b37ea6ca99929d7c5d53843fc23e914"
SRC_URI[deb0.sha512sum] = "4852cf736b47b5063a1ca1237a4de0a4538bd52e4e99e1d45f78ccb3d224ca31c27c4e0c1c4b23437757f1da250f4af574a22fbae9173e26a859d47bdca23fa4"


RPROVIDES = " \
    ncurses-runtime \
"
