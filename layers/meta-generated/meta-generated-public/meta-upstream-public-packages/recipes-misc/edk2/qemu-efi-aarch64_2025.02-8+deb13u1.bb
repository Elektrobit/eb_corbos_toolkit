# This was autogenerated! Do not modify
SUMMARY = "UEFI firmware for 64-bit ARM virtual machines"
DESCRIPTION = ""
SECTION = "misc"
SOURCE_PACKAGE = "edk2"
HOMEPAGE = "http://www.tianocore.org"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/e/edk2/qemu-efi-aarch64_2025.02-8+deb13u1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "1611f831a6c0deafaecc45526e638a16"
SRC_URI[deb0.sha1sum] = "6a7e1464c910a497263c8ec086d1f8be1d1628bd"
SRC_URI[deb0.sha256sum] = "a00b2411a79c8aeafd95a7c868ac3cd1aab592f1af9fff965f02d81a625276ed"
SRC_URI[deb0.sha512sum] = "a02353d6ffc22c8e2293a6cc4b7a3f3d7144c2f8f7fad694906b73e7e5f1c64439822c10643eaa8ed6cce8162366dc6566802e1d46324d5c5560e4206d8c8496"


