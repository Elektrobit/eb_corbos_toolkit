# This was autogenerated! Do not modify
SUMMARY = "transitional package for Linux Standard Base init script functionality"
DESCRIPTION = ""
SECTION = "misc"
SOURCE_PACKAGE = "lsb"
HOMEPAGE = "https://wiki.linuxfoundation.org/lsb/start"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/l/lsb/lsb-base_11.6_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "e11ef978bfbcf7e07758cc35adf4d4a0"
SRC_URI[deb0.sha1sum] = "a35020cdf6d77bfe6ba53bca12f6f78ddb3ddf5b"
SRC_URI[deb0.sha256sum] = "f8bedd167280e76636df3a1bc023cd2906d458916c1af4c1d7912c5b971fc642"
SRC_URI[deb0.sha512sum] = "2bfdccbf2e689b22b5bf9d61ed3e316700c65a28bc543efcc34b5458f3bb4f3183b1eb7241e1719b18fc756e2f71e5564c4c4d4af269eb8af50c2c48f6fa81e3"

RDEPENDS = " \
    sysvinit-utils \
"

