# This was autogenerated! Do not modify
SUMMARY = "Library to access U-Boot environment - tool"
DESCRIPTION = ""
SECTION = "utils"
SOURCE_PACKAGE = "libubootenv"
HOMEPAGE = "https://github.com/sbabic/libubootenv"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libu/libubootenv/libubootenv-tool_0.3.5-0.1+b2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libu/libubootenv/libubootenv-tool_0.3.5-0.1+b2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "8be5a8b8e52fa1800c71cf4aec805b5d"
SRC_URI[deb0.sha1sum] = "2be27daeeec282b20d175353ca4d259d6eec8cd8"
SRC_URI[deb0.sha256sum] = "cced582480fc7ee77c324dde40d5eb5a70f41e6e125c9e58bd386d22cdd0a56b"
SRC_URI[deb0.sha512sum] = "5620d573bcc6a807228017a33849e4e951544beb3fe3dfa5877a3a0974f3aa17fcce77d0c8659a99f500f404a49c867d5e95acebfbdeb8c577b5582b05a14390"
SRC_URI[deb1.md5sum] = "95652bdc6ec6a7dfeab8435e5f6ff4a6"
SRC_URI[deb1.sha1sum] = "d5f3d9fd3db085f91f69ec81ed44168a13504dc9"
SRC_URI[deb1.sha256sum] = "8a01328023abedaa45f8ed30be05c0ae351f413589e7ecc57695ba89d6cfada8"
SRC_URI[deb1.sha512sum] = "96b4b86f6782b019d7b01b53b05432e69f8a6448bb6f93d156a92d6b5eb1851434d60aba17e5faeaebe8fe284e2b18b965a57b3c788ff75465859d6c76174ae7"

RDEPENDS = " \
    libc6 \
    libubootenv0.1 \
"

