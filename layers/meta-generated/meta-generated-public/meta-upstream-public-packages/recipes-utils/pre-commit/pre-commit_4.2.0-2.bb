# This was autogenerated! Do not modify
SUMMARY = "Git pre-commit hook framework"
DESCRIPTION = ""
SECTION = "utils"
SOURCE_PACKAGE = "pre-commit"
HOMEPAGE = "https://pre-commit.com"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/pre-commit/pre-commit_4.2.0-2_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "bf636b905de7f62fc54f077d4ab3a84b"
SRC_URI[deb0.sha1sum] = "cc38bb14bc4b407b136cd09dbb8e2a02f4128d5f"
SRC_URI[deb0.sha256sum] = "3dc5aff8ea3c70da49cb35dfd2c9cdfe14a3c04ca53963d50e7444a5d0e649bf"
SRC_URI[deb0.sha512sum] = "df6f7ed1f358958ced46df4c3cd9922b821dcd9934051be50ba0396d04dfee8ed049a1c987982e6235194cf801b5bb8d013062c9d22060dfa92d318b8dc2a4a9"

RDEPENDS = " \
    nodeenv \
    python3 \
    python3-cfgv \
    python3-identify \
    python3-virtualenv \
    python3-yaml \
"

