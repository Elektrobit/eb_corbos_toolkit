# This was autogenerated! Do not modify
SUMMARY = "SELinux core policy utilities (Python utilities)"
DESCRIPTION = ""
SECTION = "utils"
SOURCE_PACKAGE = "selinux-python"
HOMEPAGE = "https://selinuxproject.org"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/selinux-python/policycoreutils-python-utils_3.8.1-2_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "292b5659def3cc2055b2a8a018da32b5"
SRC_URI[deb0.sha1sum] = "b0ea8363df697bda316ab1260641729b3d4cf9f2"
SRC_URI[deb0.sha256sum] = "c1ffb05cbb817f4f6424ad4f79a0a82f7ff8e726299e0cc86a0a1ee99647aec1"
SRC_URI[deb0.sha512sum] = "01abb14424312b92689f7eacbf98fce16eceb018650eed2940af4702c7defbb56ed6dab92482066c32440ca63d12fb1494894a96c8a2dc8ff2df7c2d6b6fda68"

RDEPENDS = " \
    policycoreutils \
    python3 \
    python3-audit \
    python3-selinux \
    python3-semanage \
    python3-sepolgen \
    python3-sepolicy \
    python3-setools \
    selinux-utils \
"

