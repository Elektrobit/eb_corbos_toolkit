# This was autogenerated! Do not modify
SUMMARY = "Node.js virtual environment builder"
DESCRIPTION = ""
SECTION = "utils"
SOURCE_PACKAGE = "nodeenv"
HOMEPAGE = "https://ekalinin.github.io/nodeenv/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/n/nodeenv/nodeenv_1.9.1-3_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "1c0598872684c854714b9db0a3167c9a"
SRC_URI[deb0.sha1sum] = "5b209355e932c6f60c0d5e040d4cc4dd8ff68616"
SRC_URI[deb0.sha256sum] = "161b1503da95c24eb3221038fd4c09abe3c94ce41e3ffc59a8cbc8c85473bdb3"
SRC_URI[deb0.sha512sum] = "8ece6fc47804ada790e7e0860ddb1d1483b1f6b7c91cac9d6957a6edbc9fb99c461518a995906676a7b91330ba0235d8e002add91ea39aef6242d594bd80273f"

RDEPENDS = " \
    g++ \
    gcc \
    libssl-dev \
    make \
    python3 \
"

