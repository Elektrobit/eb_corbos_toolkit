# This was autogenerated! Do not modify
SUMMARY = "lightweight and flexible command-line JSON processor"
DESCRIPTION = ""
SECTION = "utils"
SOURCE_PACKAGE = "jq"
HOMEPAGE = "https://jqlang.github.io/jq"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/j/jq/jq_1.7.1-6+deb13u3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/j/jq/jq_1.7.1-6+deb13u3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "171d30d8b0ab8d9d4a4abc9842708238"
SRC_URI[deb0.sha1sum] = "319826865114024846a4efa2ba8599934110f5ae"
SRC_URI[deb0.sha256sum] = "4415dc18d4ea29d8e12d410dd8c71c567d44d8ec5e24afaed3aa7a149b063643"
SRC_URI[deb0.sha512sum] = "e2f6c9c09f5a8d90ee864cc1644bd72d782e865b395b27d20f21170dd6d06a321e6a8f9be33c896ffa3578bf77929db83c78caece610ef9363ed98a8c31e3a3f"
SRC_URI[deb1.md5sum] = "5c0fae4a28863081b2a3e5c157db2238"
SRC_URI[deb1.sha1sum] = "d352ec4c6ad49118a89af1f480fb1112c6df9589"
SRC_URI[deb1.sha256sum] = "d35bc9f804784d39e7b89e63314a80f113d8a7ccbeb36cf0d3cc01c3a65312e2"
SRC_URI[deb1.sha512sum] = "039ef4e9676a76e480e5f574da4cbf32c66e5f5a097513dbf89c081e5796cd82d7fc302968bb56975c210b1391f5ac2d1d5725dada78fd9ff619e9e59d5c8f07"

RDEPENDS = " \
    libc6 \
    libjq1 \
"

