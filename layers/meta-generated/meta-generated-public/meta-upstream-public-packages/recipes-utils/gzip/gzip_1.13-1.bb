# This was autogenerated! Do not modify
SUMMARY = "GNU compression utilities"
DESCRIPTION = ""
SECTION = "utils"
SOURCE_PACKAGE = "gzip"
HOMEPAGE = "https://www.gnu.org/software/gzip/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gzip/gzip_1.13-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gzip/gzip_1.13-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "4dc3f9227aec0a08165d6ea4ee37184d"
SRC_URI[deb0.sha1sum] = "17e2275e726dad554ab38aa3f3d240f5270923cb"
SRC_URI[deb0.sha256sum] = "c98b1130f08ef6ac3932972c56be84cfc308ce1afa37105cb06aaf47ced2d078"
SRC_URI[deb0.sha512sum] = "35cf2aedfe212fd2e3b42a6f6f899929c65c1ab13bf33dea222103b6300eeeaac4bc0459daefb8d217c3f3cded6683ef1cc3c5b19b98deb66e3421e3eab32b18"
SRC_URI[deb1.md5sum] = "234d86bb175c262044cc6d9c23952459"
SRC_URI[deb1.sha1sum] = "12136dd88ce463df2f49cdfa4a33666076228318"
SRC_URI[deb1.sha256sum] = "cd46c9482fd3b96d4ecf282b01185ef9341b0ffcd40816372141f73037ce2c36"
SRC_URI[deb1.sha512sum] = "af930a9b759d3652813d6914112c56f27ca25b2cf22acfcabd56f462fd08bdd1077cb496cfa2320f3648e08e92c9dd1293bd6fc722c644953b6b735fa331d708"

RDEPENDS = " \
    libc6 \
"

