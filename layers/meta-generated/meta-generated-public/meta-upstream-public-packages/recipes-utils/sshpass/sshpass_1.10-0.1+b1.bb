# This was autogenerated! Do not modify
SUMMARY = "Non-interactive ssh password authentication"
DESCRIPTION = ""
SECTION = "utils"
SOURCE_PACKAGE = "sshpass"
HOMEPAGE = "https://sourceforge.net/projects/sshpass"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/sshpass/sshpass_1.10-0.1+b1_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "69faf0fe4acf475a29afa6b806c7cf7e"
SRC_URI[deb0.sha1sum] = "3a243a822e3bc12b5b8fbac19442494bee55a2ca"
SRC_URI[deb0.sha256sum] = "b9e7e2e9ef68f33ddcd3e1c6882e15de3309c2512263c5f3ad8ba2bcfd00ec59"
SRC_URI[deb0.sha512sum] = "07ed10884f51616801c35a84bd9867e5e805e5d5ebc3c43749a673424a2a1c7c33f77a51c61b789e8c90df729eeb2c122bb0509f6e293757e5a776e45f16388e"

RDEPENDS = " \
    libc6 \
"

