# This was autogenerated! Do not modify
SUMMARY = "lm-sensors configuration files"
DESCRIPTION = ""
SECTION = "utils"
SOURCE_PACKAGE = "lm-sensors"
HOMEPAGE = "https://github.com/hramrach/lm-sensors"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/l/lm-sensors/libsensors-config_3.6.2-2_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "9d468823435bd29c9fe580b1db754ae3"
SRC_URI[deb0.sha1sum] = "3c77a8d6a326d3d2c8324f3f31a4a0db9f2a01c8"
SRC_URI[deb0.sha256sum] = "3056da80c7d963af795dab480ab6f6f4b154ad4ac39f522dc52d17c834fea253"
SRC_URI[deb0.sha512sum] = "d66f52e0afdecb373ce4a6da9c884fb9072e7b6ef40f3d065bddf5284d3031fc8ebf4d926d24da0e088315b9a711498022414054c341068167fd95dcd66c1963"


