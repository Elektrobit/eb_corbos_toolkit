# This was autogenerated! Do not modify
SUMMARY = "tool for simulating superuser privileges"
DESCRIPTION = ""
SECTION = "utils"
SOURCE_PACKAGE = "fakeroot"
HOMEPAGE = ""

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/f/fakeroot/fakeroot_1.37.1.1-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/f/fakeroot/fakeroot_1.37.1.1-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "a8f2ef0069773028e87cf6edceb92972"
SRC_URI[deb0.sha1sum] = "6c7064933bf6f07d244dd194da4491a6829ae6dc"
SRC_URI[deb0.sha256sum] = "df17a351eaac7168ac56c197abf0d015ae34fc9dbba0c1d507a76409034311de"
SRC_URI[deb0.sha512sum] = "60b7f3ca648181c781d5f7c42955e89aa6486cd9bdab803f3bdb1703e53b839dbfa0a00eb95c597a8d114a3c70e74199208152dd81407135dd922eace0b9354d"
SRC_URI[deb1.md5sum] = "d0d075661d76708b8223968fadb37dd6"
SRC_URI[deb1.sha1sum] = "ff4628b75c4a8f8f1fb4a0c7bbc260be68321e69"
SRC_URI[deb1.sha256sum] = "12033a4b5d561769b89cea9346b94e516e03863b3d7180c24f0dd178d50606df"
SRC_URI[deb1.sha512sum] = "77f90d7576e44b7b70a8ecaac4f2161c8b88736e30a92264a2e600b6ad2a33eb31ff071d2533680f49a8ca96820e2339f7a4beffce7c5218a9b16fa59487624a"

RDEPENDS = " \
    libc6 \
    libfakeroot \
"

