# This was autogenerated! Do not modify
SUMMARY = "Recursively searches directories for a regex pattern"
DESCRIPTION = ""
SECTION = "utils"
SOURCE_PACKAGE = "rust-ripgrep"
HOMEPAGE = "https://github.com/BurntSushi/ripgrep"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/r/rust-ripgrep/ripgrep_14.1.1-1+b4_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/r/rust-ripgrep/ripgrep_14.1.1-1+b4_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "34ad26dc7eea2c61e30f428db74577c8"
SRC_URI[deb0.sha1sum] = "e50e70fd7e8db869582c250fdb9bfa7cc46fbe5c"
SRC_URI[deb0.sha256sum] = "7e0c32510c264c31335fe3b9ae37ab76dcd22f7d1627a0a08518a5bf28b17ac2"
SRC_URI[deb0.sha512sum] = "e3b2db3188814da0dba9c4bc4f44c54ba84b38ae6299378f16fe80bbc92016e92f67510cd86d05989ac99e41e9e40856a199e1d75d0651a5e34ad376dab24b9d"
SRC_URI[deb1.md5sum] = "3d4ef8d08464e3f8fe9f9ce9ba269134"
SRC_URI[deb1.sha1sum] = "4eaf2cc62648fba9568d2a6ba83aad1fb903dfda"
SRC_URI[deb1.sha256sum] = "9b4f347ba2320b22cba217cc4b078536596cc6a1409df001fc560ad3fa396609"
SRC_URI[deb1.sha512sum] = "a13ab50729d22e412a140043604a8144e29f1b60ec921bd6b932bf8292d2a65fa327588e3c25b553ab6bc1a0eb627acbefec6b98ae3254e842e2a5d30a4ca9e0"

RDEPENDS = " \
    libc6 \
    libgcc-s1 \
    libpcre2-8-0 \
"

