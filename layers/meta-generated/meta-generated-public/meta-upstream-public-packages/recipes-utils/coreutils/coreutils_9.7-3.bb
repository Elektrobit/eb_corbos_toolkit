# This was autogenerated! Do not modify
SUMMARY = "GNU core utilities"
DESCRIPTION = ""
SECTION = "utils"
SOURCE_PACKAGE = "coreutils"
HOMEPAGE = "https://gnu.org/software/coreutils"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/c/coreutils/coreutils_9.7-3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/c/coreutils/coreutils_9.7-3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "4a48f61cc5b86a87f14b3d2045c9870f"
SRC_URI[deb0.sha1sum] = "b030cfa538f5265585eb5d8a08af1cc65d855dab"
SRC_URI[deb0.sha256sum] = "1299ab6f9389a288eb2f5f3dd222c26cc777b9a2d5ecb6ee4cbd340cebcdada2"
SRC_URI[deb0.sha512sum] = "cfb50cf3c2040fbb204a4c53434ace3d3dac15396074d867c172f9813ef8999b71c4e3bf31235558e41c4802be0dc8e4e486adc4368d46b38d791aa9884d9c8f"
SRC_URI[deb1.md5sum] = "88659d3c1264b01686c9c4391df6b073"
SRC_URI[deb1.sha1sum] = "907c52e0edf6a3c94f256c547e0bbb78fb97caa5"
SRC_URI[deb1.sha256sum] = "99b2531e8d16e4f2d3f239ae3cb57913ec1f43764d2d6cd5c69154cbb1e57f3e"
SRC_URI[deb1.sha512sum] = "17626c7ac1b9ca3cfa0fea4e1ee96c6704da7dcc5af1e9b3e26953da29b517dad433b8fe56fa6b2885226d5f14b9b715e0f7aff9cc0165df229965649e8ffcf8"

RDEPENDS = " \
    libacl1 \
    libattr1 \
    libc6 \
    libcap2 \
    libgmp10 \
    libselinux1 \
    libssl3t64 \
    libsystemd0 \
"

