# This was autogenerated! Do not modify
SUMMARY = "OpenPGP signature verification program from Sequoia"
DESCRIPTION = ""
SECTION = "utils"
SOURCE_PACKAGE = "rust-sequoia-sqv"
HOMEPAGE = "https://sequoia-pgp.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/r/rust-sequoia-sqv/sqv_1.3.0-3+b2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/r/rust-sequoia-sqv/sqv_1.3.0-3+b2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "bf6effd54bb6a82a20b73c4da2f51729"
SRC_URI[deb0.sha1sum] = "02ff6f8f2f49adced927e50c4f225bbc01017808"
SRC_URI[deb0.sha256sum] = "97760aa17acceee0cace13d9edbed781d891b43e0dec0d6ddc4bd5e4c3ac65aa"
SRC_URI[deb0.sha512sum] = "64012bce51cce6945c19254a528dbbeef40562da53a3104bb956b471945f8d5e999a0fbafa5db36160540c90494669bcea5ea197bfdb5f6ba0ad36f4dae31780"
SRC_URI[deb1.md5sum] = "69851acef157c0797af3f82f68b0a639"
SRC_URI[deb1.sha1sum] = "af0d690b758f57996836aceb52d8541959238956"
SRC_URI[deb1.sha256sum] = "feb611506f420594bf767b1a8748429802ff4f324536ab1154bcc61478b9a8b6"
SRC_URI[deb1.sha512sum] = "4c6cfbc67d98fc014bdd4a89e8b6fe953344fecda0cadf46791249fc23b6dca5803d2bc580c355c4de412bec2f48c6dfa59a41df5ea47f2a727b594e5c56a3ce"

RDEPENDS = " \
    libc6 \
    libgcc-s1 \
    libgmp10 \
    libhogweed6t64 \
    libnettle8t64 \
"

