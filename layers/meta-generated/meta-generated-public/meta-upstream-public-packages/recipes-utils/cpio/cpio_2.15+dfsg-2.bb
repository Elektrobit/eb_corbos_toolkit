# This was autogenerated! Do not modify
SUMMARY = "GNU cpio -- a program to manage archives of files"
DESCRIPTION = ""
SECTION = "utils"
SOURCE_PACKAGE = "cpio"
HOMEPAGE = "https://www.gnu.org/software/cpio/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/c/cpio/cpio_2.15+dfsg-2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/c/cpio/cpio_2.15+dfsg-2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "e44d988295c7d37423f4e3ee918d8bc1"
SRC_URI[deb0.sha1sum] = "6f38a0e7017b459d069465780d77623c13672355"
SRC_URI[deb0.sha256sum] = "d8faece250bcf72e91ac15a5fef198be173af18c9f48bae257e7ee937fbc6cdc"
SRC_URI[deb0.sha512sum] = "2d9a65e58cff45b8338595d451e185eaf24e44422feb31210d0ea4348e98501851f8508360200a60a59bd1d1c32f59a743ecb834c3325d7f484df31709a2dc2b"
SRC_URI[deb1.md5sum] = "4a8d31717b01aa20d57329136af07e9a"
SRC_URI[deb1.sha1sum] = "2dd9908cef64b1a4c2ada93ae2d10bbebac11044"
SRC_URI[deb1.sha256sum] = "cbb9ecfc347a854e78d56b7ebeb1b58cdc4316de816132588c457a76ee823d96"
SRC_URI[deb1.sha512sum] = "1e8170f6d6fc7c42893fec72f23def05488dab7f5edce02b41f37800429031d3941451b2319405d7b5d5161f370e5c81356d374065c0bacba64359335caed1dd"

RDEPENDS = " \
    libc6 \
"

