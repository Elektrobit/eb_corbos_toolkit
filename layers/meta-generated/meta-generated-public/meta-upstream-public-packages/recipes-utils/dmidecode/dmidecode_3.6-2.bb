# This was autogenerated! Do not modify
SUMMARY = "SMBIOS/DMI table decoder"
DESCRIPTION = ""
SECTION = "utils"
SOURCE_PACKAGE = "dmidecode"
HOMEPAGE = "https://nongnu.org/dmidecode/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/d/dmidecode/dmidecode_3.6-2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/d/dmidecode/dmidecode_3.6-2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "cbce14b716f39829c87174b22fe30e5d"
SRC_URI[deb0.sha1sum] = "7e929cc9906ba39ab355dd666759b6a04e24fbbb"
SRC_URI[deb0.sha256sum] = "6ad5a5483752ea05e425e77adc9ccf58ce9da22cca28d8932ea316d641f199d3"
SRC_URI[deb0.sha512sum] = "3722668349f2322142b286fbcc1efc8fb4a252e95d1bdc27c2e157d1189d7147d4fa3f1c54cdba79bf0a760f06783d63ce3167cecd85c284c0f8b52e068e92ba"
SRC_URI[deb1.md5sum] = "578650be8bca78bbf91733889a5d1e18"
SRC_URI[deb1.sha1sum] = "a4a98f2f793945cede6594a4cf03b643ebbcc9ed"
SRC_URI[deb1.sha256sum] = "19deda968a88bff26d574b512c6d3619472695373e492212a65ab3f51823234a"
SRC_URI[deb1.sha512sum] = "9b43be0da54a8190d59056095960c17725b4c78f0f58b5128b2e1aa638181e8ce68bfa9e7346fd1789ff690c8f39120a5e39ee5794a46a2dd2da6b22b93758cf"

RDEPENDS = " \
    libc6 \
"

