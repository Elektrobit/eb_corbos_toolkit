# This was autogenerated! Do not modify
SUMMARY = "curses-based PIN or pass-phrase entry dialog for GnuPG"
DESCRIPTION = ""
SECTION = "utils"
SOURCE_PACKAGE = "pinentry"
HOMEPAGE = "https://www.gnupg.org/related_software/pinentry/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/pinentry/pinentry-curses_1.3.1-2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/pinentry/pinentry-curses_1.3.1-2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "ee9c1be603c92f77ac0f735154d013de"
SRC_URI[deb0.sha1sum] = "0c6a5743bb350b5d9f49167a3b0c44b8da0a1d63"
SRC_URI[deb0.sha256sum] = "aed82cd9cc92b8a37f1332f951737f549595a3126aa609e632f9205d95405efc"
SRC_URI[deb0.sha512sum] = "fc9bc7e4672fc011927563332ed8a80970d7b1c3f8d8e80c5a75aaac275b7ff69b4d83db02f0c4fc95a44506db0eaf8a5df92df657333f7f2c7a31dcaa1149c8"
SRC_URI[deb1.md5sum] = "4c5601657c59ca5efe4a9764d2cf29a8"
SRC_URI[deb1.sha1sum] = "f76325be14738636bf263e42e5f0689cd62fe1c4"
SRC_URI[deb1.sha256sum] = "038633a7ae80fb2cefc1d13eedfea7797254a08eaee7e9acdc481818011c0b0c"
SRC_URI[deb1.sha512sum] = "2fcf381f47675a76611c15fe1c4bb6ba59edf53a484076622913d8358cd0b22f5cda20e169337ae33b6106298994e21cda49de9f4b66e071dfa7b23bfd60d045"

RDEPENDS = " \
    libassuan9 \
    libc6 \
    libgpg-error0 \
    libncursesw6 \
    libtinfo6 \
"

RPROVIDES = " \
    pinentry \
"
