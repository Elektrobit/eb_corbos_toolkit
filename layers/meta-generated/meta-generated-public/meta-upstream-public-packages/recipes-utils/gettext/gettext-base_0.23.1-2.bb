# This was autogenerated! Do not modify
SUMMARY = "GNU Internationalization utilities for the base system"
DESCRIPTION = ""
SECTION = "utils"
SOURCE_PACKAGE = "gettext"
HOMEPAGE = "https://www.gnu.org/software/gettext/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gettext/gettext-base_0.23.1-2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gettext/gettext-base_0.23.1-2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "b73ddd8d04c5ddac8cf09e6eb47aed11"
SRC_URI[deb0.sha1sum] = "ed5d2f1fa5b7952d917ccc401f5785ff4744e544"
SRC_URI[deb0.sha256sum] = "1a3dfadd661520ff01d379fd89cd0d49972a5a775d490609f1712134ee3d62ca"
SRC_URI[deb0.sha512sum] = "fa245a3a7c4369baef0117f08b23199e0b8b129a99da69c622469ae5e5ed3fe03dd5fe448b857cb44e90a3ab43d0d8ed9783c8f4df3634898be8d628ba50131c"
SRC_URI[deb1.md5sum] = "8394dcc002b0f588ceae8105cbd4747d"
SRC_URI[deb1.sha1sum] = "ec7e275e5a2c39c19d651f32e8fc996f6312e44b"
SRC_URI[deb1.sha256sum] = "b2cacbf178915d739c5134dfffeb0cfc0edcf4247a61329ab7a872628a91d80a"
SRC_URI[deb1.sha512sum] = "7e35b7f9990234a94eea4f412f8403a72ead5fd80a3f87f3f5d4bf88ba683f40957448b8f470c94027af890870cb51764d156b1314268717b1544f8d0b897739"

RDEPENDS = " \
    libc6 \
"

