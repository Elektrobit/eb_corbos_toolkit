# This was autogenerated! Do not modify
SUMMARY = "utilities for finding files--find, xargs"
DESCRIPTION = ""
SECTION = "utils"
SOURCE_PACKAGE = "findutils"
HOMEPAGE = "https://savannah.gnu.org/projects/findutils/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/f/findutils/findutils_4.10.0-3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/f/findutils/findutils_4.10.0-3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "45a7c08bd8d663f88282d7085c54ed95"
SRC_URI[deb0.sha1sum] = "61921be671ffab5ab351306b9cde74a0987cd62a"
SRC_URI[deb0.sha256sum] = "3edf02b016456b6a98cefdbab99c5ce6f829b786f63affe970badea221aecfc7"
SRC_URI[deb0.sha512sum] = "5252bc6d501ec410026135201eaac9101b9767b777628fe31772e546939d5ad0331f9e61ddfe54716dbfaf385ff54b556299cf474b6b68438c69882d5fda9aa9"
SRC_URI[deb1.md5sum] = "b91a1c172f5ab09636414ca523627490"
SRC_URI[deb1.sha1sum] = "f01d162a671756a944f61672439dee89cd2983b4"
SRC_URI[deb1.sha256sum] = "c8b505ce907c293031095b3a237cb231967963b1d5aa8b1699aff45ccec3158a"
SRC_URI[deb1.sha512sum] = "cabb8f0caa2cee1c53bd1f4876db11aee6c4de802ca797d5199272766aa4c3511fd83665a0f2c45248fe9a83aafd0da68565b27d40d74f1c540c78ae027acbfa"

RDEPENDS = " \
    libc6 \
    libselinux1 \
"

