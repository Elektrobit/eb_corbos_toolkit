# This was autogenerated! Do not modify
SUMMARY = "Recognize the type of data in a file using "magic" numbers"
DESCRIPTION = ""
SECTION = "utils"
SOURCE_PACKAGE = "file"
HOMEPAGE = "https://www.darwinsys.com/file/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/f/file/file_5.46-5_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/f/file/file_5.46-5_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "a5120ebc10175a31d5c4894d8be4f621"
SRC_URI[deb0.sha1sum] = "5e56edf7ab85950c576bb13a178311dde08a888b"
SRC_URI[deb0.sha256sum] = "5b980b02a7d91aab9cb50c65ac7e059678a36d36ed626ec52506442f4501a1a7"
SRC_URI[deb0.sha512sum] = "939b73254743b70e304be4276aa6716ecdae525a296ba6ef681b0c2e723190aa140b4ebd264e5aa6226c6ae3dfadf4d39ed2c0a844c33baa1a9fe881cccd19e0"
SRC_URI[deb1.md5sum] = "8873b39e2d119302970411560646857a"
SRC_URI[deb1.sha1sum] = "626fd3ff17c0bfda0d673ac7056b393d4db32dc3"
SRC_URI[deb1.sha256sum] = "6160ce90e6246a12eb644685dde480d6d7383bb733fa3b3e16b171348d05ba26"
SRC_URI[deb1.sha512sum] = "a7fe3b70fa3c19cfd5a412fd170c76dd88dd42478aaacff652d74fe15d60fb2716755fd80db1fbf9253a111005f3ca4490e53a5a10ae93a390578323a78ccd16"

RDEPENDS = " \
    libc6 \
    libmagic1t64 \
"

