# This was autogenerated! Do not modify
SUMMARY = "dracut is an event driven initramfs infrastructure (dracut-install)"
DESCRIPTION = ""
SECTION = "utils"
SOURCE_PACKAGE = "dracut"
HOMEPAGE = "https://github.com/dracut-ng/dracut-ng/wiki"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/d/dracut/dracut-install_106-6_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/d/dracut/dracut-install_106-6_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "e7acec2e6ea1c542405f5ac31832e6d7"
SRC_URI[deb0.sha1sum] = "c33f0bafe347628e8ba07c526666c3fc37738d39"
SRC_URI[deb0.sha256sum] = "5ef87c15510db933d4ec7617b88012b436b0ebfc248e4c7d3b6baf9aa5acbc76"
SRC_URI[deb0.sha512sum] = "98a804a5187798de0707abfa47acfa60b9a355803643778462300c91907d3fb29244204f105532fa20f6bd9373914bea87dc48deca513d538bfae23edd241c67"
SRC_URI[deb1.md5sum] = "80ac05fe57683eae74259930a0f7b24c"
SRC_URI[deb1.sha1sum] = "f592e2ebd390f30d69de1f041d92b7392ba95da2"
SRC_URI[deb1.sha256sum] = "318f89cb1f08d843fea4f7aa290af6f1f6c9ecc9e88e2b2b29488cfa366bd1d3"
SRC_URI[deb1.sha512sum] = "ebc2e4361173a135b2b0bbd501924ac69c8ec12d3af55edf20f751201ed042f49a325d772f4b5f6f65f1a4f1feccc897841714d6e7848884df1dfb8710f8008d"

RDEPENDS = " \
    libc6 \
    libkmod2 \
"

