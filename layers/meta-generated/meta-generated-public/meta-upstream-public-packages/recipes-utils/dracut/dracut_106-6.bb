# This was autogenerated! Do not modify
SUMMARY = "Initramfs generator using udev"
DESCRIPTION = ""
SECTION = "utils"
SOURCE_PACKAGE = "dracut"
HOMEPAGE = "https://github.com/dracut-ng/dracut-ng/wiki"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/d/dracut/dracut_106-6_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "3f12edaf352445df7709eb3336bf4e28"
SRC_URI[deb0.sha1sum] = "db4014d196d2d38095bd504aa459028a220970fd"
SRC_URI[deb0.sha256sum] = "01d71791af2b8306296c48f22b3aef390df21c84eb1328ded174722f19e1d349"
SRC_URI[deb0.sha512sum] = "f1c2411229382c9a04e0c5275d1fd0c26f21232f7ef9f2eda43dd2ff4da0263496933bbf4bcc8c9192a666a6a82339f15d08b533f03928a23f8119c756db6027"

RDEPENDS = " \
    dracut-core \
    linux-base \
"

RPROVIDES = " \
    linux-initramfs-tool \
"
