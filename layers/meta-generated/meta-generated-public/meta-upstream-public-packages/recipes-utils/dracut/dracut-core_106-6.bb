# This was autogenerated! Do not modify
SUMMARY = "dracut is an event driven initramfs infrastructure (core tools)"
DESCRIPTION = ""
SECTION = "utils"
SOURCE_PACKAGE = "dracut"
HOMEPAGE = "https://github.com/dracut-ng/dracut-ng/wiki"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/d/dracut/dracut-core_106-6_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/d/dracut/dracut-core_106-6_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "29e995d9bbe36a1342ee90892eeba936"
SRC_URI[deb0.sha1sum] = "3ae170d88becd23036b40cdb794cac62eeba4803"
SRC_URI[deb0.sha256sum] = "3d42a242f2a1d6a8dcef15a66ddbb1263050695b2cff544b57a7a12d88338686"
SRC_URI[deb0.sha512sum] = "658b5843879fd71b20a243bde92dcf045e60da990d324e47b70851caffd7763bb4b561063ce0ca67ca7402e4e9aff353fd462530896ba7dec7c96aebec6627ed"
SRC_URI[deb1.md5sum] = "03f40988ab5e963d4ed7facb8706cb98"
SRC_URI[deb1.sha1sum] = "2e4608a8fb165d79554bdcd2bb748725bf426e61"
SRC_URI[deb1.sha256sum] = "262da4bd53df8b17658d93c2fa80622ffb4e7efd85a7b797ae09201578f3f760"
SRC_URI[deb1.sha512sum] = "ed926ffbcbfa30b021254a66c2f00138d40248641dca9ad525122ab9626c778af5cb9912558b0d6c717dcad205c8b9a696d624a615b88391c4d4832666a63d23"

RDEPENDS = " \
    cpio \
    dracut-install \
    e2fsprogs \
    kmod \
    libc6 \
    udev \
"

