# This was autogenerated! Do not modify
SUMMARY = "POSIX 1003.1e capabilities (utilities)"
DESCRIPTION = ""
SECTION = "utils"
SOURCE_PACKAGE = "libcap2"
HOMEPAGE = "https://sites.google.com/site/fullycapable/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libc/libcap2/libcap2-bin_2.75-10+deb13u1+b1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libc/libcap2/libcap2-bin_2.75-10+deb13u1+b1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "076ac3af3d08af732672f683aa10bbb8"
SRC_URI[deb0.sha1sum] = "361046d3091da9e3e805889087d2994a8a5eef24"
SRC_URI[deb0.sha256sum] = "4abf33b256068c1621c9e5bca99b47a506e11f34ebc20a220404f3c256a057ca"
SRC_URI[deb0.sha512sum] = "7be8e5100604cc297498741d26b6ca3c0a5cd0b103ec74e2966aa2de6402eadd114b3af3dd6b611071865c13172be7bea6c2f7c6f8403a67f56f28cf2f86d31d"
SRC_URI[deb1.md5sum] = "b3cea8818a7f371a40ac968ac22f3210"
SRC_URI[deb1.sha1sum] = "e4d7b8ef1860ab701fe228991bbe4d7936b414e6"
SRC_URI[deb1.sha256sum] = "0717912b3dc3bb1fd0011d662da9d95c1ec08ac23cea951d3c7cb3ed1437d6b0"
SRC_URI[deb1.sha512sum] = "f51d8c4366281fe559d70ec21e2b7ed3831ebf2fca5e25189738a27f261617bebabb00c44e860e47a758a1e1e0b6b43ee495bf5e75149ad450aa554980a735b5"

RDEPENDS = " \
    libc6 \
    libcap2 \
"

