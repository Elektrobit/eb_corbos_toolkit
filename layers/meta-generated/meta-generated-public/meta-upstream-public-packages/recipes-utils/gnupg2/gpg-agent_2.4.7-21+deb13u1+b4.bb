# This was autogenerated! Do not modify
SUMMARY = "GNU privacy guard - cryptographic agent"
DESCRIPTION = ""
SECTION = "utils"
SOURCE_PACKAGE = "gnupg2"
HOMEPAGE = "https://www.gnupg.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gnupg2/gpg-agent_2.4.7-21+deb13u1+b4_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gnupg2/gpg-agent_2.4.7-21+deb13u1+b4_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "54828e9585cd9f60e6f5c0bb5c693b4f"
SRC_URI[deb0.sha1sum] = "598d750ed366839d902d85ff6fbd89f34b9d335f"
SRC_URI[deb0.sha256sum] = "f67b953b03d7394d83e1e022bc548f4553d0cec20c83b90e9832666235f89631"
SRC_URI[deb0.sha512sum] = "efd8ffeb8eafd63fb003eaa1b124d3c6f822d151f009aa4d665f17cfe83bd00b2bc2aeca429355a286ad96f339610e30d7a1c19ace08dea40d13740d096971a6"
SRC_URI[deb1.md5sum] = "8c3b615fafa4e2d506619ed119da580a"
SRC_URI[deb1.sha1sum] = "74358e49ecdf84051d82da3add03c6f4d9f5f6e1"
SRC_URI[deb1.sha256sum] = "40d0556bc05a02cf60a7308f00e52e796a10341d9b404e67a8cf0f7bb00340d9"
SRC_URI[deb1.sha512sum] = "afab5785ffdd90d6a8519364d4f790dd65709d848c0478ff2734532ae3ef565eb237853a873742e481b7841e956a5c69dab84d6d7e33d263f249f5b4b4cce2c3"

RDEPENDS = " \
    gpgconf \
    init-system-helpers \
    libassuan9 \
    libc6 \
    libgcrypt20 \
    libgpg-error0 \
    libnpth0t64 \
    pinentry-curses \
"

RPROVIDES = " \
    gnupg-agent \
"
