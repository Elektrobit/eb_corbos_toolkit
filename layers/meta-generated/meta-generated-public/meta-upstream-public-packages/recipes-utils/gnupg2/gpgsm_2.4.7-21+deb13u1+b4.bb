# This was autogenerated! Do not modify
SUMMARY = "GNU privacy guard - S/MIME version"
DESCRIPTION = ""
SECTION = "utils"
SOURCE_PACKAGE = "gnupg2"
HOMEPAGE = "https://www.gnupg.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gnupg2/gpgsm_2.4.7-21+deb13u1+b4_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gnupg2/gpgsm_2.4.7-21+deb13u1+b4_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "7f973b5c83122d01704c5fee1a058fd8"
SRC_URI[deb0.sha1sum] = "4cf267e62f91b08b055b0ff2ae33278330cf2059"
SRC_URI[deb0.sha256sum] = "03997aceaf3d9eb0ff557a46d0daffd49de8699fb3928f8d94f02c67a9ff9acd"
SRC_URI[deb0.sha512sum] = "2633f31929b1607db720578ba6fdd787b31e39607143eac4276059dcb01d37cc4f10c9098b8581b4768a6640e42b7722f4763829da8a21b81deafd99efb49d87"
SRC_URI[deb1.md5sum] = "2d32d262d55761398c0f0734d2e5615a"
SRC_URI[deb1.sha1sum] = "d94a18f320ce59d4e714734be4772f6b59579396"
SRC_URI[deb1.sha256sum] = "8657f653661eccde6d6678759ef8e7a9932f27869d8f9dd49565264d9b1bc04f"
SRC_URI[deb1.sha512sum] = "312056c93e96b7980f5207f643e834278a70d4b82b16174c20ee4e2d5878a836d4b4a620540813b01cf32273e525b67adf5d2d772def46e2cb9454b74a7606a5"

RDEPENDS = " \
    gpgconf \
    libassuan9 \
    libc6 \
    libgcrypt20 \
    libgpg-error0 \
    libksba8 \
    libnpth0t64 \
    libreadline8t64 \
"

