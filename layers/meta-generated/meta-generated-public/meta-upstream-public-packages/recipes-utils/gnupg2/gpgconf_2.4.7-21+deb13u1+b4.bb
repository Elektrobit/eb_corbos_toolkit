# This was autogenerated! Do not modify
SUMMARY = "GNU privacy guard - core configuration utilities"
DESCRIPTION = ""
SECTION = "utils"
SOURCE_PACKAGE = "gnupg2"
HOMEPAGE = "https://www.gnupg.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gnupg2/gpgconf_2.4.7-21+deb13u1+b4_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gnupg2/gpgconf_2.4.7-21+deb13u1+b4_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "2657e6aeef30d098f66541d4b27163f6"
SRC_URI[deb0.sha1sum] = "826461d3cdb05b131c949d1d053dd49bcc930fb2"
SRC_URI[deb0.sha256sum] = "942c6dc84831ddb1cdb7c2268129458ccc00fc71b01305d9ac4ea7752bd8ac77"
SRC_URI[deb0.sha512sum] = "5dbefa1372d12ac0331c03bb999b91e5a795135cf8fa34e1aebdbce77b718bf486ad4d50d2fe391b1a1e5abd243028a485a3e2913df93134ac5d630d7304c49f"
SRC_URI[deb1.md5sum] = "4d3917c43053305895f8895d3556ee26"
SRC_URI[deb1.sha1sum] = "947684aed0f60ec5eac1ab976de7a3a7f2c5d97f"
SRC_URI[deb1.sha256sum] = "d4b1556e8f13b48cd0061b343cf56beed20fec06a1045631d585ef587d449569"
SRC_URI[deb1.sha512sum] = "e59661febc735a1ef3795a9043d7730e53292f018fdd87b538bb3bf9b94f97359b990792ca99c2dbd3354b6fe0b53a4c6dfb7294fb443910b21dabf8abcc83b0"

RDEPENDS = " \
    libassuan9 \
    libc6 \
    libgcrypt20 \
    libgpg-error0 \
    libreadline8t64 \
"

