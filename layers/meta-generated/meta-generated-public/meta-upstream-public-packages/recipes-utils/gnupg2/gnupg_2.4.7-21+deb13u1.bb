# This was autogenerated! Do not modify
SUMMARY = "GNU privacy guard - a free PGP replacement"
DESCRIPTION = ""
SECTION = "utils"
SOURCE_PACKAGE = "gnupg2"
HOMEPAGE = "https://www.gnupg.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gnupg2/gnupg_2.4.7-21+deb13u1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "e82a3393bd5bfe5db1fc9b3920c39609"
SRC_URI[deb0.sha1sum] = "e049fda4bf18eada4664faf9d5f95f5d812d0737"
SRC_URI[deb0.sha256sum] = "e68f0fd24a7a62f1112ae3e442564e134f21040492f11d1aefa7b18de93ebf6e"
SRC_URI[deb0.sha512sum] = "2402ee18385532904ae05aebd16d8e6e3b207c22896f2bc696a1d094a4a3222b3771df8748b676fbab6af66f4f3ba52a46607042b56852fc12cc3e56a19d1205"

RDEPENDS = " \
    dirmngr \
    gnupg-l10n \
    gpg \
    gpg-agent \
    gpgsm \
"

