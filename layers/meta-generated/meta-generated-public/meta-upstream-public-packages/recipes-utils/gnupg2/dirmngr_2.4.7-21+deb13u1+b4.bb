# This was autogenerated! Do not modify
SUMMARY = "GNU privacy guard - network certificate management service"
DESCRIPTION = ""
SECTION = "utils"
SOURCE_PACKAGE = "gnupg2"
HOMEPAGE = "https://www.gnupg.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gnupg2/dirmngr_2.4.7-21+deb13u1+b4_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gnupg2/dirmngr_2.4.7-21+deb13u1+b4_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "868d6614e6f5e1a6c4b44b6c588872e2"
SRC_URI[deb0.sha1sum] = "5aa8242c1e2de1e4e0251a46f7aac6fd36a165af"
SRC_URI[deb0.sha256sum] = "ad8c291675f38ec1e96a509391860a634619dcc114371fcb5d3028466273bec6"
SRC_URI[deb0.sha512sum] = "3340350a18c3d9bc45bcf17274f142af48bc350d1a4ee1af3304a032251dbc31535ff9c64472b663b78ea0edf205edbe9db7b68a06be5d35b44169ab587fa86c"
SRC_URI[deb1.md5sum] = "bedeeed5ffd496e79a6096717fb4b8c0"
SRC_URI[deb1.sha1sum] = "aa5fa032bda41a69a688ade20e59a41b79999958"
SRC_URI[deb1.sha256sum] = "cc4e5e1a7d684c1ab81bac52a298353f494299e2bb29c5e93a26909b4cf88951"
SRC_URI[deb1.sha512sum] = "03624f7cac0f0c9f58793aad27dad489ae98daaac173664288ee7f140d54041d28c332db117701e55750bf2f00a1d3fec61d36b0dce14420a22ee5236de693cd"

RDEPENDS = " \
    adduser \
    gpgconf \
    init-system-helpers \
    libassuan9 \
    libc6 \
    libgcrypt20 \
    libgnutls30t64 \
    libgpg-error0 \
    libksba8 \
    libldap2 \
    libnpth0t64 \
"

