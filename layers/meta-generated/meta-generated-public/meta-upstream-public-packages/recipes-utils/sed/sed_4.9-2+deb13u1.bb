# This was autogenerated! Do not modify
SUMMARY = "GNU stream editor for filtering/transforming text"
DESCRIPTION = ""
SECTION = "utils"
SOURCE_PACKAGE = "sed"
HOMEPAGE = "https://www.gnu.org/software/sed/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/sed/sed_4.9-2+deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/sed/sed_4.9-2+deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "e1193c8a2c1b124f8d71803ca7490f45"
SRC_URI[deb0.sha1sum] = "6656c2b8b369f80b2c1b6bb86c058b4bdf4d608d"
SRC_URI[deb0.sha256sum] = "7071270ed4f6adda55bc4f926347fb847bacaffbdee3dff917bc6006ed7e3775"
SRC_URI[deb0.sha512sum] = "93008361eabebf6f4e0bba9e2ac36fefb6e25662891d6faa1ceb7759168aecd1822beccdd946ffc99a1d995829435f0fa3d66073b7727612015897f350cd6d2f"
SRC_URI[deb1.md5sum] = "1e8240467fa1d1cf8095244eae665dbb"
SRC_URI[deb1.sha1sum] = "24d792d7d9ee1f20d809f337bea878061fe55146"
SRC_URI[deb1.sha256sum] = "c654fa045de8cc722855b8db59990b703cb7299c897c6e187bf949d42df82b62"
SRC_URI[deb1.sha512sum] = "77d9adb72b87f4902293dabe7d35de0fa96eef000dfe51004cb92e4418f34a11c5934f89cdb1196205813957d81e5d0fe175a4cb666a300aed95f59586881317"

RDEPENDS = " \
    libacl1 \
    libc6 \
    libselinux1 \
"

