# This was autogenerated! Do not modify
SUMMARY = "SELinux core policy utilities"
DESCRIPTION = ""
SECTION = "utils"
SOURCE_PACKAGE = "policycoreutils"
HOMEPAGE = "https://selinuxproject.org"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/policycoreutils/policycoreutils_3.8.1-2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/policycoreutils/policycoreutils_3.8.1-2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "414101567eed668cb542ae601c93f5fc"
SRC_URI[deb0.sha1sum] = "5a77ac1dcb055dcaf449bc9a20e503db6744672d"
SRC_URI[deb0.sha256sum] = "ff7fd62f4db52ebb491e85fa1f9f96289680bd99a9cd3b74c54fec86eefb0f3d"
SRC_URI[deb0.sha512sum] = "c25076b4a8b16e05f6028dd964d5769807b48288499fcc928d2af56a449f1aa00248aaf130c7c070520b01e684533f2275237629ec0a85d9da3f7925892dcb4f"
SRC_URI[deb1.md5sum] = "a1da17cdb9304396fc6d318fc24bb751"
SRC_URI[deb1.sha1sum] = "d59c6c94e9ea7b87fba423ba1a7e07b8ff32d476"
SRC_URI[deb1.sha256sum] = "e92646de24466b042732d3005932744e9b5d103614bf918f479bdee36893c48a"
SRC_URI[deb1.sha512sum] = "eee74e0ed6eda01198ed0bd7e782ae282486764fa1af318b0932289e6ca083e590d451e957b013e772dae62959da6339a083de4f3a10eda273c478f8d506e8be"

RDEPENDS = " \
    libaudit1 \
    libc6 \
    libselinux1 \
    libsemanage2 \
    libsepol2 \
    selinux-utils \
"

