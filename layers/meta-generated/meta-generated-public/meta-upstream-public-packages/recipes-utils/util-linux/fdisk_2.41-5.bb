# This was autogenerated! Do not modify
SUMMARY = "collection of partitioning utilities"
DESCRIPTION = ""
SECTION = "utils"
SOURCE_PACKAGE = "util-linux"
HOMEPAGE = "https://github.com/util-linux/util-linux"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/u/util-linux/fdisk_2.41-5_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/u/util-linux/fdisk_2.41-5_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "eb3ed867747101364ac253adda3b8b59"
SRC_URI[deb0.sha1sum] = "41cbcdd8d01257e1b188b70181d7a06ab809e637"
SRC_URI[deb0.sha256sum] = "d9f6b4586d362d98bdc8e930515e8b44b69009b0f05d8cedf6b578240db24031"
SRC_URI[deb0.sha512sum] = "2272abd2871d0dc2d627209c68fc0c01c68bb39ffabd4ce27cd0c5d2b16ee3da00c952b25ed00dfebf6f5693cb82329fafc766b38583be74af255c44d132b129"
SRC_URI[deb1.md5sum] = "c8d520ad4f4197c5a1ded29c2a7860db"
SRC_URI[deb1.sha1sum] = "102cfdec2d609edbcde0247651e75390eb62ca32"
SRC_URI[deb1.sha256sum] = "519653c1567df134173dbe5303751f2539a7b66b3fc863356ade94a4f6e03b2f"
SRC_URI[deb1.sha512sum] = "9b1b6a49d775469860a9e26c414d4090bf66623c00d805ae5e076a0060c4593f01c5976801259b8cf618c711d10ff2d64579dc67fc8e361a723cac5213250c2d"

RDEPENDS = " \
    libc6 \
    libfdisk1 \
    libmount1 \
    libncursesw6 \
    libreadline8t64 \
    libsmartcols1 \
    libtinfo6 \
"

