# This was autogenerated! Do not modify
SUMMARY = "extra utilities from 4.4BSD-Lite"
DESCRIPTION = ""
SECTION = "utils"
SOURCE_PACKAGE = "util-linux"
HOMEPAGE = "https://github.com/util-linux/util-linux"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/u/util-linux/bsdextrautils_2.41-5_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/u/util-linux/bsdextrautils_2.41-5_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "95fd76cdee60a5a012cc8305b1ebba7d"
SRC_URI[deb0.sha1sum] = "52a001ac80e59931f09ff5925fb72585b028830c"
SRC_URI[deb0.sha256sum] = "117a29c515e7622f9824c0538df7fe9ab960ed5432fb6a48e32381ffedb39e84"
SRC_URI[deb0.sha512sum] = "016d4fc65aed6f1167ddb1d6518e212b13ef95c7e5f19bec627a4e615617b583d393bd22287369441b16c418a8edfa514282cdda6802f5f14ddd59aae5f15fd7"
SRC_URI[deb1.md5sum] = "ccbfd93ebd8e4862916ad58a8792186a"
SRC_URI[deb1.sha1sum] = "9d0926114060df0332bc3649100fe9c306cd5bf6"
SRC_URI[deb1.sha256sum] = "2a689acb8d0583266888d9dccd7f2125e86fc75522888b3890ff17dcdf1ee471"
SRC_URI[deb1.sha512sum] = "d288b5c40f28760b896aabb2bdb8779cb48d9548378db19a612a499d1ae6b0ee74fd7af4cbface6ddd9e98e34a15c44ea699172a709fa0e899da077eec5869da"

RDEPENDS = " \
    libc6 \
    libsmartcols1 \
    libtinfo6 \
"

