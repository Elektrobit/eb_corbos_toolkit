# This was autogenerated! Do not modify
SUMMARY = "basic utilities from 4.4BSD-Lite"
DESCRIPTION = ""
SECTION = "utils"
SOURCE_PACKAGE = "util-linux"
HOMEPAGE = "https://github.com/util-linux/util-linux"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/u/util-linux/bsdutils_2.41-5_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/u/util-linux/bsdutils_2.41-5_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "69b1f4622bbac6f2fbc34c91856c0801"
SRC_URI[deb0.sha1sum] = "afc4240894358a10f60337be459bb29f6cbaa8af"
SRC_URI[deb0.sha256sum] = "4548718c2fd4152486be0de7cab16027caef5678e52e200e51ded265fca89629"
SRC_URI[deb0.sha512sum] = "8ab6922c8443f7cd5949f8aaf8c94be6949f1180f986a035934a2bcd8987a87bd09f0ad03bb6ad6fd6baad1935b171f6b01bf5b1f568e4859a81341e785b3481"
SRC_URI[deb1.md5sum] = "2d7ff5ae037279107fec5b3d4f2a7b5a"
SRC_URI[deb1.sha1sum] = "d5c30687591b8e9dcd6c0e8286f23f019644c4f8"
SRC_URI[deb1.sha256sum] = "a96b13485499f2c764b23fddac21397f79c104b4140838a8daebb1e6c6e8fec8"
SRC_URI[deb1.sha512sum] = "8eaa556c44249adfb2c2ccd4d2157cb7b8545e2e8a7794ef002f0f0b283116a59d1beba10a1161c8b32818cb4699cafccd53d3e3727a4ab9d5bbfb5768a5fb2f"

RDEPENDS = " \
    libc6 \
    libsystemd0 \
"

