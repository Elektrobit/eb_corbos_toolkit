# This was autogenerated! Do not modify
SUMMARY = "modify properties of ELF executables"
DESCRIPTION = ""
SECTION = "utils"
SOURCE_PACKAGE = "patchelf"
HOMEPAGE = "https://nixos.org/patchelf.html"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/patchelf/patchelf_0.18.0-1.4_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/patchelf/patchelf_0.18.0-1.4_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "51e4b7a9af83d21ddc0d2f996634d0eb"
SRC_URI[deb0.sha1sum] = "0e45e252476a0c9c832fc5148772f6779ea2cab0"
SRC_URI[deb0.sha256sum] = "1d39a7973504a4a5eb4101293cca142b83055a5a0f94e1d4286ded2563289b92"
SRC_URI[deb0.sha512sum] = "c7997b4aef1b2e7cee9c8d0611674be5d949a2d7c06aef23ceddee9dfc8da2f076eed8e614dd9ffb263ee16738dbb739988fd46e7e57ca6b0eaf3ca791c32ab5"
SRC_URI[deb1.md5sum] = "136c446d7a4021724ffe7bce9c7bed36"
SRC_URI[deb1.sha1sum] = "d8862ab55477498146eca50c4322a1471cdc3386"
SRC_URI[deb1.sha256sum] = "0c0f4fa523837615f649835ef9c396e5ae13095801980bffaf13351645f9075b"
SRC_URI[deb1.sha512sum] = "c29d10501be0c83c2fc98f385754a6e2c675797016456c2764ddd4c000d20b8358c9e341ec5b1b4a6a9c1fecb213125e99a64910f26ab8913d36fb7c77c01b71"

RDEPENDS = " \
    libc6 \
    libgcc-s1 \
    libstdc++6 \
"

