# This was autogenerated! Do not modify
SUMMARY = "high-quality block-sorting file compressor - utilities"
DESCRIPTION = ""
SECTION = "utils"
SOURCE_PACKAGE = "bzip2"
HOMEPAGE = "https://sourceware.org/bzip2/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/b/bzip2/bzip2_1.0.8-6_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/b/bzip2/bzip2_1.0.8-6_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "f9e2f91306ce31a447aa51ab618e49a9"
SRC_URI[deb0.sha1sum] = "fddc4a36f535ca9530e72b0bd42b4d6bc9e91218"
SRC_URI[deb0.sha256sum] = "6b5fbe71f0fc41e85919bc4b3c514e6c47577c5005dbf1f5af6e4a49cc221aab"
SRC_URI[deb0.sha512sum] = "603dc2846def445019e0b2dc9a779048095ab51e52145fb3990ce79d90790e5cb8c9b25ead2a780838f75ed87d6075f9e3b6d202471a166313ffe2bda9887e71"
SRC_URI[deb1.md5sum] = "55c90a75e68c3451ad91761f6a3350ca"
SRC_URI[deb1.sha1sum] = "697a401b32776b2556f9011b22428f340699b8d5"
SRC_URI[deb1.sha256sum] = "9fa8514c3fb3f363e7fa8bc85f699aaf15e747afaf220c57b978e9b74fd568bc"
SRC_URI[deb1.sha512sum] = "863e88197f8bfc976f85f05f2342fe409af9cc479135607e6004e093fe73344962e7993855666c7bcfb4366b9520337d3253dedf1f815dc7371fadba170fec41"

RDEPENDS = " \
    libbz2-1.0 \
    libc6 \
"

