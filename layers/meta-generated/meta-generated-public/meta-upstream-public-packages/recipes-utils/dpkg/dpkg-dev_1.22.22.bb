# This was autogenerated! Do not modify
SUMMARY = "Debian package development tools"
DESCRIPTION = ""
SECTION = "utils"
SOURCE_PACKAGE = "dpkg"
HOMEPAGE = "https://wiki.debian.org/Teams/Dpkg"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/d/dpkg/dpkg-dev_1.22.22_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "0195cfec3dcf105991bb58063ef77478"
SRC_URI[deb0.sha1sum] = "b478d0d91b6c5458686983c1baf28cd347914283"
SRC_URI[deb0.sha256sum] = "6d4020421740a70e1fb9c41b07f8bb8306d93aef6fea1a8ce11a1f839921f414"
SRC_URI[deb0.sha512sum] = "ca7d76014344eaa281849188e14687ead9581242662bbcaf801a64ca216ffaba4ee0cee16c0d7b25a619700c281b719308b2bad7fdec335245842428ed9ba73b"

RDEPENDS = " \
    binutils \
    bzip2 \
    libdpkg-perl \
    make \
    patch \
    perl \
    tar \
    xz-utils \
"

RPROVIDES = " \
    dpkg-build-api \
"
