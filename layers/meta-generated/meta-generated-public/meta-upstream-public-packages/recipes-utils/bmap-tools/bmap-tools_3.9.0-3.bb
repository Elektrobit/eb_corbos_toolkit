# This was autogenerated! Do not modify
SUMMARY = "transitional package"
DESCRIPTION = ""
SECTION = "utils"
SOURCE_PACKAGE = "bmap-tools"
HOMEPAGE = "https://github.com/yoctoproject/bmaptool"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/b/bmap-tools/bmap-tools_3.9.0-3_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "360507ae9145521a867526326dc91d53"
SRC_URI[deb0.sha1sum] = "97084e889391f64f0c8737b44d2592e4b1aad3ed"
SRC_URI[deb0.sha256sum] = "c9c825c49c8813217d92a244d8ad5322e869ea41c96c33640ba3c594e45cd488"
SRC_URI[deb0.sha512sum] = "f75577d6b11a6c2935cbb565549ea80e90f12648a51d1c5698e649a92d9d3d2e2f078de297f99619c20ef2f4cfac14e52e885205edd2f1b2efbcb61f11f85423"

RDEPENDS = " \
    bmaptool \
"

