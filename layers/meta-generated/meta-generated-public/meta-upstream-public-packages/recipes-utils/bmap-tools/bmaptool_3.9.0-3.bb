# This was autogenerated! Do not modify
SUMMARY = "tool to flash image files to block devices using the block map"
DESCRIPTION = ""
SECTION = "utils"
SOURCE_PACKAGE = "bmap-tools"
HOMEPAGE = "https://github.com/yoctoproject/bmaptool"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/b/bmap-tools/bmaptool_3.9.0-3_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "f17c17dd9b1528726c96f95378ad0389"
SRC_URI[deb0.sha1sum] = "82685902e669b19c3853e42be863fd94dc1ccf78"
SRC_URI[deb0.sha256sum] = "25855ef25857a77a31fa750ea8239e8df250d2f20f4e303e9cbe1402db28347d"
SRC_URI[deb0.sha512sum] = "da22f4fa8358ecd1f85c028aa104c26af6fe3b64c5c2683cc2ed7e09e89c41930db5941338345da910e9daffc2564d813469ca7b774c2c1a5be4b949de0f0e63"

RDEPENDS = " \
    python3 \
"

RPROVIDES = " \
    bmap-tools \
"
