# This was autogenerated! Do not modify
SUMMARY = "Secure Sockets Layer toolkit - cryptographic utility"
DESCRIPTION = ""
SECTION = "utils"
SOURCE_PACKAGE = "openssl"
HOMEPAGE = "https://openssl-library.org"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/o/openssl/openssl_3.5.6-1~deb13u2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/o/openssl/openssl_3.5.6-1~deb13u2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "8a87f7d54af366db55fedc572e530322"
SRC_URI[deb0.sha1sum] = "800be77287a05e5b1a4c70e2ea363dbab6945cea"
SRC_URI[deb0.sha256sum] = "7b4270966255f0bad468ac889f4b090a6e10eb6ccbc2be0fa418560b24bdef5a"
SRC_URI[deb0.sha512sum] = "eb508215ec97ca63295fa65f32483671ffca6fbd7f4f4718d7c4e6d081620a5f112ef646e9000f493536d5bb8c176bea92f1c045487c0fc01e0ccef2e55fdf14"
SRC_URI[deb1.md5sum] = "8e4a5e4460f82f4a311c049e07737108"
SRC_URI[deb1.sha1sum] = "4b411e66ee3d3106570389d5d1e022b15c1975a8"
SRC_URI[deb1.sha256sum] = "1ee735e2480519bd1fd5f6576a879243bc81b9773059e1fa1ec8b8943c84e77c"
SRC_URI[deb1.sha512sum] = "2f3d41dca662b6e0d708169bc63e0c238c6daf16c43d493819c83a5f7083314726860c22563713ee7bef3ec719107074de8e21b6d13b41007ce1d9459ff058ab"

RDEPENDS = " \
    libc6 \
    libssl3t64 \
"

