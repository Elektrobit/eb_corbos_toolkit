# This was autogenerated! Do not modify
SUMMARY = "Git pre-commit hook framework (hooks)"
DESCRIPTION = ""
SECTION = "utils"
SOURCE_PACKAGE = "pre-commit-hooks"
HOMEPAGE = "https://pre-commit.com"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/pre-commit-hooks/pre-commit-hooks_5.0.0+dfsg-5_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "a615dbb42b8aa2b5ba60cb0229e0186b"
SRC_URI[deb0.sha1sum] = "f08979c5090d2ba1033fba79b519e10909b4c072"
SRC_URI[deb0.sha256sum] = "a2eb5ad2a7d302eda40dc538dbb10627f3bf9e58860f7600178bbd743d1001f7"
SRC_URI[deb0.sha512sum] = "8c467f03143d5080f6a7c8620cdc4f48a6044ffabb25fea8d1efd5ba0b717524812981b87fbeef0141770bd1c9b5e66d930338c78ebc8da1cbdd478868d21868"

RDEPENDS = " \
    pre-commit \
    python3 \
    python3-ruamel.yaml \
    python3-tomli \
"

