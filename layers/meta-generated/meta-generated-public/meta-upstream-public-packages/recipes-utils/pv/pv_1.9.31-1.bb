# This was autogenerated! Do not modify
SUMMARY = "Shell pipeline element to meter data passing through"
DESCRIPTION = ""
SECTION = "utils"
SOURCE_PACKAGE = "pv"
HOMEPAGE = "https://www.ivarch.com/programs/pv.shtml"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/pv/pv_1.9.31-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/pv/pv_1.9.31-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "cf599ce9c74b0acdb5a96650da7bde1a"
SRC_URI[deb0.sha1sum] = "7a3132d3600bd373a25f710b1128b95a42a25812"
SRC_URI[deb0.sha256sum] = "0511c9cab1bd89e8463bf0dcdf75d3aec20ded3a02f78ee90dbad220a9f80ce4"
SRC_URI[deb0.sha512sum] = "54ed813fd06721c5744f00517717398c8c83594d343f4d368c9cb9ae59ab103f7f7a7ae23ea2fb98c2727b67117ca1b7f82497b660c12418b7a8908f0fa12fb7"
SRC_URI[deb1.md5sum] = "c7899204e6e4fcf6b992f0754507e67d"
SRC_URI[deb1.sha1sum] = "cabea5afb51b4daf38014fd553f4703013f7188c"
SRC_URI[deb1.sha256sum] = "9b88169ddfb7bb5de035ddccaa91729d8dc0b8d4fd188b650bb28406a5bf129b"
SRC_URI[deb1.sha512sum] = "2d56da75cdde357cba58fd74b1582f467040cebd9183bbe22dc14a9128277fceb18048fad0759fde2eba9e4938c295ddb72b59fbb0a650492cf9965923dc638a"

RDEPENDS = " \
    libc6 \
"

