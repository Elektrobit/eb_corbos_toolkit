# This was autogenerated! Do not modify
SUMMARY = "GNU grep, egrep and fgrep"
DESCRIPTION = ""
SECTION = "utils"
SOURCE_PACKAGE = "grep"
HOMEPAGE = "https://www.gnu.org/software/grep/"

inherit dpkg-prebuilt

DPKG_ARCH = "amd64"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/grep/grep_3.11-4_amd64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "1f47b207c6d08b310fe88ec3576cdf80"
SRC_URI[deb0.sha1sum] = "acab56dcc116f8299c197dff8e071559a4c0cbf9"
SRC_URI[deb0.sha256sum] = "2d78ed07d86a530ebf538f05cb2415f37c8daf908596bc32fc2563cc7e88c55a"
SRC_URI[deb0.sha512sum] = "7340e5d47335a72bc10633fba86f0fc124ae92a24535d929da95cab03b6cd359a033dbaac38a896a25ca68d2ca22a3ed48a68f4445751920e3c301eddb8e4cf2"

RDEPENDS = " \
    libc6 \
    libpcre2-8-0 \
"

RPROVIDES = " \
    rgrep \
"
