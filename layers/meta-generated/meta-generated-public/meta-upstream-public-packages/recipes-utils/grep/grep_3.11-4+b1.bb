# This was autogenerated! Do not modify
SUMMARY = "GNU grep, egrep and fgrep"
DESCRIPTION = ""
SECTION = "utils"
SOURCE_PACKAGE = "grep"
HOMEPAGE = "https://www.gnu.org/software/grep/"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/grep/grep_3.11-4+b1_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "d4ddfd57fcaabe16ef8443305ef15adc"
SRC_URI[deb0.sha1sum] = "ffaa924916c8c7738b968c5e5c7d51d029864b55"
SRC_URI[deb0.sha256sum] = "6f7257fbec0197bd54b2347861ff01e2c4e8411790b0df20242483615324fe66"
SRC_URI[deb0.sha512sum] = "c54e9933de5de7a0c74062efc22e0c91df33a3e0c50a129d39cda88f67f8175d7c1934037b1fdb32a9068a8fc455050fe0ad60f68910dd5d873bdd522ed9594b"

RDEPENDS = " \
    libc6 \
    libpcre2-8-0 \
"

RPROVIDES = " \
    rgrep \
"
