# This was autogenerated! Do not modify
SUMMARY = "fast lossless compression algorithm -- CLI tool"
DESCRIPTION = ""
SECTION = "utils"
SOURCE_PACKAGE = "libzstd"
HOMEPAGE = "https://github.com/facebook/zstd"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libz/libzstd/zstd_1.5.7+dfsg-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libz/libzstd/zstd_1.5.7+dfsg-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "46b1e66daba096341f3718c7032606f7"
SRC_URI[deb0.sha1sum] = "68018e28d4afac4567e7ef0b4b86aa8cd888734d"
SRC_URI[deb0.sha256sum] = "6da09b6aad171ef9b50d6a2bb4c62f756b3561aac5e05b452b80516223e5e0f5"
SRC_URI[deb0.sha512sum] = "97c233923b7b7e8bab604c2e173ec092944e70f22c44b9ba892df960f04432f86ee9d828928ab68d11893b8a95f4d6ee543a4220bd96bdea1c572e429bc6651c"
SRC_URI[deb1.md5sum] = "3193d080a9cb13e29bf3f71a453546a0"
SRC_URI[deb1.sha1sum] = "20ac84ea4dbc16287ac25fa680130b1a6e01d643"
SRC_URI[deb1.sha256sum] = "715696637b45bf1c30230f1c97f9ffdc9af18ead053564d9349f92accccbe988"
SRC_URI[deb1.sha512sum] = "f5855d80401519b5f90b70a2de7078f58af34da131f188cc72c9f871d36fe78321d344809167cf4cd551210d2d0def3118c0d5faf443926630cdb9f19b4a729d"

RDEPENDS = " \
    libc6 \
    libgcc-s1 \
    liblz4-1 \
    liblzma5 \
    libstdc++6 \
    zlib1g \
"

