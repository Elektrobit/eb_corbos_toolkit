# This was autogenerated! Do not modify
SUMMARY = "Debian package repository producer"
DESCRIPTION = ""
SECTION = "utils"
SOURCE_PACKAGE = "reprepro"
HOMEPAGE = ""

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/r/reprepro/reprepro_5.4.6+really5.3.2-1+deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/r/reprepro/reprepro_5.4.6+really5.3.2-1+deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "667536c2ee53ffa2ff8119207df001de"
SRC_URI[deb0.sha1sum] = "821bcd14cb5b26a814c950e024943ab474f21bdb"
SRC_URI[deb0.sha256sum] = "65e79fec4d40fc8bb71fb39d4d7048388313b634910dcc2d9a09c8a5a11147fc"
SRC_URI[deb0.sha512sum] = "761b797223e97580147b37013c7db08ee82cb808e0ea10865495a441fb4d60358ccd3560c1bdfe5ccc9d2cf3dee6b2c5af7dfbe229f28b3938950d52d3c8f77f"
SRC_URI[deb1.md5sum] = "15b833c5b05edeb18b4d015609ac9d3b"
SRC_URI[deb1.sha1sum] = "6adc1f389dd04392e5be0082df8a56b0fafabd27"
SRC_URI[deb1.sha256sum] = "fa02dc4489f6f43c1b67c6a6ba1ac22919da46e8f6ffc7cc854d7e1cfaa910d4"
SRC_URI[deb1.sha512sum] = "fc34b0bc913c4dd66f1ef1a47fdc04c48c8a67064f2e2779abb69d73c6c6d812d00df8c71829c797c11050548bc1cad0d52a202712bcb37c33731a1b6c8e64e2"

RDEPENDS = " \
    libarchive13t64 \
    libbz2-1.0 \
    libc6 \
    libdb5.3t64 \
    libgpg-error0 \
    libgpgme11t64 \
    liblzma5 \
    zlib1g \
    zstd \
"

