# This was autogenerated! Do not modify
SUMMARY = "File comparison utilities"
DESCRIPTION = ""
SECTION = "utils"
SOURCE_PACKAGE = "diffutils"
HOMEPAGE = "https://www.gnu.org/software/diffutils/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/d/diffutils/diffutils_3.10-4_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/d/diffutils/diffutils_3.10-4_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "450c9dbd5dd06e7f36929edb5b822a99"
SRC_URI[deb0.sha1sum] = "e3bb06b8e1842b3876f98c276d12bf98b51fd907"
SRC_URI[deb0.sha256sum] = "d3412669f7ae53ba895c3a509620ea7494ec1a36faa204c5215442ced381a479"
SRC_URI[deb0.sha512sum] = "8a3caeff4f23c5332326b9d9085a21334a81460dbfb89bde50a094201d5deca76162da007c6545a1b87cb8606d48924b2c66e4fe5786c8b88b3f63d976970897"
SRC_URI[deb1.md5sum] = "dfe9dd35f95d49cc7c9962b5bdf783b5"
SRC_URI[deb1.sha1sum] = "0cf1ca80b95f8947fdb744789960344c69100b17"
SRC_URI[deb1.sha256sum] = "85cfb5576fa43ba2bd2047c53140fb465b929753048e53eb0fe6482ed343a5b9"
SRC_URI[deb1.sha512sum] = "c6f379ede8112260de40aeea706bd2f5b29e43330c9614193a7f416ccd69d82986613e517bd2f63741c10270b150d6b3542c70b92dea0167fc81f4fd8a006032"

RDEPENDS = " \
    libc6 \
"

