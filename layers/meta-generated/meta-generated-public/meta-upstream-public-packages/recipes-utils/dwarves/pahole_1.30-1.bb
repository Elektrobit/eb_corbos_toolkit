# This was autogenerated! Do not modify
SUMMARY = "set of advanced DWARF utilities"
DESCRIPTION = ""
SECTION = "utils"
SOURCE_PACKAGE = "dwarves"
HOMEPAGE = "https://git.kernel.org/pub/scm/devel/pahole/pahole.git"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/d/dwarves/pahole_1.30-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/d/dwarves/pahole_1.30-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "9a55f4a269de6d9add4ad2afd4af3da4"
SRC_URI[deb0.sha1sum] = "e9dd11bd6770f68b289e7c354bca2a78b031246b"
SRC_URI[deb0.sha256sum] = "08b8b559ab1707dc146880d329f1e96f011788a18d6d3dc7159accd488ae2712"
SRC_URI[deb0.sha512sum] = "895ecad093b838290b97c0e2d838ab407bc44b6dedec1087c50116cb188f91c4b8f8c61a70c770d78800b0df07878a5bacc62e9016db9c94d0e1d2664638969e"
SRC_URI[deb1.md5sum] = "3c095f0f697d3afa72f9ad02f456f005"
SRC_URI[deb1.sha1sum] = "84b9d53f152fce2515a7d7d6d4e543ee65e59ce9"
SRC_URI[deb1.sha256sum] = "0363d28e3153746e08f18de2b916f292937e292f0abf0cd1cf67a10a8884ec1b"
SRC_URI[deb1.sha512sum] = "fd8668c3269c0c895405aa19f57dab90beeee4f3d9988dda90b13c08c6f0430d40f6c56927264082b930d451c65b1a5388821fd0489e386a7b6097866b78016f"

RDEPENDS = " \
    libbpf1 \
    libc6 \
    libdw1t64 \
    libelf1t64 \
    zlib1g \
"

