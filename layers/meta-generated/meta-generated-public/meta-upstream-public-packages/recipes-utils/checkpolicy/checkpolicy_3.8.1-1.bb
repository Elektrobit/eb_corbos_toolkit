# This was autogenerated! Do not modify
SUMMARY = "SELinux policy compiler"
DESCRIPTION = ""
SECTION = "utils"
SOURCE_PACKAGE = "checkpolicy"
HOMEPAGE = "https://selinuxproject.org"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/c/checkpolicy/checkpolicy_3.8.1-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/c/checkpolicy/checkpolicy_3.8.1-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "bd2ee94f095e086711e429976f6caa97"
SRC_URI[deb0.sha1sum] = "ea5ec866dc93e266e312959d8e1c3a81b0e397eb"
SRC_URI[deb0.sha256sum] = "516e55cd961b7083cf973d5e7fb37240ead5b410afbaf34130b227736fb72cf8"
SRC_URI[deb0.sha512sum] = "328756cc7c20836b7a1db292efc77cf58ad23ebdf2dc46da2294f5c539915838e66d406fe9f19db758651c399f563f1399f2626dc6fefc1552c40c3c377d2d1a"
SRC_URI[deb1.md5sum] = "157774abc5d473dafe4549a89b8fc456"
SRC_URI[deb1.sha1sum] = "e2228e1daf67d562b6bb2ee189837d8a65118305"
SRC_URI[deb1.sha256sum] = "ea0be7635a1b7ef0c2e8f9bc47c6d0d6738117d1e52ec23c218470f57ec6ff73"
SRC_URI[deb1.sha512sum] = "9f8ea37bb87f4ee914d69d453dc9e25234e2e84d418bf4c0a136565b170bd662e501ff99ae881e40883444fd5c0e6814bfcd85bf3f78bf2be8f30abdddc44381"

RDEPENDS = " \
    libc6 \
"

