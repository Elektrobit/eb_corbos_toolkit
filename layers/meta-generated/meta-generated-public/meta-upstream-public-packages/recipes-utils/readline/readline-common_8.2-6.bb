# This was autogenerated! Do not modify
SUMMARY = "GNU readline and history libraries, common files"
DESCRIPTION = ""
SECTION = "utils"
SOURCE_PACKAGE = "readline"
HOMEPAGE = "https://tiswww.case.edu/php/chet/readline/rltop.html"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/r/readline/readline-common_8.2-6_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "699adc544b8b12ad493f3b410ad4e4af"
SRC_URI[deb0.sha1sum] = "0167929bc1df456a6491de90b1f861fb0b6a4e89"
SRC_URI[deb0.sha256sum] = "f77e8aa0bf0de618f11cb0b21658a4ed60f177d63b3cf26d7fc3706b6d0eaaa9"
SRC_URI[deb0.sha512sum] = "108b7c792a22a95734804b1f2ba4893463fb8353da03ced2480d0a255ef0a9af1ff2378921eb7e0f677a1c9ac7b3842d7bd4f9ef95153ba1478c8d4f296ba6e6"


