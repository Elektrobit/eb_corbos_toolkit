# This was autogenerated! Do not modify
SUMMARY = "commandline package manager"
DESCRIPTION = ""
SECTION = "admin"
SOURCE_PACKAGE = "apt"
HOMEPAGE = ""

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/a/apt/apt_3.0.3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/a/apt/apt_3.0.3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "76925aa223bcc069e7a062819111857b"
SRC_URI[deb0.sha1sum] = "f322c60c73430de334f48aaf4be1918bcd4a72e9"
SRC_URI[deb0.sha256sum] = "55e341fbe92d7502c98faf1b3c235393ea0744db119cf2173603e965b658aef4"
SRC_URI[deb0.sha512sum] = "0bba33fb09eb7e099cc966235fcbd02419a60d04ff5daf4275d46fdf486b0fd28266c05e2150fcf9a962d9b34d774f8e643a6ff0690fa60275a16b8dba257adf"
SRC_URI[deb1.md5sum] = "5371ac3167816a5489f7cc3c6b2e1572"
SRC_URI[deb1.sha1sum] = "ad65d3295e23316ef868e881d95e2a2ad8af9250"
SRC_URI[deb1.sha256sum] = "9d88b95c6a6c9880b1bb40aebe7df3b34a0a160a9430d76fac496512a4cf69a6"
SRC_URI[deb1.sha512sum] = "f9c92e40428cc29b4a9fce2599b6af9f145e76069aa872b5ee982197520781d9f53f139cca7a86f7593e42a3ecbfe62d3d7778434ba2c7435cd0b8ed6862e6a9"

RDEPENDS = " \
    base-passwd \
    debian-archive-keyring \
    libapt-pkg7.0 \
    libc6 \
    libgcc-s1 \
    libseccomp2 \
    libssl3t64 \
    libstdc++6 \
    libsystemd0 \
    sqv \
"

RPROVIDES = " \
    apt-transport-https \
"
