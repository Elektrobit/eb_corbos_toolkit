# This was autogenerated! Do not modify
SUMMARY = "Strict and Targeted variants of the SELinux policy"
DESCRIPTION = ""
SECTION = "admin"
SOURCE_PACKAGE = "refpolicy"
HOMEPAGE = "https://github.com/SELinuxProject/refpolicy/releases"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/r/refpolicy/selinux-policy-default_2.20250213-10_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "421f92391582def62b61576722a54999"
SRC_URI[deb0.sha1sum] = "799c32f30d42dec259d8ff58f875ec9af4cd07ab"
SRC_URI[deb0.sha256sum] = "9354bf9acb15df41d5a67b8d610585b1df5e532d15f6c5a5a97af02935c8976b"
SRC_URI[deb0.sha512sum] = "05633a3e48ca8ace67db35bc63e639f91ff09e7da3574efddf1bb25cf404cdb8b1293100d3c9969233610ceb5a0824410aeef1f7416458cee783e3fa80580ccf"

RDEPENDS = " \
    libselinux1 \
    libsemanage2 \
    libsepol2 \
    policycoreutils \
    selinux-utils \
"

