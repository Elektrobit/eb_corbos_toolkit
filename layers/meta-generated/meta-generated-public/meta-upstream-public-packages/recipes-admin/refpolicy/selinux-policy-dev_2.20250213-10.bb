# This was autogenerated! Do not modify
SUMMARY = "Headers from the SELinux reference policy for building modules"
DESCRIPTION = ""
SECTION = "admin"
SOURCE_PACKAGE = "refpolicy"
HOMEPAGE = "https://github.com/SELinuxProject/refpolicy/releases"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/r/refpolicy/selinux-policy-dev_2.20250213-10_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "d0e0137fd730abc5d6801b420dfbf663"
SRC_URI[deb0.sha1sum] = "9f80be3a2574447e47b25172f1009a806009b92e"
SRC_URI[deb0.sha256sum] = "670b240872625921f2106bf543dda416a4753e46d56671aee18f358ed9cda079"
SRC_URI[deb0.sha512sum] = "6d9fa77df4ff72e4f56052edd20a0f8a958acfa2911d41eaacabc2583862d9866cb217b5649119bf87d77d6c1f4e3011f212c1c62eb9e80db233ab84294c6ae5"

RDEPENDS = " \
    checkpolicy \
    gawk \
    m4 \
    make \
    policycoreutils \
    policycoreutils-dev \
    policycoreutils-python-utils \
    python3 \
    selinux-utils \
"

