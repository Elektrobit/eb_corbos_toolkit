# This was autogenerated! Do not modify
SUMMARY = "disk partition manipulator"
DESCRIPTION = ""
SECTION = "admin"
SOURCE_PACKAGE = "parted"
HOMEPAGE = "https://www.gnu.org/software/parted"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/parted/parted_3.6-5_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/parted/parted_3.6-5_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "24dc476e730123516c5b72aa551c7bb9"
SRC_URI[deb0.sha1sum] = "ab61706c0b9ddb09d7492966ea851a38c2cea2b5"
SRC_URI[deb0.sha256sum] = "fbb8429783a8dd065bf9c37e249acaa56cb7bb8a3ff5bb531ef0aac3e8945f2d"
SRC_URI[deb0.sha512sum] = "2286830f5d77874b2a8060e2ccfc7c24fa0a321c9dcb186b45d9be9f49c1fcbe798b9ff288f991f1c04e7cae876ea7d8af884dc184853a2ae2135881f860d0e7"
SRC_URI[deb1.md5sum] = "3d67003a6cdc9f1f6e0a68a23be2cbc2"
SRC_URI[deb1.sha1sum] = "c5362e764424d0ede7a47952cad531f728a1f596"
SRC_URI[deb1.sha256sum] = "62006921ec2a8b10ad3e52d0bbaf41b31f6806ea5d3ee15c8544b379c6e712ab"
SRC_URI[deb1.sha512sum] = "08c2b8dbc14a7234cf2bf5e04723a66d785b91a03e5bb8954517b04d7a45dae9547bfa60a5c1a50ac4099c1a63afcb3a46bdfe13396d6d4c5ceeb1d119d3960f"

RDEPENDS = " \
    libc6 \
    libparted2t64 \
    libreadline8t64 \
    libtinfo6 \
    libuuid1 \
"

