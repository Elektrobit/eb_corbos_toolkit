# This was autogenerated! Do not modify
SUMMARY = "/dev/ and hotplug management daemon"
DESCRIPTION = ""
SECTION = "admin"
SOURCE_PACKAGE = "systemd"
HOMEPAGE = "https://systemd.io"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/systemd/udev_257.13-1~deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/systemd/udev_257.13-1~deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "85541050882865f0984cf8e63154055c"
SRC_URI[deb0.sha1sum] = "215050c14e0f43209c2ea88ce6d576c1ee437dd0"
SRC_URI[deb0.sha256sum] = "a9d751b4d73a489120ef68a21caedf0b58fba80598fb22a17f85060f308bfe7e"
SRC_URI[deb0.sha512sum] = "d4b1558142badddf14889de57290bfabd98498944ce504ef9830079dba0828d1f1855bc79f0cc42c6de97f3051828aa60a14ffa6fef341081e3253e691748155"
SRC_URI[deb1.md5sum] = "1d0403e80ac7b8db6103593dbed536a1"
SRC_URI[deb1.sha1sum] = "39ed500eb48d2c8283b8b8c4f18cddee0d179d3d"
SRC_URI[deb1.sha256sum] = "eed77ec245475039937d5c2d5ae3bbd7241420f21277a2edbb28c60cf9fec1ca"
SRC_URI[deb1.sha512sum] = "5ab25f7dd786d61b0b4ae9cc47206e87593265dee1dd2f18bd21c55b419a2197395182bd37f26bf2e84657fbf3c053f7b9c55f67a4f670d255685d776e73099a"

RDEPENDS = " \
    libblkid1 \
    libc6 \
    libkmod2 \
    libsystemd-shared \
    libudev1 \
    systemd \
"

