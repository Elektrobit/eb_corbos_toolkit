# This was autogenerated! Do not modify
SUMMARY = "system and service manager - SysV compatibility symlinks"
DESCRIPTION = ""
SECTION = "admin"
SOURCE_PACKAGE = "systemd"
HOMEPAGE = "https://systemd.io"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/systemd/systemd-sysv_257.13-1~deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/systemd/systemd-sysv_257.13-1~deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "ce9df137ccdd5d04d7c15e66fa53523d"
SRC_URI[deb0.sha1sum] = "c304bc6b5a2e5973212c31fba26eee3f5aa48996"
SRC_URI[deb0.sha256sum] = "3bed48042b6e40f8a3c439e79b4a4ed6a12102eb3ab66123dc43aa18f0416729"
SRC_URI[deb0.sha512sum] = "4d94f1f35447cb84b4a15512329776e1c3a2e69b5879269e5c265268743c92855e043de067a95c284f7e4d550f845b1c1c7450fa16a11a0f7c27b45d59a75e81"
SRC_URI[deb1.md5sum] = "b51f5b15c68dcc615d83492cc839ac00"
SRC_URI[deb1.sha1sum] = "7fc7d1967ab60582f4444630d59b338365525991"
SRC_URI[deb1.sha256sum] = "af3c883fabc97850c7afe9489a9e1808b4db2d9cfdc4dc1639da9e1b0356c97b"
SRC_URI[deb1.sha512sum] = "cb35e28a9ea89155010b3765382b99fb99f1ab49e5fd0d1034954c87441bd741c7c0b8e9a26fa94c842707a6df518095d55fdae2fee43f9957b85b97ce5ac5bf"

RDEPENDS = " \
    systemd \
"

