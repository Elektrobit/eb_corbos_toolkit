# This was autogenerated! Do not modify
SUMMARY = "system and service manager"
DESCRIPTION = ""
SECTION = "admin"
SOURCE_PACKAGE = "systemd"
HOMEPAGE = "https://systemd.io"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/systemd/systemd_257.13-1~deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/systemd/systemd_257.13-1~deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "ac7a446ab9400f597a25d1157c61d333"
SRC_URI[deb0.sha1sum] = "24970c2bee6b3392b3969e3e59e3ca5226fd7be0"
SRC_URI[deb0.sha256sum] = "ee81302a1d5b7434762b6e784a572854d4b6cf6235e33e2d104ad4e1cae71ab4"
SRC_URI[deb0.sha512sum] = "1afbf8d88bce1c16aa98f6d53a086a74cfa74f5e072668f9c17427874334cd42aecc7c7da46fec3fbdf653a4d143d72c6caf8c250eaf0fde74bb96b1896f0f19"
SRC_URI[deb1.md5sum] = "40442a42afffc12c3d63a30a15b6b413"
SRC_URI[deb1.sha1sum] = "d7b0a8e759f444d3b456b0baeba7887ae8d48c37"
SRC_URI[deb1.sha256sum] = "dcc3ba37f0488ecd513820035b4efc300e198849f5b6437a9bac9c2f307149ab"
SRC_URI[deb1.sha512sum] = "9dfdb1e5072d7a808d33ee757ba16df27513763bc84e537ea4de0cd00275e223b8c2f9a7cee8af3d4e6d1642c99a8206be8d0c2e498cf4fdfb946d126e6730ee"

RDEPENDS = " \
    libacl1 \
    libapparmor1 \
    libc6 \
    libmount1 \
    libpam0g \
    libseccomp2 \
    libselinux1 \
    libssl3t64 \
    libsystemd-shared \
    libsystemd0 \
    mount \
"

RPROVIDES = " \
    systemd-sysusers \
    systemd-tmpfiles \
"
