# This was autogenerated! Do not modify
SUMMARY = "common files for schroot"
DESCRIPTION = ""
SECTION = "admin"
SOURCE_PACKAGE = "schroot"
HOMEPAGE = "https://codeberg.org/shelter/reschroot"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/schroot/schroot-common_1.6.13-7_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "cf5de70ab7fd33ed5800e5629a9ee827"
SRC_URI[deb0.sha1sum] = "c20f48faa1b2e1671c70bf29d0866eb24784052c"
SRC_URI[deb0.sha256sum] = "d6587ad2968e83a9838c80b6cb328c2d41741616785794769b56f18f4e436646"
SRC_URI[deb0.sha512sum] = "e1ff2d8c7e11e059938f0f712cde4480e810cabdb9fe5a8887938d52d4b320502bbf451391e9d2c082b619dc36ebb45174514e1c3febb215ebcf0f88d16b2c89"


