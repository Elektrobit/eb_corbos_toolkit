# This was autogenerated! Do not modify
SUMMARY = "Execute commands in a chroot environment"
DESCRIPTION = ""
SECTION = "admin"
SOURCE_PACKAGE = "schroot"
HOMEPAGE = "https://codeberg.org/shelter/reschroot"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/schroot/schroot_1.6.13-7_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/schroot/schroot_1.6.13-7_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "c88a05d930d463ef77d3c78479000482"
SRC_URI[deb0.sha1sum] = "9f09e823b8d708ba0a25d6e120495cc9afddf89e"
SRC_URI[deb0.sha256sum] = "cbaa5dca557e322c39d34c6b955dba7065176c661eca12bc0e17aca5a6f201c7"
SRC_URI[deb0.sha512sum] = "04922387a706ceccd7185cfec6fb51637f8403f4811e29963f06c104b2a9ddfc350cadc1fb8be18f06b508f51e5078512db4bb8e279a27d3025089650114904d"
SRC_URI[deb1.md5sum] = "642dc56cc39b20d1c47d87bef77f4861"
SRC_URI[deb1.sha1sum] = "7339ba8844241a059bc77122185990f12d438516"
SRC_URI[deb1.sha256sum] = "a82a925cf4de2a047e9426c362f0590a602c0dbdefa79da3de54f5a15a483555"
SRC_URI[deb1.sha512sum] = "787569cd42003f64bfeb56e28904bcdeabc39cf2baad5fb235fb220624ee234b019fd24f7d0a7acf1e5ca93761db183cb6546d54e78d7c8485983a123473aa6c"

RDEPENDS = " \
    debconf \
    libboost-filesystem1.83.0 \
    libboost-iostreams1.83.0 \
    libboost-program-options1.83.0 \
    libc6 \
    libgcc-s1 \
    libpam0g \
    libstdc++6 \
    libuuid1 \
    schroot-common \
    sysvinit-utils \
"

