# This was autogenerated! Do not modify
SUMMARY = "process scheduling daemon"
DESCRIPTION = ""
SECTION = "admin"
SOURCE_PACKAGE = "cron"
HOMEPAGE = "https://ftp.isc.org/isc/cron/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/c/cron/cron_3.0pl1-197_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/c/cron/cron_3.0pl1-197_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "ca8ca3eaa6d8fad8566c70034a2e5109"
SRC_URI[deb0.sha1sum] = "f7ea1548691003f8fff1051cd096ffc8ac4baa33"
SRC_URI[deb0.sha256sum] = "32d7fc3e00dc504401c61682ac31c4a60068721b4e267e8439a04754af914c5b"
SRC_URI[deb0.sha512sum] = "aee272f278a9b9acdff3f4dff42631737a0c5103c7b0cb678cf272e26ba19c16d71b18b59bda1941a46ae7bafaf56177741a4fa24e36e51c2420c80075ef2c3f"
SRC_URI[deb1.md5sum] = "e81e429c4c21133c95e6090c5112ba39"
SRC_URI[deb1.sha1sum] = "12bf3a0e967c8ea317b6a9d713209030f9e3be12"
SRC_URI[deb1.sha256sum] = "bcaaebfbdaa7b265e6baa8ecd7e86040f2cddcce7fd882a36e172ff9b371bfc2"
SRC_URI[deb1.sha512sum] = "9de30febff22b643d061868cfb183f99aeb25f50800fcdbdb8f64673a228b03beb5b118adf63bf828aaedca7a7c37ed149f513c4339f2bed43ceb12f53f8f9f2"

RDEPENDS = " \
    cron-daemon-common \
    init-system-helpers \
    libc6 \
    libpam-runtime \
    libpam0g \
    libselinux1 \
    sensible-utils \
"

RPROVIDES = " \
    cron-daemon \
"
