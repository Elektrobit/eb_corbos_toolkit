# This was autogenerated! Do not modify
SUMMARY = "process scheduling daemon's configuration files"
DESCRIPTION = ""
SECTION = "admin"
SOURCE_PACKAGE = "cron"
HOMEPAGE = "https://ftp.isc.org/isc/cron/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/c/cron/cron-daemon-common_3.0pl1-197_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "6f461cf5807db6dc0663fa7e1dbcc557"
SRC_URI[deb0.sha1sum] = "9b7ed2e086ac4f26efda152fb7a0e0ef7ff44bd1"
SRC_URI[deb0.sha256sum] = "47f7f603a425ad97c1093ff9512328da0b8bfa1ab29c2cddc13f06eab45ed9a6"
SRC_URI[deb0.sha512sum] = "32897ab3e21b154e3e11d141622f3b2eaa8f3daa4408be30a0816f48bca95eedc3bb14d49ad849ab28fc50d129565a374a031bb5ab186724b3d8b235482e4882"

RDEPENDS = " \
    adduser \
    systemd \
"

