# This was autogenerated! Do not modify
SUMMARY = "tools for Security Enhanced Linux policy analysis"
DESCRIPTION = ""
SECTION = "admin"
SOURCE_PACKAGE = "setools"
HOMEPAGE = "https://github.com/SELinuxProject/setools/wiki"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/setools/setools_4.5.1-1.1+b1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/setools/setools_4.5.1-1.1+b1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "a8b1e59339e362ce855628bcfbd451a5"
SRC_URI[deb0.sha1sum] = "a11e000ff1bd8f97376086c135bcd8f8ab720364"
SRC_URI[deb0.sha256sum] = "dc06e7c9f9e0db4fed6e3b1e0010e9b46eb8c348d3dec371ef096fe2c035d439"
SRC_URI[deb0.sha512sum] = "6b7dfa2e309291cc6cc1462c8af28443e8ed97c4737965dec09400a4bf49517c8fd098dd47b376f998732ac74516f40bf8c019bfe6ce80b76eeb31cc8052787a"
SRC_URI[deb1.md5sum] = "4bbee517678ec4b16a6e0ed8d92918a6"
SRC_URI[deb1.sha1sum] = "38138bd0c3612cb48bfaa936cc3ce9c48f917b67"
SRC_URI[deb1.sha256sum] = "5c544b45e9cb33ad0b4aeb9bbf966a373b1902e4e3bc067a75f124b57af0e86b"
SRC_URI[deb1.sha512sum] = "6737e162ccf37b9819937245ce0f98973fb2cf778115cdbd914d31004df9be00932d410cc2e37334f02694dc49f4dd473a88f3e5427799d25762deb6cb4437bd"

RDEPENDS = " \
    python3 \
    python3-setools \
"

