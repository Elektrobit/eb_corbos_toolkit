# This was autogenerated! Do not modify
SUMMARY = "companion tools for Das U-Boot bootloader"
DESCRIPTION = ""
SECTION = "admin"
SOURCE_PACKAGE = "u-boot"
HOMEPAGE = "https://www.denx.de/wiki/U-Boot/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/u/u-boot/u-boot-tools_2025.01-3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/u/u-boot/u-boot-tools_2025.01-3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "2e2e77eeea8cc0e256d94b7b6588d5a8"
SRC_URI[deb0.sha1sum] = "7ce259314637169dac4928b549c7a474aee70af5"
SRC_URI[deb0.sha256sum] = "11c1ba6f45d1e056fdfeb8822962e115df76ad054da3269b46ccafcac7d81484"
SRC_URI[deb0.sha512sum] = "a0437160c543be8820736f9d05e192f710fc601e0b73ddfa1a010cee00d9de69790f43af3e0144d459519478efd41f8267fc17333befd394413cfbe50478d229"
SRC_URI[deb1.md5sum] = "5fea99bfdcb800c0ae7add6a7e7a96bf"
SRC_URI[deb1.sha1sum] = "f1da326523aa02d8f23d2d1a5176d76578141377"
SRC_URI[deb1.sha256sum] = "52f374dfbaa175f8d134cab562294c750db4edb9603b1c9abde5f6fec154946f"
SRC_URI[deb1.sha512sum] = "1405925f976459dccb2a4fe4513a9c2dd9fea437d4f58b5be264fd5b7568ec393c55d52f4d7843d1ca95ac07bb4d936ae5a1820bf20400d593651ea8974fe73d"

RDEPENDS = " \
    libc6 \
    libgnutls30t64 \
    libssl3t64 \
    libtinfo6 \
"

