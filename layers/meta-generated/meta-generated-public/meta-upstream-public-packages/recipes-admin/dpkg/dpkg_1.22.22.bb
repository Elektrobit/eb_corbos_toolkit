# This was autogenerated! Do not modify
SUMMARY = "Debian package management system"
DESCRIPTION = ""
SECTION = "admin"
SOURCE_PACKAGE = "dpkg"
HOMEPAGE = "https://wiki.debian.org/Teams/Dpkg"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/d/dpkg/dpkg_1.22.22_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/d/dpkg/dpkg_1.22.22_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "5f21fa24ba8ab8547bd70787875a7a2c"
SRC_URI[deb0.sha1sum] = "1e0baaf640e70d3e141e26863898eaee6e2b6e11"
SRC_URI[deb0.sha256sum] = "3e800c6d75e8e709007ed1c356e5fa8509a75c1694fb0a1183709abc9cfdc1f3"
SRC_URI[deb0.sha512sum] = "4d8dedbf31b5b598f74f82803269593735e980c5d35ffe8fe650fb1946fdd75d484003f153e7ba769e8ae2bb3f8fac478ac47ec96f7f965f889ea17124a7da54"
SRC_URI[deb1.md5sum] = "09b02099c61772a7d65133be22743b38"
SRC_URI[deb1.sha1sum] = "1b11e8d6ef6d4bc6112b0d8a099fd99716b5bd07"
SRC_URI[deb1.sha256sum] = "1142468e57f69e13d174f517dff739508c61ee97d81c182c120cd6b281d8cdfa"
SRC_URI[deb1.sha512sum] = "5736568f761e4b93a20bc373478757b32261e4a9b71c8562512e647a0055612bc47ce3d8e36b64b9a43a3878ee623a9b877ba9db1bae8c07a81dae3ce400d659"

RDEPENDS = " \
    libbz2-1.0 \
    libc6 \
    liblzma5 \
    libmd0 \
    libselinux1 \
    libzstd1 \
    tar \
    zlib1g \
"

