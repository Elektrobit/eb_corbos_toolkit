# This was autogenerated! Do not modify
SUMMARY = "utility for unprivileged chroot and namespace manipulation"
DESCRIPTION = ""
SECTION = "admin"
SOURCE_PACKAGE = "bubblewrap"
HOMEPAGE = "https://github.com/containers/bubblewrap"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/b/bubblewrap/bubblewrap_0.11.0-2+deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/b/bubblewrap/bubblewrap_0.11.0-2+deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "a34895fa65bb0d93d6d42553da01e490"
SRC_URI[deb0.sha1sum] = "817a2e6186906394f63696c2b289f0f19e45b8d3"
SRC_URI[deb0.sha256sum] = "7a541ad9d12b23db7082ed3bf1f6d5253f23439cdfa7c28b4e022d0a602a19d6"
SRC_URI[deb0.sha512sum] = "f98cac43fb6f88ff20566fd58086e6561189d879cebb0b11fe96d0f2f20917464d1ad8a663dcd4a1872bb2de01f048cbe56cf32607b6f5b0ddb00a3294a6fabd"
SRC_URI[deb1.md5sum] = "d6e0a575f91d3215954dc7ee531a47e9"
SRC_URI[deb1.sha1sum] = "ef2d83d8c40c740e00a7dde0ffffff41e5f855ee"
SRC_URI[deb1.sha256sum] = "c838daebddb7fe169ebb461612e90b1fcb981de838f81bfbecf26d45ab5a71ee"
SRC_URI[deb1.sha512sum] = "00facae9614901f91447ebfcb2fecf00901536886844a8b1f42e28cc41eaea3742c65ca0c92c043b9b26d74694b08cdf364109fcc436eb4a37b08185d37c6eb4"

RDEPENDS = " \
    libc6 \
    libcap2 \
    libselinux1 \
"

