# This was autogenerated! Do not modify
SUMMARY = "terminal multiplexer"
DESCRIPTION = ""
SECTION = "admin"
SOURCE_PACKAGE = "tmux"
HOMEPAGE = "https://github.com/tmux/tmux/wiki"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/t/tmux/tmux_3.5a-3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/t/tmux/tmux_3.5a-3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "dca7474f7db527f847840aed09869549"
SRC_URI[deb0.sha1sum] = "d60809fd0c8cba4d409910028853b671ed8aadaf"
SRC_URI[deb0.sha256sum] = "e6b6aa51780044e2c4a0e618c33f832b70ec80caa30303e6c254a0c851b5af78"
SRC_URI[deb0.sha512sum] = "3919db7cb0248e63094d4f612087850c8b46c2adae4191670470bac5b32706b562ac358c7653803841fc527bb2a8eaabb2682fdbd50ff51334fde6d95d4bec4a"
SRC_URI[deb1.md5sum] = "5dcd2e42e3bf725bcae32831515d82e3"
SRC_URI[deb1.sha1sum] = "c8426ec3b368e9887c58e4cc3497edb9497ebd99"
SRC_URI[deb1.sha256sum] = "835d23b320f5d0457f7a695d90d1c5cca5c2b4a6481fa28b06ad14b18dcabff2"
SRC_URI[deb1.sha512sum] = "7cfc5240dea764b9f6ba66bf9742573b501b60a9b0e8730fe05b50b89758b06e502ed1fc3c3b49b319a645b5a2e28d523154effa86d6880baa9fda185f9df81d"

RDEPENDS = " \
    libc6 \
    libevent-core-2.1-7t64 \
    libjemalloc2 \
    libsystemd0 \
    libtinfo6 \
"

