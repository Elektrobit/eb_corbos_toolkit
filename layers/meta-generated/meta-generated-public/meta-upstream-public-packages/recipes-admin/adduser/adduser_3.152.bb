# This was autogenerated! Do not modify
SUMMARY = "add and remove users and groups"
DESCRIPTION = ""
SECTION = "admin"
SOURCE_PACKAGE = "adduser"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/a/adduser/adduser_3.152_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "3e2aa9bed1bdede835f08a225c5de673"
SRC_URI[deb0.sha1sum] = "4381d3865d7422032b5acc9a59003ef39e59d09d"
SRC_URI[deb0.sha256sum] = "e50984d2e1ef6300e3fd51303839842189a077b10cb5cadff1923df10c61c493"
SRC_URI[deb0.sha512sum] = "a95aac8d22804a239675c3bfd86dd9321125aafe08ce898cfc9b41186d711156b27adc4854344ffc9cd52635d184c33295490346966843d36ac9a204e438bb41"

RDEPENDS = " \
    passwd \
"

