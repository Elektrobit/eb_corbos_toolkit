# This was autogenerated! Do not modify
SUMMARY = "dh-runit implementation detail"
DESCRIPTION = ""
SECTION = "admin"
SOURCE_PACKAGE = "dh-runit"
HOMEPAGE = "https://salsa.debian.org/debian/dh-runit"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/d/dh-runit/runit-helper_2.16.4_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "361e38e86ce834775f4984edd7c42683"
SRC_URI[deb0.sha1sum] = "e59a508f2c1a11ec173668063f37e3c96016f556"
SRC_URI[deb0.sha256sum] = "8a5866d3036a1645a1cff2bfe7dcf5b62e8d2c30ec31a115d4ccd2486645a54e"
SRC_URI[deb0.sha512sum] = "fce3297fa2cb466caf1154380182bb4a51d2ad494eb547bd79d5d36c008f4fa1cc54480badc67e24ff7a9756b8171adf233b8373c2bfc6d1b258646771919df3"


