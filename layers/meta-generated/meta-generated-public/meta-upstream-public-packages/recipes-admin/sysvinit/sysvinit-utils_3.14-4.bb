# This was autogenerated! Do not modify
SUMMARY = "System-V-like utilities"
DESCRIPTION = ""
SECTION = "admin"
SOURCE_PACKAGE = "sysvinit"
HOMEPAGE = "https://github.com/slicer69/sysvinit"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/sysvinit/sysvinit-utils_3.14-4_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/sysvinit/sysvinit-utils_3.14-4_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "baa84f8a70f457b6611ef0c4b43ae89c"
SRC_URI[deb0.sha1sum] = "7af2404a70d975b8a0e61f41808855df52416820"
SRC_URI[deb0.sha256sum] = "c7e957360dff89675b491e501b00047cf750695178cabab167c92fc260d358ec"
SRC_URI[deb0.sha512sum] = "fdafe5934eef1c9becbd06d590f2dfd187eb9f068021eab635884e94f3041beaa3ef5f5b30a6935bae0530d45ffb24e8c6761e3db314cef9c4b04e0d8a313ecb"
SRC_URI[deb1.md5sum] = "150b8128ffe277ab81250b2cb64d5f6f"
SRC_URI[deb1.sha1sum] = "16ef55170608b2180548b0499b86e9e9f62fe65f"
SRC_URI[deb1.sha256sum] = "1366e87a382a6b95a0a7c507b8f1be9b193f772f3428f9f7e0271a217915cfae"
SRC_URI[deb1.sha512sum] = "fed38ef6f0b151b4f9e0f27d7c5dc208b39728104f2fd2de1206c7e744d1994b981e5082dcf9026c684b66f1bebaf560d4dcafc48ff1cc5ed871bdcea08a0a98"

RDEPENDS = " \
    libc6 \
"

RPROVIDES = " \
    lsb-base \
"
