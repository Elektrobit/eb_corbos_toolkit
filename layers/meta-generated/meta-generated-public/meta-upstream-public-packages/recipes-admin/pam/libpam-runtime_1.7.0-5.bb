# This was autogenerated! Do not modify
SUMMARY = "Runtime support for the PAM library"
DESCRIPTION = ""
SECTION = "admin"
SOURCE_PACKAGE = "pam"
HOMEPAGE = "http://www.linux-pam.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/pam/libpam-runtime_1.7.0-5_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "33352d4b91bffa6bf074b837862f8029"
SRC_URI[deb0.sha1sum] = "14bae5b5fd64a19b3fb77c220fd58d2dee519dc3"
SRC_URI[deb0.sha256sum] = "b02792c9ed6174db695a653b95ef3629fdac3a73ba1eff1754ab161b5711bfbf"
SRC_URI[deb0.sha512sum] = "d6d932b9e430b46255f326a9a7b31ecc2815e00ce1020d704bb09947d71ef9ee0846ce3c9b111983d5449cbc0ce58c5a7fbce950229fc62ebe41029304300fcf"

RDEPENDS = " \
    debconf \
    libpam-modules \
"

