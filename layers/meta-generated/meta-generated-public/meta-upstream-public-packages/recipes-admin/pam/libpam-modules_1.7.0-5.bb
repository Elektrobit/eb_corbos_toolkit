# This was autogenerated! Do not modify
SUMMARY = "Pluggable Authentication Modules for PAM"
DESCRIPTION = ""
SECTION = "admin"
SOURCE_PACKAGE = "pam"
HOMEPAGE = "http://www.linux-pam.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/pam/libpam-modules_1.7.0-5_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/pam/libpam-modules_1.7.0-5_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "e23fe049a9c98324298ccc072ef40372"
SRC_URI[deb0.sha1sum] = "5975b79ea553d14acd81c477220c3bef32d93620"
SRC_URI[deb0.sha256sum] = "9679ade117f8775ac0471f48a92652ab8e8dcda4e2ff06de75158cded9cfd83c"
SRC_URI[deb0.sha512sum] = "e82c1585632dfd0e355eba7d0d5deb8c46e33b2a8ad08f749da27e27719fecd03cedc5a129e8e9d45214d07417629a6e486831a374f67ea4d74601061925dd59"
SRC_URI[deb1.md5sum] = "cd3be4eb5319bbdb9c7096e647371887"
SRC_URI[deb1.sha1sum] = "ad5a9e3fb4c7ed8105204ee78d9ed1111dd52726"
SRC_URI[deb1.sha256sum] = "3c6c4b0be396f2a90d150effd480e06674d7d22739fe4c54ffbf95587fe2bcf4"
SRC_URI[deb1.sha512sum] = "d1789b0ad89849ac3bb7e93d6d198da0c8389332b22005f3d2448ac7828223d88601e9f8a8ca4693ec7154373d169eadfe0f898c9b5bf58398616dc88cb845bd"

RDEPENDS = " \
    debconf \
    libaudit1 \
    libc6 \
    libcrypt1 \
    libdb5.3t64 \
    libpam-modules-bin \
    libpam0g \
    libselinux1 \
    libsystemd0 \
"

RPROVIDES = " \
    libpam-mkhomedir \
    libpam-motd \
    libpam-umask \
"
