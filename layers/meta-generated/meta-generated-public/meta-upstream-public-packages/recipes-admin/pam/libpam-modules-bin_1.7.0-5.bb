# This was autogenerated! Do not modify
SUMMARY = "Pluggable Authentication Modules for PAM - helper binaries"
DESCRIPTION = ""
SECTION = "admin"
SOURCE_PACKAGE = "pam"
HOMEPAGE = "http://www.linux-pam.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/pam/libpam-modules-bin_1.7.0-5_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/pam/libpam-modules-bin_1.7.0-5_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "a6c7ea0cf7c66828445774c7c3c7ccc8"
SRC_URI[deb0.sha1sum] = "ebc3c6714ae37f732db326e26bf889fccc6f4434"
SRC_URI[deb0.sha256sum] = "cc72066d008444317738e8e931d6131b301466b4e2dd5ef5baa75fb1a45d61a7"
SRC_URI[deb0.sha512sum] = "796bf14b6eec13e94b05e94e975b63230295d3eff7a50ab0b3caa1344c8d52a1b4da2dd3c48775ddbe028e9e9808e509877debdcec71ca7f96370b493968cc49"
SRC_URI[deb1.md5sum] = "8048f3eebfb6abff174959ab5ca5d668"
SRC_URI[deb1.sha1sum] = "be796b48cd2d9fe73a2c881ee944bf12b3c072de"
SRC_URI[deb1.sha256sum] = "8c50ad191934474b5177cba48aed2c4023ec8392ef7096808311315c50b3bfec"
SRC_URI[deb1.sha512sum] = "5ecc291083e005849b905cb374f817a9bbc71f5c448ca30d0261c8467801ef831317b7139d47c667bdcf826952121ebf68663fb2d40ac954af72ed7e218e9a9c"

RDEPENDS = " \
    libaudit1 \
    libc6 \
    libcrypt1 \
    libpam0g \
    libselinux1 \
    libsystemd0 \
"

