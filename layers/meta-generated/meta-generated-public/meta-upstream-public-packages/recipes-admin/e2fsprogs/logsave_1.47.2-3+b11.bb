# This was autogenerated! Do not modify
SUMMARY = "save the output of a command in a log file"
DESCRIPTION = ""
SECTION = "admin"
SOURCE_PACKAGE = "e2fsprogs"
HOMEPAGE = "http://e2fsprogs.sourceforge.net"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/e/e2fsprogs/logsave_1.47.2-3+b11_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/e/e2fsprogs/logsave_1.47.2-3+b11_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "50de517117b328185bb28e8694a5c498"
SRC_URI[deb0.sha1sum] = "14135ee0e19ea4e402a2371325949407e87ecbb1"
SRC_URI[deb0.sha256sum] = "0dd470e53e65eb4307a8911f632d180000ec4380cb4109bddc0ee66ae385fc24"
SRC_URI[deb0.sha512sum] = "b9969fb8d1ff4c21e49d0c2df2c08bf17aafafa2e9857b55bd7f52b7e146ca24042f22c2a4dd09a5f5a474b1a047994fb680d26c82a4fef232b723ab3b8832b4"
SRC_URI[deb1.md5sum] = "98e16bc188249fde6f16443fb3455c61"
SRC_URI[deb1.sha1sum] = "826765a7ccf3f62368691ea5c4f59af7dd2dcead"
SRC_URI[deb1.sha256sum] = "26bc538fb6b9279c99a5f83fb81e770c3df841ea8de1db64c7da0320536c6f94"
SRC_URI[deb1.sha512sum] = "e823b2c254079ff88add4b210aa517069d443a80f5d5323af12cec2313eebec7ec5eded540bc027c3d2c02c03324b0ec4c4bd138d59de6cf3fd52f6900176ede"

RDEPENDS = " \
    libc6 \
"

