# This was autogenerated! Do not modify
SUMMARY = "ext2/ext3/ext4 file system utilities"
DESCRIPTION = ""
SECTION = "admin"
SOURCE_PACKAGE = "e2fsprogs"
HOMEPAGE = "http://e2fsprogs.sourceforge.net"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/e/e2fsprogs/e2fsprogs_1.47.2-3+b11_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/e/e2fsprogs/e2fsprogs_1.47.2-3+b11_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "cc3a49e8633b1edbb2f5a7980e3a18d5"
SRC_URI[deb0.sha1sum] = "670bef7c979a4ab76dbc4890a8131771f26289ba"
SRC_URI[deb0.sha256sum] = "ed9400fa9364b6e771ce13c4f7eb71cdc2432c2e2dbde8ca57c9e6bece93112b"
SRC_URI[deb0.sha512sum] = "b716458f5724ac460c96675a2f1a62394babe31955f43c29757291cd2403b700bc6e43318d61cfbf116166b35d4952237f98ae42cd3ff0ee68f437bf579b656e"
SRC_URI[deb1.md5sum] = "eab0e75cf8f866d995cf65c7d112eeda"
SRC_URI[deb1.sha1sum] = "8eece1923da6e9fa7b1faa7edeb9250ce412041c"
SRC_URI[deb1.sha256sum] = "dac7d1325b25ec13df9878a62ec9db2b2c490e8f31166a01a3c736f16bded428"
SRC_URI[deb1.sha512sum] = "6687076bd762dd1969a5a7ba4768dcca3a095e80cdc64b3a8c79eb724ae7dddc7dc1084f9f2de52c6e4dab4d76cc560abc87fb90f57974a1df0a2949ad122f45"

RDEPENDS = " \
    libblkid1 \
    libc6 \
    libcom-err2 \
    libext2fs2t64 \
    libss2 \
    libuuid1 \
    logsave \
"

