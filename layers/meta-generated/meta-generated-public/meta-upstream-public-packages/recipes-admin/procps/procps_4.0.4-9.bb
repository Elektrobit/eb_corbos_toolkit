# This was autogenerated! Do not modify
SUMMARY = "/proc file system utilities"
DESCRIPTION = ""
SECTION = "admin"
SOURCE_PACKAGE = "procps"
HOMEPAGE = "https://gitlab.com/procps-ng/procps"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/procps/procps_4.0.4-9_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/procps/procps_4.0.4-9_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "7171002cf30cd38ddcd985332786d2e2"
SRC_URI[deb0.sha1sum] = "cdbd731553617765ebc9c3caecd0d8b730c692f6"
SRC_URI[deb0.sha256sum] = "4db90bb6776772fc52585d6b1fbfc52ec2a85480e1b4363b743fbb2ffa2a5375"
SRC_URI[deb0.sha512sum] = "f2379746a61b5cb18315bbd2228f760bc2a885947f9e62ed10b75a236a989856514854d15ea15ead572b2c29830aab3b7599135b194e850ef0922e0ce5acf11d"
SRC_URI[deb1.md5sum] = "3e4fc385787b0a551600ee298aaa2d83"
SRC_URI[deb1.sha1sum] = "ce79c63f3a205b6172dcde8625ea44b04ba9ec7f"
SRC_URI[deb1.sha256sum] = "9afd4ad2e8da92322715114fb9555c63ce92f6c72bf72867e76ab2d6a7a3b541"
SRC_URI[deb1.sha512sum] = "86003ea6030eb2a246ff9a6d2a68b86b62df5ad55219f9e8bf71289956ca208711c2616394915b89d89477938c75112d075cfd87fff21050dfcbc47e972163ff"

RDEPENDS = " \
    init-system-helpers \
    libc6 \
    libncursesw6 \
    libproc2-0 \
    libsystemd0 \
    libtinfo6 \
"

RPROVIDES = " \
    watch \
"
