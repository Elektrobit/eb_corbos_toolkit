# This was autogenerated! Do not modify
SUMMARY = "lightweight OCI runtime for running containers"
DESCRIPTION = ""
SECTION = "admin"
SOURCE_PACKAGE = "crun"
HOMEPAGE = "https://github.com/containers/crun"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/c/crun/crun_1.21-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/c/crun/crun_1.21-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "44599e2013b8e5fe046fe2848f8494bc"
SRC_URI[deb0.sha1sum] = "9ca1e41d353e716516c251b35977a6260d7fb8b7"
SRC_URI[deb0.sha256sum] = "f94f8d4acf08a304884666d67d9faa797ab8401b46c311827783a432cb15b652"
SRC_URI[deb0.sha512sum] = "e79d5c24a036daec1eade4cdaca833eea2e5df10bef9761f7d5cf72607957dfffb91521342acf244c7614132fb6891e247beca432b7560c0d222954ee620a171"
SRC_URI[deb1.md5sum] = "0c51e9d3486c0dd1496b620d994dc71a"
SRC_URI[deb1.sha1sum] = "e84cd65c974547ad4712c51f4d3112055bec1701"
SRC_URI[deb1.sha256sum] = "f1f102167176d0ae3a68370cb016e1793c40c69b8966da74abe39fa8655929a3"
SRC_URI[deb1.sha512sum] = "b5fefcb1ab28f89808fbda319403b5b843f1ced5dcb6c0b00be6eda18386513467136b4a2f39508763fa044184c9fbb5f3f67b8963f8897b2d09e331f1d04ec6"

RDEPENDS = " \
    libc6 \
    libcap2 \
    libseccomp2 \
    libsystemd0 \
    libyajl2 \
"

