# This was autogenerated! Do not modify
SUMMARY = "Debian base system miscellaneous files"
DESCRIPTION = ""
SECTION = "admin"
SOURCE_PACKAGE = "base-files"
HOMEPAGE = ""

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/b/base-files/base-files_13.8+deb13u6_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/b/base-files/base-files_13.8+deb13u6_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "6bcd452e8aca5ea70fea75cea1f8dd96"
SRC_URI[deb0.sha1sum] = "51de90f3b511211179f9012a2f6bc221441d48e5"
SRC_URI[deb0.sha256sum] = "c4bb697554ef3e6588b38ffb73e27a22698c2b9525b1c7223b06d42d155e63fa"
SRC_URI[deb0.sha512sum] = "fa0f7d3639c787ae01611fd523f24c0f78794f5a5787395c494725bb29a38f906f25b7fb247e3733388fbff5e3e362635ffb850595918cd24a0b9edf3036ca0b"
SRC_URI[deb1.md5sum] = "368a48d4de9186911eeaa1d8453b0cff"
SRC_URI[deb1.sha1sum] = "dd8f59e915626abef50262eed3fc1bb7f3f6aedf"
SRC_URI[deb1.sha256sum] = "5f5a571ec846d7db05d9f825f0388a37bc033267b33cbf85b4eaa838dffcc41b"
SRC_URI[deb1.sha512sum] = "a9015df1afd0d63dc1cac07e5751de012ffc1bc2679f86406667062faf8d1f87e90b1e1a07f9cca2cc202ddbe0034e000255f0037084a01f45302d722c802583"

RDEPENDS = " \
    awk \
"

RPROVIDES = " \
    base \
    usr-is-merged \
"
