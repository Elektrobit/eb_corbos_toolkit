# This was autogenerated! Do not modify
SUMMARY = "Provide limited super user privileges to specific users"
DESCRIPTION = ""
SECTION = "admin"
SOURCE_PACKAGE = "sudo"
HOMEPAGE = "https://www.sudo.ws/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/sudo/sudo_1.9.16p2-3+deb13u2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/sudo/sudo_1.9.16p2-3+deb13u2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "082ec1f0212895c744b3a77521228471"
SRC_URI[deb0.sha1sum] = "578aedf738e7a243381a1c33871c48a5a1ca3136"
SRC_URI[deb0.sha256sum] = "4f926f8f0704575158a90135713977f98f7d50d185969d9a8a405cdce5e3e50c"
SRC_URI[deb0.sha512sum] = "b73a15dc646b7f9de6fefefea0f909c94f6863ad8a452a2b39c2dac3b2ff1d901ebf66c18fbe10228ee6c605374f8ee640b7c1f57fb251c46a63cb8c6873c376"
SRC_URI[deb1.md5sum] = "d3e14522afb0b98e3281a09d52a97029"
SRC_URI[deb1.sha1sum] = "0aeda216d93ac5e8b0b72da80eb0c5d3569cdd61"
SRC_URI[deb1.sha256sum] = "907d333f72f3369b2ceda64dbcfccf0dc515543b76ac68d5c901e309f118709b"
SRC_URI[deb1.sha512sum] = "73cb9fef9cc2cca86d1f8d59507f77ffd1d280f939ecce37035ae6efca4aa0cd3e3819588ad86aa4fb1369de8717eb60d747fffd0db7a3065d4735ee295fbe19"

RDEPENDS = " \
    init-system-helpers \
    libapparmor1 \
    libaudit1 \
    libc6 \
    libpam-modules \
    libpam0g \
    libselinux1 \
    libssl3t64 \
    zlib1g \
"

