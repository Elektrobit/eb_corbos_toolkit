# This was autogenerated! Do not modify
SUMMARY = "Debian configuration management system"
DESCRIPTION = ""
SECTION = "admin"
SOURCE_PACKAGE = "debconf"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/d/debconf/debconf_1.5.91_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "19f464db8fc065dfbca92198ee28f058"
SRC_URI[deb0.sha1sum] = "d1922ab37a3b1d767c0176cd192b3540359ee444"
SRC_URI[deb0.sha256sum] = "1ddc7e6c5925f748eefb7ca811d98e049f18c158bb21fbc7e122262ce6011e49"
SRC_URI[deb0.sha512sum] = "9d24db8201c080e48fa45e4008305a8f7a97e1d65be5dcfd9680ee9306237ad0b62dfe663918235771116c239655b774b434cf2f0b677d0af7d36fd521454d3d"


RPROVIDES = " \
    debconf-2.0 \
"
