# This was autogenerated! Do not modify
SUMMARY = "GPT fdisk text-mode partitioning tool"
DESCRIPTION = ""
SECTION = "admin"
SOURCE_PACKAGE = "gdisk"
HOMEPAGE = "http://sourceforge.net/projects/gptfdisk/"

inherit dpkg-prebuilt

DPKG_ARCH = "amd64"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gdisk/gdisk_1.0.10-2_amd64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "ff37d74275e568d059ef5dbce0f7d039"
SRC_URI[deb0.sha1sum] = "9926ba7f338220f1990afb67f516b24b6c857cf2"
SRC_URI[deb0.sha256sum] = "a64944b38e8477bf23b9a0ffb6fc653c8847facb1f851864b1a5c40a931456d2"
SRC_URI[deb0.sha512sum] = "b8c326c2a478d9afb8a6ade1fa0e5207e4329dce95b4480941c12baee453a23415f52f47ecf0bea5b04263053fa8105fd7ff586af6ea2456368e4b42f54f9eec"

RDEPENDS = " \
    libc6 \
    libgcc-s1 \
    libncursesw6 \
    libpopt0 \
    libstdc++6 \
    libtinfo6 \
    libuuid1 \
"

