# This was autogenerated! Do not modify
SUMMARY = "GPT fdisk text-mode partitioning tool"
DESCRIPTION = ""
SECTION = "admin"
SOURCE_PACKAGE = "gdisk"
HOMEPAGE = "http://sourceforge.net/projects/gptfdisk/"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gdisk/gdisk_1.0.10-2+b1_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "4f34c0aa5a6747c02a7bb7374e333806"
SRC_URI[deb0.sha1sum] = "4f6c89353ad99455b896252f89d8186bba325bd6"
SRC_URI[deb0.sha256sum] = "b6b48390e63bff9d18b32be3270910fab83f8c14117d49ada13cba8a2a75c7e9"
SRC_URI[deb0.sha512sum] = "0495d3274f5a8fbae08bdaf71447554d7b8c66afc8e54c8c0a81bbf72ded255a12434b1ffba0baf580ed44c0dccdf050d310d1622b95d25c48dbc9039172c8b4"

RDEPENDS = " \
    libc6 \
    libgcc-s1 \
    libncursesw6 \
    libpopt0 \
    libstdc++6 \
    libtinfo6 \
    libuuid1 \
"

