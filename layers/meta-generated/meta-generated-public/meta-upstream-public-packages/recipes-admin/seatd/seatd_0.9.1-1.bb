# This was autogenerated! Do not modify
SUMMARY = "minimal user, seat and session management daemon"
DESCRIPTION = ""
SECTION = "admin"
SOURCE_PACKAGE = "seatd"
HOMEPAGE = "https://sr.ht/~kennylevinsen/seatd/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/seatd/seatd_0.9.1-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/seatd/seatd_0.9.1-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "5f70df5577aeb86a43e20b8e253af1df"
SRC_URI[deb0.sha1sum] = "5acbbfeeb402bf8611cb0547378b1a75b57c0adb"
SRC_URI[deb0.sha256sum] = "f2f36d7660ca281c1e2603c21f6f87acc0990149017a49777d222cdca9a4a3c6"
SRC_URI[deb0.sha512sum] = "9c8a97fdd9110d42e79b5e46ebcac4a2d0e710faca49d647c660393446e6e3f61d3fea416d6ee2173c4d83ebf43997ba647d724cb88d6ac9f075de14c62f274e"
SRC_URI[deb1.md5sum] = "4cec14835fa69df7404ce1e70537a729"
SRC_URI[deb1.sha1sum] = "6ba9307848b3d2234c5a534c112d5f16946c6e3b"
SRC_URI[deb1.sha256sum] = "95c93e9de7701254f8b116607db7520cd3380065cbebf5561b3ec364d2d17e1e"
SRC_URI[deb1.sha512sum] = "d39d424af7581cf8b618ae3641448c4a174f87938327006b0664b1180e3ae6d985fb62ebfd3c31e64b58240c3cb82dff1ddbc92f695ede13772def9f827d6662"

RDEPENDS = " \
    debconf \
    init-system-helpers \
    libc6 \
"

