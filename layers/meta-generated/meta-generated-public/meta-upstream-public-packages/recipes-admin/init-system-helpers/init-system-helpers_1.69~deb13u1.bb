# This was autogenerated! Do not modify
SUMMARY = "helper tools for all init systems"
DESCRIPTION = ""
SECTION = "admin"
SOURCE_PACKAGE = "init-system-helpers"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/i/init-system-helpers/init-system-helpers_1.69~deb13u1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "48f451739effa45774b7b78d51671fdb"
SRC_URI[deb0.sha1sum] = "01f445c5ba4bc769417f8ee0797d8a8259054fb3"
SRC_URI[deb0.sha256sum] = "addf78073e1cbc5a5508937e11d2571055e29835e00ee8fab52a66775649378f"
SRC_URI[deb0.sha512sum] = "c1f35ca8662b742ccdae6f0b483d539ddb635e7296f4e59c5e0679a4040cda04fc628205f27ec2fb8f875ce18b27deccac711e9fc83912e24f9d66b715bc75a2"


