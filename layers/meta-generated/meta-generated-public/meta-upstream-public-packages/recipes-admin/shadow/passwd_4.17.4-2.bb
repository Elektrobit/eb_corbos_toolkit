# This was autogenerated! Do not modify
SUMMARY = "change and administer password and group data"
DESCRIPTION = ""
SECTION = "admin"
SOURCE_PACKAGE = "shadow"
HOMEPAGE = "https://github.com/shadow-maint/shadow"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/shadow/passwd_4.17.4-2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/shadow/passwd_4.17.4-2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "cfb91ab621da2c62be2037755574af9b"
SRC_URI[deb0.sha1sum] = "0e040dd70f063e7f5d87cf635a5d27bbf30cb772"
SRC_URI[deb0.sha256sum] = "c5eaef41c6947d2888fa3462f787a7e02158b997bd0119154283f425ba57b8b8"
SRC_URI[deb0.sha512sum] = "779c6b49f372f0deafb7afbd7246e9b572355bafbf0d0327e682ea58990fc83cc69de2e150243bbbf5e5f57ef112f7ca30535acb941724613dafde030c646e23"
SRC_URI[deb1.md5sum] = "1d1b39b6716f5a1b5cf6dff903dd2cfb"
SRC_URI[deb1.sha1sum] = "59d9c6dbe0be096834f49828d4d8377a62627493"
SRC_URI[deb1.sha256sum] = "a6863055a3d53bf805dd0048b836e4b7a3d14a899b832a50d577b047da4202d8"
SRC_URI[deb1.sha512sum] = "68720fdb48fffc390db08ea1389db1c6c1fb944ae3e1e943eb853a2b32009b9c9852b322afddb2559d7c1d68a5efe0c4a8de286a0558b1f83d441e68e4cbecfc"

RDEPENDS = " \
    base-passwd \
    libacl1 \
    libattr1 \
    libaudit1 \
    libbsd0 \
    libc6 \
    libcrypt1 \
    libpam-modules \
    libpam0g \
    libselinux1 \
    libsemanage2 \
    login.defs \
"

