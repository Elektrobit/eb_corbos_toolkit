# This was autogenerated! Do not modify
SUMMARY = "system user management configuration"
DESCRIPTION = ""
SECTION = "admin"
SOURCE_PACKAGE = "shadow"
HOMEPAGE = "https://github.com/shadow-maint/shadow"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/shadow/login.defs_4.17.4-2_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "b6eb2480a7da34d774e68f6223f275ac"
SRC_URI[deb0.sha1sum] = "d9b0f1f20373b50fc6a022c45956c9abfbc3ec49"
SRC_URI[deb0.sha256sum] = "b4bbb8242cbf5588de7aafeb9d578a3dee1db2891f444ab454fd30bd80ccf2b4"
SRC_URI[deb0.sha512sum] = "7649b2aa66065a2db9ad0ac608aebc422fcf287510a880292c237d3ebd88d50038f4a2ac032f1b9a6d2a2778d710599d975a4587774199f7282b2cfbb13193a8"


