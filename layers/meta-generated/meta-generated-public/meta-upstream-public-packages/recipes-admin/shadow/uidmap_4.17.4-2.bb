# This was autogenerated! Do not modify
SUMMARY = "programs to help use subuids"
DESCRIPTION = ""
SECTION = "admin"
SOURCE_PACKAGE = "shadow"
HOMEPAGE = "https://github.com/shadow-maint/shadow"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/shadow/uidmap_4.17.4-2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/shadow/uidmap_4.17.4-2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "c1e621da753f035f4fe41cc3433cff8e"
SRC_URI[deb0.sha1sum] = "b951d2916e49ae82218bbf0bd7e93d4c49e5d48d"
SRC_URI[deb0.sha256sum] = "a017182d42a32ca241cd830a59153488e1f65ae6e31a760014575878044a9d2d"
SRC_URI[deb0.sha512sum] = "de6c9955f8081baa233fcb84de353caf2748ac02f13f6cbc83a83a9627a7fc00df788ee04264f3af218c4fffb24945f147a5eb2a0a2ef1053d7d70b8d8d0dac9"
SRC_URI[deb1.md5sum] = "aacda1521fd3100ddbb9273ec6bea129"
SRC_URI[deb1.sha1sum] = "0a878c64e0540ab0d28cf4f9a667fc79ba6a8749"
SRC_URI[deb1.sha256sum] = "e06aab52f0586f6f0fabf1ab1b4f946e18796d1cea837201f11346a25dc3ce3c"
SRC_URI[deb1.sha512sum] = "c8bd5b34b1bd9d72966f3906cd6753c20e4c07e60016ffe6339850e154cf2a44e90b819ace5b155d84babb4b869374e3267f4f1bb359901b5d6c61303df13af4"

RDEPENDS = " \
    libaudit1 \
    libbsd0 \
    libc6 \
    libselinux1 \
    libsubid5 \
"

