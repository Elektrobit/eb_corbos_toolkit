# This was autogenerated! Do not modify
SUMMARY = "Support for extra binary formats"
DESCRIPTION = ""
SECTION = "admin"
SOURCE_PACKAGE = "binfmt-support"
HOMEPAGE = "https://nongnu.org/binfmt-support/"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/b/binfmt-support/binfmt-support_2.2.2-7+b1_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "82ab4d87c1b205d1af82a9e509ab3f3b"
SRC_URI[deb0.sha1sum] = "65ef39f338bbbd2f71c98feb8d0f06ae4ceb41c0"
SRC_URI[deb0.sha256sum] = "25315b70f30c153b13f7cadb3e48424c4595fb4604f7e61b9d707c3ed32097d4"
SRC_URI[deb0.sha512sum] = "8877e68e8e8649fb82c42802c95cd32c105c12272d2fc39e1c6d1bf04e47acca5318aa67a65d08140cfacc2781fe844074e0b18dec5fdebb3a99632e17196a76"

RDEPENDS = " \
    init-system-helpers \
    libc6 \
    libpipeline1 \
"

