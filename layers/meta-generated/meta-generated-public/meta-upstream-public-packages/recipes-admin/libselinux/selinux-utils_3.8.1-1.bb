# This was autogenerated! Do not modify
SUMMARY = "SELinux utility programs"
DESCRIPTION = ""
SECTION = "admin"
SOURCE_PACKAGE = "libselinux"
HOMEPAGE = "https://github.com/SELinuxProject"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libs/libselinux/selinux-utils_3.8.1-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libs/libselinux/selinux-utils_3.8.1-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "bf45b66766d2647b56ccac42167e4a90"
SRC_URI[deb0.sha1sum] = "c4fae537d59c25837a3a9e594fe71bd47907d7f2"
SRC_URI[deb0.sha256sum] = "91639acf5dfe246637a088581ebc6a77b347f587472886f126a16727fc2f0e4f"
SRC_URI[deb0.sha512sum] = "cd34b77fb210fc0447df5a8a3234ad792571c5c671e38b71993e5325ec7f65c086dfe26bec11826b14d4ca14d24d74d9b24538bfdb0b20301bfe4828c0b51b0b"
SRC_URI[deb1.md5sum] = "9dc6654a9eea12582f7e039f13c05cff"
SRC_URI[deb1.sha1sum] = "50e8bc4dd83911d1d323638e7f50c037337d1dc5"
SRC_URI[deb1.sha256sum] = "1a68c18f7f7ddf21f8544369f289b9b9191b230dfd41545d0d404032b07fcd11"
SRC_URI[deb1.sha512sum] = "389b1af3c0a19f35e28118a0eb6eb15240f0890b56d9bcb87f7994dde3b73ee293613486b83c784b3830e3214b801f141e25ba8c691b70d53a36ee67f8da56e3"

RDEPENDS = " \
    libc6 \
    libpcre2-8-0 \
    libselinux1 \
    libsepol2 \
"

