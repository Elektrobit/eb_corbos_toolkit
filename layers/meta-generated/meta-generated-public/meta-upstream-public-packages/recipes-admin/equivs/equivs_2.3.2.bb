# This was autogenerated! Do not modify
SUMMARY = "Circumvent Debian package dependencies"
DESCRIPTION = ""
SECTION = "admin"
SOURCE_PACKAGE = "equivs"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/e/equivs/equivs_2.3.2_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "24f1bf6420281689ad8b807eb5f1e021"
SRC_URI[deb0.sha1sum] = "ac7d5fae32ca729979aa9527663be44b3854a3ef"
SRC_URI[deb0.sha256sum] = "1279c59d5adac26c460f1010c7e4b94ba7b40ed3169f00ad97bca9f460b86eb3"
SRC_URI[deb0.sha512sum] = "561d07b2f9a85fe981ab525eb7831eafdf76e9cd7e5c704c9a371fa37076f8340225169aba8dfe86569d373e3e0d5118923e4572b6aaf0994d22ea3aeca9901a"

RDEPENDS = " \
    debhelper \
    dpkg-dev \
    make \
    perl \
"

