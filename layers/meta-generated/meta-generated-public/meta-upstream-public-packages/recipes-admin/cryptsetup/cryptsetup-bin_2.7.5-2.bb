# This was autogenerated! Do not modify
SUMMARY = "disk encryption support - command line tools"
DESCRIPTION = ""
SECTION = "admin"
SOURCE_PACKAGE = "cryptsetup"
HOMEPAGE = "https://gitlab.com/cryptsetup/cryptsetup"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/c/cryptsetup/cryptsetup-bin_2.7.5-2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/c/cryptsetup/cryptsetup-bin_2.7.5-2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "9184ef4bb7990248122ac74d404d9408"
SRC_URI[deb0.sha1sum] = "34efe14f96828813f2b823e9e4c2f13ffa9ddab2"
SRC_URI[deb0.sha256sum] = "b77b192cf1c35f96da02134300bb227ab92c49eec2444268049fa1ce84fb9bc7"
SRC_URI[deb0.sha512sum] = "fcf240fc06998247ad5045f49482c101aca9ade9a88ab2280b55d109c8f7055be8ccdeba7b1de56ad859f932888cc7a424e4213bb7e4ac3a8310aa25c1b8a0a3"
SRC_URI[deb1.md5sum] = "90ac0837242f9288398033204c662333"
SRC_URI[deb1.sha1sum] = "26698bb924b5581a35b75c55160426f5d439fa97"
SRC_URI[deb1.sha256sum] = "94b6bf78404b2e7d2329935960041b5306ef6adad53a3271b7a7ac9d33776c23"
SRC_URI[deb1.sha512sum] = "fd3f64a208378c16367cbf8078317ff58480f680411b91954ecce972f29f54ade1d667274c1891e527983a8019ffe0eddaee2a48c743fa0c1fd5edc52aab3bfc"

RDEPENDS = " \
    libblkid1 \
    libc6 \
    libcryptsetup12 \
    libpopt0 \
    libuuid1 \
"

