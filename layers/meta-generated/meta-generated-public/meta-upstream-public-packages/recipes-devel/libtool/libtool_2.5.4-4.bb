# This was autogenerated! Do not modify
SUMMARY = "Generic library support script"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "libtool"
HOMEPAGE = "https://www.gnu.org/software/libtool/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libt/libtool/libtool_2.5.4-4_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "cc219573a2ea0baf43a1dc48de9c001f"
SRC_URI[deb0.sha1sum] = "2844c4b2cf59b0cdaabf71092330b3becdc32556"
SRC_URI[deb0.sha256sum] = "be5361a8c1fce2758c3e19608bf97393d5f3afdb7e926aeb83e2818355bd885f"
SRC_URI[deb0.sha512sum] = "9fece2411d39c6dc25f4b6fc7a56b875eabf19a2746bf2c556799684e47bb7605478ed902a25391ab031e421722a7fc533d83ec0c8983d5e13f4dc629e94cc66"

RDEPENDS = " \
    autotools-dev \
    cpp \
    file \
    gcc \
    libc6-dev \
"

