# This was autogenerated! Do not modify
SUMMARY = "GNU Standard C++ Library v3 (development files) (arm64)"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "gcc-14-cross"
HOMEPAGE = "http://gcc.gnu.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gcc-14-cross/libstdc++-14-dev-arm64-cross_14.2.0-19cross1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "bc38ef34e66c15dcbe1954dc30da8996"
SRC_URI[deb0.sha1sum] = "4f6813803976299bfac02d40565996b06c00b3d5"
SRC_URI[deb0.sha256sum] = "dc2d2e1e59f2687a6cb30f3f5ed25e795f2769482ee8f7c5835f00481bf5ad65"
SRC_URI[deb0.sha512sum] = "e8ce493a21808875596467681d3cfd56e7a24b5a24ea131a75aa96e9347da4f02592444c0e78389d6dac1ee2e022547d612a62aa76e80ac341b73e083cfd3f84"

RDEPENDS = " \
    gcc-14-cross-base \
    libc6-dev-arm64-cross \
    libgcc-14-dev-arm64-cross \
    libstdc++6-arm64-cross \
"

RPROVIDES = " \
    libstdc++-dev-arm64-cross \
    libstdc++-dev-arm64-dcv1 \
"
