# This was autogenerated! Do not modify
SUMMARY = "GNU C++ compiler for x86_64-linux-gnu architecture"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "gcc-14-cross"
HOMEPAGE = "http://gcc.gnu.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gcc-14-cross/g++-14-x86-64-linux-gnu_14.2.0-19cross1_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "2a7e95804cacf46d2b43909e096a05ff"
SRC_URI[deb0.sha1sum] = "7a597e9fa2dc7038c2d6dcbad12b0b4a6f41432a"
SRC_URI[deb0.sha256sum] = "e0eb5a9ed659454171376f176af41bf817fd314227f66b799f25bc9fff828d6c"
SRC_URI[deb0.sha512sum] = "e97399d6b9255c4dac9055624814f58c69420fc29d027120a0c71425942591066590f85d87cd70d6e065e7ff25034f4d3f83ae168504da0e7ac7271c410d0ca7"

RDEPENDS = " \
    gcc-14-x86-64-linux-gnu \
    gcc-14-x86-64-linux-gnu-base \
    libc6 \
    libgmp10 \
    libisl23 \
    libmpc3 \
    libmpfr6 \
    libstdc++-14-dev-amd64-cross \
    libzstd1 \
    zlib1g \
"

RPROVIDES = " \
    c++-compiler-x86-64-linux-gnu \
"
