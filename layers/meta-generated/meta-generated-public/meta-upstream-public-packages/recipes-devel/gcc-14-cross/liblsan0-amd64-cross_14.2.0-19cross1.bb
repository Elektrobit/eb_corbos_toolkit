# This was autogenerated! Do not modify
SUMMARY = "LeakSanitizer -- a memory leak detector (runtime)"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "gcc-14-cross"
HOMEPAGE = "http://gcc.gnu.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gcc-14-cross/liblsan0-amd64-cross_14.2.0-19cross1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "a6c453758c7a0e2aeaf47688074a75f2"
SRC_URI[deb0.sha1sum] = "22033fb847844c675abbf7ea1de7ca4c93490d97"
SRC_URI[deb0.sha256sum] = "2c08f7a362cd2ba0f22c2dd0d0b010f3069e3e52b0b4105f06bd7b7d3784e823"
SRC_URI[deb0.sha512sum] = "bd9d8e22620cd0aaf8a6bcb7925dd3b245388290eaba241bd1c69d037ad4eb6afd49dd7d9323246f2eeeb6f17b37791780f09ec06d9f0ad8c92dd52612a97e15"

RDEPENDS = " \
    gcc-14-cross-base \
    libc6 \
    libgcc-s1-amd64-cross \
"

