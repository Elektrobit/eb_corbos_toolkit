# This was autogenerated! Do not modify
SUMMARY = "AddressSanitizer -- a fast memory error detector"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "gcc-14-cross"
HOMEPAGE = "http://gcc.gnu.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gcc-14-cross/libhwasan0-amd64-cross_14.2.0-19cross1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "65fae0117621b2af4626ec36be956a8c"
SRC_URI[deb0.sha1sum] = "673d143c3655bd77f1ad5b6bda8ba4225914ab92"
SRC_URI[deb0.sha256sum] = "b306a43de4609f2713ebaf18c9e0f134e3ca6c5a4c621d8b4c4d408894c5928a"
SRC_URI[deb0.sha512sum] = "261d45dde069d4c08a45783db6f66d2ee4444c3df10485bb4b80fbbcd314eb3742021d4641c6bc9c2d1775b9de5497aa75f306fdb7d9127a9c957cd6731daa45"

RDEPENDS = " \
    gcc-14-cross-base \
    libc6 \
    libgcc-s1-amd64-cross \
"

