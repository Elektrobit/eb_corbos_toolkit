# This was autogenerated! Do not modify
SUMMARY = "GCC, the GNU Compiler Collection (base package)"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "gcc-14-cross"
HOMEPAGE = "http://gcc.gnu.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "amd64"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gcc-14-cross/gcc-14-aarch64-linux-gnu-base_14.2.0-19cross1_amd64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "589d0d5285b3d2b4625e7430dba9aa60"
SRC_URI[deb0.sha1sum] = "9495c1f7f2781736e6fdc3d05aa11a0a85ebfb54"
SRC_URI[deb0.sha256sum] = "4a40a7a5429a03f58bdb1f49df9b7aeecb86770f5585d88dcf6a27b5979a6d5d"
SRC_URI[deb0.sha512sum] = "58cc94f1f24445215976753193b3395802dbfa2af7ce1281d359ae41f619d6439ccc835c5d8ad9ebe62bbca4a4a9aab75dd487057ea86344c5c62b68d5f64c7a"


