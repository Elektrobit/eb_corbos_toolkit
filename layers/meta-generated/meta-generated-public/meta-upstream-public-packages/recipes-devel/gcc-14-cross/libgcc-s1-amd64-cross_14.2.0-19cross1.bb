# This was autogenerated! Do not modify
SUMMARY = "GCC support library (amd64)"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "gcc-14-cross"
HOMEPAGE = "http://gcc.gnu.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gcc-14-cross/libgcc-s1-amd64-cross_14.2.0-19cross1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "d0039581ac52f7e2985e6f20ceb6729b"
SRC_URI[deb0.sha1sum] = "06a47c6fe6b531fd08e7ed5f1236a685a2030b05"
SRC_URI[deb0.sha256sum] = "b319ad73d3233bfe2ac72896a7a921208035c39ea27795377c9522c728846e53"
SRC_URI[deb0.sha512sum] = "8bdaa19ce68ec7dbc8616060c4b343435c033a44f24532b37dafdb38b0cf8538cee29effb294c77b80ff60480fd2f2b91a4b62e0b1047508cf9165f81d843646"

RDEPENDS = " \
    gcc-14-cross-base \
    libc6 \
"

RPROVIDES = " \
    libgcc-s1-amd64-dcv1 \
    libgcc1-amd64-cross \
"
