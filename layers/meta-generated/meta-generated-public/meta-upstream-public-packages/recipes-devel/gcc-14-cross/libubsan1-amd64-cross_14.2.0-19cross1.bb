# This was autogenerated! Do not modify
SUMMARY = "UBSan -- undefined behaviour sanitizer (runtime)"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "gcc-14-cross"
HOMEPAGE = "http://gcc.gnu.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gcc-14-cross/libubsan1-amd64-cross_14.2.0-19cross1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "9c2d0dbe269e059f766f52b6c5ec4a3f"
SRC_URI[deb0.sha1sum] = "30df0b27fa9e36ccd374e4fb4bf82d2199d2d212"
SRC_URI[deb0.sha256sum] = "5b993bdc6a5f47c35a0814a8c252a6b83b4291755a97fcaa6b31ff00d01347ad"
SRC_URI[deb0.sha512sum] = "b910f610e490903e85d30ebd3a821725ee9a3ebd04ded92626833443e51ebc31261bbdf8203009ab3ff7712953cfd794b9c324249d1606b4dfaabe24bb9dcdec"

RDEPENDS = " \
    gcc-14-cross-base \
    libc6 \
    libgcc-s1-amd64-cross \
    libstdc++6-amd64-cross \
"

