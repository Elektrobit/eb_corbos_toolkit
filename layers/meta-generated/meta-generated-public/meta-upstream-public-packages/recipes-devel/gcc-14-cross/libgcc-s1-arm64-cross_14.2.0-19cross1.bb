# This was autogenerated! Do not modify
SUMMARY = "GCC support library (arm64)"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "gcc-14-cross"
HOMEPAGE = "http://gcc.gnu.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gcc-14-cross/libgcc-s1-arm64-cross_14.2.0-19cross1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "6967f0806fad4618297043aa07707aa0"
SRC_URI[deb0.sha1sum] = "d0a3cf012466881b4a9e3a439382354ce9e7bb72"
SRC_URI[deb0.sha256sum] = "272751f04dc1669c6368005ccea3496b28626c720c64c98980f705350f4c6b6b"
SRC_URI[deb0.sha512sum] = "e3c432e2da91254553b64363a43f0bb587d56ce478c74f1bade0847f3c7624392d45f73c48049f7b8fe16e561a6abf775a55eea6e091b793309f82ee6c9fc74c"

RDEPENDS = " \
    gcc-14-cross-base \
    libc6-arm64-cross \
"

RPROVIDES = " \
    libgcc-s1-arm64-dcv1 \
    libgcc1-arm64-cross \
"
