# This was autogenerated! Do not modify
SUMMARY = "GNU Standard C++ Library v3 (amd64)"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "gcc-14-cross"
HOMEPAGE = "http://gcc.gnu.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gcc-14-cross/libstdc++6-amd64-cross_14.2.0-19cross1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "41b4addbe5dda1d1cc86d013b552960e"
SRC_URI[deb0.sha1sum] = "59b3429da4e25e23f0372f7a3348d7de6d636b3b"
SRC_URI[deb0.sha256sum] = "3f129c30e478ef19694e6b3c796e90796316cc698395de98ecd52b1f91494912"
SRC_URI[deb0.sha512sum] = "8e64f713121ffd0948ec13baf8cd796289ff13bfa98d2953ddb190125af3206ebe279cc3aed71e9fb85ba0ec5dbc8180ea656ddfdf8109f998393c6d68f49a75"

RDEPENDS = " \
    gcc-14-cross-base \
    libc6 \
    libc6-amd64-cross \
    libgcc-s1-amd64-cross \
"

RPROVIDES = " \
    libstdc++6-amd64-dcv1 \
"
