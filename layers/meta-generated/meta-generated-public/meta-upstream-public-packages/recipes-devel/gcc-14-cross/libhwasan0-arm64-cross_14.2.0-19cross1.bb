# This was autogenerated! Do not modify
SUMMARY = "AddressSanitizer -- a fast memory error detector"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "gcc-14-cross"
HOMEPAGE = "http://gcc.gnu.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gcc-14-cross/libhwasan0-arm64-cross_14.2.0-19cross1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "1d06ab569446db9555bf2bce26f90476"
SRC_URI[deb0.sha1sum] = "2eaedf7255b0504af965fbabe54fe9768bed518e"
SRC_URI[deb0.sha256sum] = "c0a783cec783df2ac0bae56887f3afd43f2f0047daf0aa8e51cb3147c2bcbbac"
SRC_URI[deb0.sha512sum] = "d90e8cb3cb56120cdf6d4a20f1e0cc9b7eb5552f55d3b29afe05cf08550e8b79c0c212a62b5415f6aa1751387176da7522fb2ef1f45848ca861850c6bd141754"

RDEPENDS = " \
    gcc-14-cross-base \
    libc6-arm64-cross \
    libgcc-s1-arm64-cross \
"

