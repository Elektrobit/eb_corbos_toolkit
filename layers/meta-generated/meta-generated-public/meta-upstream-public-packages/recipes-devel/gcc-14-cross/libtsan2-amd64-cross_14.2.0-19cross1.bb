# This was autogenerated! Do not modify
SUMMARY = "ThreadSanitizer -- a Valgrind-based detector of data races (runtime)"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "gcc-14-cross"
HOMEPAGE = "http://gcc.gnu.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gcc-14-cross/libtsan2-amd64-cross_14.2.0-19cross1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "cae513c0ee482976724f2d35a2edb070"
SRC_URI[deb0.sha1sum] = "e454845db0d7f76f3275737782b3712146cd274e"
SRC_URI[deb0.sha256sum] = "893e663c9d5041ec4d6745d87d504bfaf3852b641897144355ad38a1c3239ded"
SRC_URI[deb0.sha512sum] = "1287cc0be0fbb8c0e7b6cf10c6763c4e9f36f562767ef345ccb26347e747eae773607ca3697ea5290dc3f73fea893e74d63b2f145cd8247f08e9fd691954241c"

RDEPENDS = " \
    gcc-14-cross-base \
    libc6 \
    libgcc-s1-amd64-cross \
"

