# This was autogenerated! Do not modify
SUMMARY = "GNU Standard C++ Library v3 (development files) (amd64)"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "gcc-14-cross"
HOMEPAGE = "http://gcc.gnu.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gcc-14-cross/libstdc++-14-dev-amd64-cross_14.2.0-19cross1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "67636e00373dcda10cbdfc8260bed59e"
SRC_URI[deb0.sha1sum] = "7328b255e5338805294744f5a11d73d8e396506e"
SRC_URI[deb0.sha256sum] = "eca155b57a02b88d56dd29cfe68b1b07b9d26c1ce2c6e5b490a3e62046538676"
SRC_URI[deb0.sha512sum] = "c775006bce53bf038a2bd857642c35991aedc0c9c9c4344403e8fa251d0920e96f5ac078e9f256921fe9224a86ac0d1d41c66b427decde9ad117357c097494ae"

RDEPENDS = " \
    gcc-14-cross-base \
    libc6-dev-amd64-cross \
    libgcc-14-dev-amd64-cross \
    libstdc++6-amd64-cross \
"

RPROVIDES = " \
    libstdc++-dev-amd64-cross \
    libstdc++-dev-amd64-dcv1 \
"
