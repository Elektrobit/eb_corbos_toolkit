# This was autogenerated! Do not modify
SUMMARY = "GNU Standard C++ Library v3 (arm64)"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "gcc-14-cross"
HOMEPAGE = "http://gcc.gnu.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gcc-14-cross/libstdc++6-arm64-cross_14.2.0-19cross1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "02429c2b22a02c97ba8fb5c0509bed9e"
SRC_URI[deb0.sha1sum] = "6330394c89f8d89c2fcc311cfbc13b15271cf1b1"
SRC_URI[deb0.sha256sum] = "81e667b7dad2d378defcc502e9772fe4f435a27e62b7a33a20576885b02e9693"
SRC_URI[deb0.sha512sum] = "75390e307dd6f22b9e2720f8efd9f79faeb031af315492ad235324de2f8eb46b0716df2820aa3387c4bcc9c3892a6966f419a2118443bc2e117360072f2b1946"

RDEPENDS = " \
    gcc-14-cross-base \
    libc6-arm64-cross \
    libgcc-s1-arm64-cross \
"

RPROVIDES = " \
    libstdc++6-arm64-dcv1 \
"
