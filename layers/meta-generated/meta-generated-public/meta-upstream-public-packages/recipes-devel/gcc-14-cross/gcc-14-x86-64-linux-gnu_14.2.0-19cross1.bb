# This was autogenerated! Do not modify
SUMMARY = "GNU C compiler for the x86_64-linux-gnu architecture"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "gcc-14-cross"
HOMEPAGE = "http://gcc.gnu.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gcc-14-cross/gcc-14-x86-64-linux-gnu_14.2.0-19cross1_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "6bc12f10b9cbda31c6bd98dca6062547"
SRC_URI[deb0.sha1sum] = "e372bd6c977c73a7e30a68e41e8bbe14fb07549b"
SRC_URI[deb0.sha256sum] = "157932608aa10a3f26cf13e2e6ffcd6744d5bfa5a8d8feb5bac75875db41df96"
SRC_URI[deb0.sha512sum] = "f8165e6a5784c58e66cccddf2a2900f59d5be228e8e627b9423065a1d0e85e49ee427ccadc47db9748a051f8ae53f6fa06ef666b19c1b07e8ef665cdcdad8d6e"

RDEPENDS = " \
    binutils-x86-64-linux-gnu \
    cpp-14-x86-64-linux-gnu \
    gcc-14-x86-64-linux-gnu-base \
    libc6 \
    libcc1-0 \
    libgcc-14-dev-amd64-cross \
    libgcc-s1 \
    libgmp10 \
    libisl23 \
    libmpc3 \
    libmpfr6 \
    libstdc++6 \
    libzstd1 \
    zlib1g \
"

RPROVIDES = " \
    c-compiler-x86-64-linux-gnu \
"
