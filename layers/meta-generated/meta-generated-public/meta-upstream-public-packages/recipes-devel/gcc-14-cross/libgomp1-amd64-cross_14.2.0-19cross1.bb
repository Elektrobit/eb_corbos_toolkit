# This was autogenerated! Do not modify
SUMMARY = "GCC OpenMP (GOMP) support library"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "gcc-14-cross"
HOMEPAGE = "http://gcc.gnu.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gcc-14-cross/libgomp1-amd64-cross_14.2.0-19cross1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "e94565deab23ae18d0f6bb340d42f38f"
SRC_URI[deb0.sha1sum] = "16a44e3020b31b93528043a36b9f45abdb62527c"
SRC_URI[deb0.sha256sum] = "d658031b6cbd8ade56ff30a1aced31acf33d66cbcd272532e2f951e6edf9836a"
SRC_URI[deb0.sha512sum] = "448b8ef29de01d4f3db74f0ce191d9a9d7452d87c63dcd18dac322d72e2307deb8b36ff96c18a40586e1ad1b1719d424bb7d3fd1416859b5e2aefaa8300f946e"

RDEPENDS = " \
    gcc-14-cross-base \
    libc6 \
"

