# This was autogenerated! Do not modify
SUMMARY = "AddressSanitizer -- a fast memory error detector"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "gcc-14-cross"
HOMEPAGE = "http://gcc.gnu.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gcc-14-cross/libasan8-arm64-cross_14.2.0-19cross1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "4c5a747a77ba554842b3aa892365dbfc"
SRC_URI[deb0.sha1sum] = "6fa12da7ef6b184aa06ec6484d8a691122761c26"
SRC_URI[deb0.sha256sum] = "e223a6c4aa71aa8754abb845cba3de9ae175a213e36a98b67b1aad558ac818be"
SRC_URI[deb0.sha512sum] = "71789b25b0f3aef91252cbe6690cc6aa769d1c43f2e4fbe0b6ce64e4bd6659642d6e296eb35048fa885de903e7a3621c7d921986c2e6824a8900bd0478772121"

RDEPENDS = " \
    gcc-14-cross-base \
    libc6-arm64-cross \
    libgcc-s1-arm64-cross \
"

