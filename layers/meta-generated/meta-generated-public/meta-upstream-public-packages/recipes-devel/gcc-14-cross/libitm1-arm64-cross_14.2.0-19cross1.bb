# This was autogenerated! Do not modify
SUMMARY = "GNU Transactional Memory Library"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "gcc-14-cross"
HOMEPAGE = "http://gcc.gnu.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gcc-14-cross/libitm1-arm64-cross_14.2.0-19cross1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "b2fe8a03f8e537136320eae96f9670a9"
SRC_URI[deb0.sha1sum] = "d157ddd559ac77bff219952853c06e80b3788904"
SRC_URI[deb0.sha256sum] = "61e0bc450632165ef442d0db2902831c878fe24bb89f08e7257e02d4eff92b40"
SRC_URI[deb0.sha512sum] = "805f6d51b1915a5e5389914fa0cb162b58ce193cef1d2fa5a48bfa584fd43c531b8c45b8ac86b94bd6b15b8688dc2c74b0f2762c56c8fec603084f9618b425b2"

RDEPENDS = " \
    gcc-14-cross-base \
    libc6-arm64-cross \
"

