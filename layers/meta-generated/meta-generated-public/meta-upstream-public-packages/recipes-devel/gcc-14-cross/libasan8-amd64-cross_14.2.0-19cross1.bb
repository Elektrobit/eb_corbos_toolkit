# This was autogenerated! Do not modify
SUMMARY = "AddressSanitizer -- a fast memory error detector"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "gcc-14-cross"
HOMEPAGE = "http://gcc.gnu.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gcc-14-cross/libasan8-amd64-cross_14.2.0-19cross1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "69e989668cc83d008f42a22ea01ff60b"
SRC_URI[deb0.sha1sum] = "2244ca451be9cff4fac53eac0f14e088f86d1ae8"
SRC_URI[deb0.sha256sum] = "f46a3a80eccc9a68d43b0c567abe7173bfc07e15bee05db7276606cbcc297c75"
SRC_URI[deb0.sha512sum] = "09c84151ff335c12445d9bc2fea721c87d06d44f86787757e45a2e963bda1c44af786b6e4562744d19efff462e90a981ff81d4243cc529c139b884e96c9315de"

RDEPENDS = " \
    gcc-14-cross-base \
    libc6 \
    libgcc-s1-amd64-cross \
"

