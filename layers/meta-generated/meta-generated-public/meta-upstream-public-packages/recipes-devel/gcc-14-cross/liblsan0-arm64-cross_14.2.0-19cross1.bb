# This was autogenerated! Do not modify
SUMMARY = "LeakSanitizer -- a memory leak detector (runtime)"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "gcc-14-cross"
HOMEPAGE = "http://gcc.gnu.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gcc-14-cross/liblsan0-arm64-cross_14.2.0-19cross1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "670219e4e62ce8ebf5df2dec4a23a110"
SRC_URI[deb0.sha1sum] = "e67b604bc5a589a509599a2c05ded39a773aff12"
SRC_URI[deb0.sha256sum] = "31cb9c474a78ea3233e4ea87badadc33f0c7e48934e39965437091f7f6d5ab78"
SRC_URI[deb0.sha512sum] = "bc99b35f982c415c2159067cd2a85b1caa559dc5f72d1877544e3cd15eb2a5d2aae6b52ca079679c38ae7d7149fd36f799e77bbbb4295c0b9296b39d4cb80025"

RDEPENDS = " \
    gcc-14-cross-base \
    libc6-arm64-cross \
    libgcc-s1-arm64-cross \
"

