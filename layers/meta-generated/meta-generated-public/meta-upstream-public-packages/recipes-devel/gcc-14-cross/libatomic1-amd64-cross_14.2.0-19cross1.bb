# This was autogenerated! Do not modify
SUMMARY = "support library providing __atomic built-in functions"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "gcc-14-cross"
HOMEPAGE = "http://gcc.gnu.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gcc-14-cross/libatomic1-amd64-cross_14.2.0-19cross1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "7ab0d2f0351f001fa44dd3bd00427c5c"
SRC_URI[deb0.sha1sum] = "aec4cd77ed347aff49ff468378570e5a9826c002"
SRC_URI[deb0.sha256sum] = "311d62ad8116bd732e0ef9eed553e4d214452dd77aef9f1fb3b75d64759ab667"
SRC_URI[deb0.sha512sum] = "0f4be563edef7021693bb549bce445fe2636bcbdb648677e06efc4355b386f166e6bd7b4aaf65c3691ed44054a965885a608ebd74d1e06647bbb6726fe1d7f3e"

RDEPENDS = " \
    gcc-14-cross-base \
    libc6 \
"

