# This was autogenerated! Do not modify
SUMMARY = "GNU Transactional Memory Library"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "gcc-14-cross"
HOMEPAGE = "http://gcc.gnu.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gcc-14-cross/libitm1-amd64-cross_14.2.0-19cross1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "718ebe956a83b8f763a6fcb16805c1de"
SRC_URI[deb0.sha1sum] = "4c529f8fe660289f59c94a9e6c71965309f04934"
SRC_URI[deb0.sha256sum] = "0fae4a0e466808666564cd628f4afc0074267b131e70787f0680b71d24c138e1"
SRC_URI[deb0.sha512sum] = "6a8a38637ac84c110cb672466f3d4677cbeaf642f802d483a683b3cdaba6b0529fd66021d0674f0f9c345c421b8fe5cd8d777ba71cdd4148cec264a076c5ae97"

RDEPENDS = " \
    gcc-14-cross-base \
    libc6 \
"

