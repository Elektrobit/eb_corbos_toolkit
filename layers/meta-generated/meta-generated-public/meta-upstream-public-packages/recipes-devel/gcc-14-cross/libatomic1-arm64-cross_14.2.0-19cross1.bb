# This was autogenerated! Do not modify
SUMMARY = "support library providing __atomic built-in functions"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "gcc-14-cross"
HOMEPAGE = "http://gcc.gnu.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gcc-14-cross/libatomic1-arm64-cross_14.2.0-19cross1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "b9305718f8d0caa3aedd60c5470411d2"
SRC_URI[deb0.sha1sum] = "bc24630476da8d6eee51146f3912abcf824fc2ec"
SRC_URI[deb0.sha256sum] = "4a8636b3c0ab2b0a568d0b7fc6ab089d5b22f7a3e696fe8784acef594c88dc1c"
SRC_URI[deb0.sha512sum] = "cfeea4d2148f236651bab8c2bd6456aeec9b40a119ec3de737345fd3427e39bc9dcaa9072d9e42ad069568352048d4d493b8dd62bff13236f377ede8ba1f0b94"

RDEPENDS = " \
    gcc-14-cross-base \
    libc6-arm64-cross \
"

