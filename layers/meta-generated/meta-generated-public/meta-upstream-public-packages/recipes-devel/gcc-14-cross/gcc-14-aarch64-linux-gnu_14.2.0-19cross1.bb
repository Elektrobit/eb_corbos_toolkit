# This was autogenerated! Do not modify
SUMMARY = "GNU C compiler for the aarch64-linux-gnu architecture"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "gcc-14-cross"
HOMEPAGE = "http://gcc.gnu.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "amd64"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gcc-14-cross/gcc-14-aarch64-linux-gnu_14.2.0-19cross1_amd64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "f46105da9949d9ea4f575a3a9d4dec52"
SRC_URI[deb0.sha1sum] = "4e7373aa1ca98cb15ea578ae0fd6782506afee6b"
SRC_URI[deb0.sha256sum] = "489acd3a7479d7e55c01e7f3af10176b70a99ec8c2230ba63cacdbcf2e6e0692"
SRC_URI[deb0.sha512sum] = "8b1e66c3b29a2eb3db05727447f929f15a331f0ca4dde7ce5bf5eed3637cf2e50694fd427461fc54b885ef66b0ba8e7589cce08756d5a00dc091bce5a366ef45"

RDEPENDS = " \
    binutils-aarch64-linux-gnu \
    cpp-14-aarch64-linux-gnu \
    gcc-14-aarch64-linux-gnu-base \
    libc6 \
    libcc1-0 \
    libgcc-14-dev-arm64-cross \
    libgcc-s1 \
    libgmp10 \
    libisl23 \
    libmpc3 \
    libmpfr6 \
    libstdc++6 \
    libzstd1 \
    zlib1g \
"

RPROVIDES = " \
    c-compiler-aarch64-linux-gnu \
"
