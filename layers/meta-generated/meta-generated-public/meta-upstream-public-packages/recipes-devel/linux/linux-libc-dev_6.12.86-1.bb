# This was autogenerated! Do not modify
SUMMARY = "Linux support headers for userspace development"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "linux"
HOMEPAGE = "https://www.kernel.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/l/linux/linux-libc-dev_6.12.86-1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "8a52c7e3ef96c8cb3a17450ac1b2cfcb"
SRC_URI[deb0.sha1sum] = "2371db9d2bc3edab28bc7431750d51ab7cff8609"
SRC_URI[deb0.sha256sum] = "b3d0d91cda2905cd5c201c8bb3d2369e10cc03a19ea432217a62e54480d6446a"
SRC_URI[deb0.sha512sum] = "0c95c3e7c3b7101b61cbbef4fc73b7ab5f4b3167d49127becf4659e8236f1f9cf38a9ee4ff11201f9923fe66ee767d2ab486f62f902b54e332984d64ca20e809"


