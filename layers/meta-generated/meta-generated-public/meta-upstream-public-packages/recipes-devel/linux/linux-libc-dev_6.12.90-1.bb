# This was autogenerated! Do not modify
SUMMARY = "Linux support headers for userspace development"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "linux"
HOMEPAGE = "https://www.kernel.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/l/linux/linux-libc-dev_6.12.90-1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "c9c667eb44ab251a37f326e35747cb01"
SRC_URI[deb0.sha1sum] = "f62fc5a0fda7e34d5f79de31484594bad96c229d"
SRC_URI[deb0.sha256sum] = "060c071d55235eaf944272ba90d848116dcface359903b1920ab46af7d63c31d"
SRC_URI[deb0.sha512sum] = "9b8f59024738b7244b1bc1ded17ef4b311798d3c9f21866c57b2d67a9164af59a400c28eb8090ffb0f5f69c2f4a6ad1930c4d7ebc1e3214e230d72013d5687c0"


