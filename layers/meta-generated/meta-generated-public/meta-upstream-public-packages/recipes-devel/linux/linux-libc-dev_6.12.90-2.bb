# This was autogenerated! Do not modify
SUMMARY = "Linux support headers for userspace development"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "linux"
HOMEPAGE = "https://www.kernel.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/l/linux/linux-libc-dev_6.12.90-2_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "d4fd09c4be19d3f9d9f3f47c472b199f"
SRC_URI[deb0.sha1sum] = "8b913f59c1b49552a4d1385529698661cc804ce0"
SRC_URI[deb0.sha256sum] = "13dd621af5286c8e807536458f59fb8e37c53ac1e3e6a42b9374c0953343c3b7"
SRC_URI[deb0.sha512sum] = "a745632b9f690cb2140a1465e98f394c0635b207d3a08e64b8b995d268c98814cfd9ec31d6a6808739734438c9a7f983d4998686bfe1c8e76e4acf09af12e7f3"


