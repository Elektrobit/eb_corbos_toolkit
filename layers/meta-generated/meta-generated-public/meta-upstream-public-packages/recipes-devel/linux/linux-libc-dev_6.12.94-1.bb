# This was autogenerated! Do not modify
SUMMARY = "Linux support headers for userspace development"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "linux"
HOMEPAGE = "https://www.kernel.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/l/linux/linux-libc-dev_6.12.94-1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "042e13b6cf6d9f53315267adea4247af"
SRC_URI[deb0.sha1sum] = "3ce41db3e9e4c73adc415c26ce4325b66f67586d"
SRC_URI[deb0.sha256sum] = "6183985d8fa4b97d277e8b55b10ad247bd98bc23aa8b531c1f79f05bfbf50997"
SRC_URI[deb0.sha512sum] = "f3906897d55927442877d30a08711bbe85f9908b2d7756859f9374f6b8e00095f332c5a785a1d5a883c34663d2ae1d6104857fe667efcc46617e05d5db4a2278"


