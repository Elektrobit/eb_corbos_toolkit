# This was autogenerated! Do not modify
SUMMARY = "Tool for generating GNU Standards-compliant Makefiles"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "automake-1.17"
HOMEPAGE = "https://www.gnu.org/software/automake/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/a/automake-1.17/automake_1.17-4_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "6ab1979e73b025b743a5e04cca5d3ccf"
SRC_URI[deb0.sha1sum] = "d9ac3d32319bd502abf2059b1d646cebb48bf2e5"
SRC_URI[deb0.sha256sum] = "8d4b172d4ff8070789c54b48a95585b53e4c65faeb07a2ae52da16cb364df635"
SRC_URI[deb0.sha512sum] = "f20fb4b1e2b08b8ce9933d020528cd2d0493a90ef1498b598bd716767bc59a9f91ad30f7100dfe8ea69b2db5de830378d1a7456c9880a67038b626d3b6979db4"

RDEPENDS = " \
    autoconf \
    autotools-dev \
"

RPROVIDES = " \
    automake-1.16 \
    automake-1.17 \
    automaken \
"
