# This was autogenerated! Do not modify
SUMMARY = "automatic configure script builder"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "autoconf"
HOMEPAGE = "https://www.gnu.org/software/autoconf/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/a/autoconf/autoconf_2.72-3.1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "687aca0081ef2f226cef4f73c94a894e"
SRC_URI[deb0.sha1sum] = "bb093989f7535851cee6851f7ae33f2a129a6302"
SRC_URI[deb0.sha256sum] = "0de76b647b0afb6c7934999aaefeb463656c147672464a367df1019969e77af3"
SRC_URI[deb0.sha512sum] = "5eb4037c3a11dad0165ad7656182c6b4c631e856e992cca8d4df8a70931d2b3c02bd33a513eaaccd80567dc0a857e61db12f4f64cc5c9d71c7def39d9f1dcddf"

RDEPENDS = " \
    debianutils \
    m4 \
    perl \
"

