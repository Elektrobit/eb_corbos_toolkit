# This was autogenerated! Do not modify
SUMMARY = "GNU binary utilities, for aarch64-linux-gnu target"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "binutils"
HOMEPAGE = "https://www.gnu.org/software/binutils/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/b/binutils/binutils-aarch64-linux-gnu_2.44-3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/b/binutils/binutils-aarch64-linux-gnu_2.44-3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "f125439e6d179725ba0438153e7ff87a"
SRC_URI[deb0.sha1sum] = "5659204d33c65e589e817a1d15e51e99deef898b"
SRC_URI[deb0.sha256sum] = "6e5a9be38121213dda42189a525db01aad4dc52194b577d7d73d659a5843ce6c"
SRC_URI[deb0.sha512sum] = "32d27a807ac638f4b7dd0b90d0f989dd7e51f20a66e1b9817ef13a90facfcfb04924db09faa530c6169460905459faa4378d375c2c93327bf78a872244a4298a"
SRC_URI[deb1.md5sum] = "d47fc7f34fc8c28f35f37cc0ae0148e8"
SRC_URI[deb1.sha1sum] = "a3097306a80f8f868d7b443ea4722ebaa1bae554"
SRC_URI[deb1.sha256sum] = "79cbf1459118bce3535133ffbf1fd2adbd57af65271f95c829af5cfa7f474168"
SRC_URI[deb1.sha512sum] = "335842326126a091a7d704b94e6dd91eca129930ce8bd9cffd9c96b4b6af086969e053e6f10239643771fa37c82a65cbef1e856458f612f4ea5b709f201e3253"

RDEPENDS = " \
    binutils-common \
    libc6 \
    libjansson4 \
    libsframe1 \
    libzstd1 \
    zlib1g \
"
RDEPENDS:append:arm64 = " \
    libbinutils \
    libctf-nobfd0 \
    libctf0 \
"

