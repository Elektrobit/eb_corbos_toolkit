# This was autogenerated! Do not modify
SUMMARY = "Common files for the GNU assembler, linker and binary utilities"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "binutils"
HOMEPAGE = "https://www.gnu.org/software/binutils/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/b/binutils/binutils-common_2.44-3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/b/binutils/binutils-common_2.44-3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "f2453d21ad64186db1c48a15f647cc10"
SRC_URI[deb0.sha1sum] = "273382c5e56614777ef78d42eb213ab1f55139b1"
SRC_URI[deb0.sha256sum] = "002da5d23f8757dee97a2c0a40e0e1d4d85a43da094488ee2ee7068d4d3691f9"
SRC_URI[deb0.sha512sum] = "74cf8ead9186c8788ab1a3dc10e8b7d974c129b7a1cc66ca1e2d951fbf0e5052937a79dfbc0517804213f998c1d3615d90a76183f23df84bccbb17c4c0546526"
SRC_URI[deb1.md5sum] = "e3de4465786b11d755b580dca2ba2890"
SRC_URI[deb1.sha1sum] = "733d94b3bc76aacc182c3049e609c8eefc9874f7"
SRC_URI[deb1.sha256sum] = "f2d6b7d0b5521c4c90fc105e32819cd5268c1aa69104173b3fb856595f898249"
SRC_URI[deb1.sha512sum] = "c0cbb8e966bb045743aa4ad78d6a036f65f42203a9e349fccdacaea471d228cf8f3c8be810c27518a3e6373878dca2afda5cdf43f0b6696efc58cd0118d61a9d"


