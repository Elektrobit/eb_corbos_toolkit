# This was autogenerated! Do not modify
SUMMARY = "GNU binary utilities (private shared library)"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "binutils"
HOMEPAGE = "https://www.gnu.org/software/binutils/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/b/binutils/libbinutils_2.44-3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/b/binutils/libbinutils_2.44-3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "0a4fede3fa875d18d1226d767450f2ac"
SRC_URI[deb0.sha1sum] = "150afad071e8968436aaef066ec3c66082abedf6"
SRC_URI[deb0.sha256sum] = "4f4664c8a8f0ad0c8631c39fab02e3d8d86ccc6f4436a1d59f059dbcb0492679"
SRC_URI[deb0.sha512sum] = "ea9dedb90fff687e72d2321370e51bda774046728171654c1a202d255b86c306d07f6f74b8c1cd95e7f6ec1546966ae4723bfd71ef1a8115c61a46dfcb59e5fc"
SRC_URI[deb1.md5sum] = "b65697fbca1442d3c0512938619fc51f"
SRC_URI[deb1.sha1sum] = "2e02fd5c0a8d3152761a45d14ba92a064b6eac40"
SRC_URI[deb1.sha256sum] = "c51c0cc0272202d00fc3e6da8b96bfed2a428c239b689363abddd3bac6bd7a02"
SRC_URI[deb1.sha512sum] = "07daf3442f763c533714ad901801c6321dd08c50734d7343407c31068c7ca884ad30875a886150e4d4583dad5dcb72ae6f7da1a729a284083f3148006fe19428"

RDEPENDS = " \
    binutils-common \
    libc6 \
    libsframe1 \
    libzstd1 \
    zlib1g \
"

