# This was autogenerated! Do not modify
SUMMARY = "Compact C Type Format library (runtime, BFD dependency)"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "binutils"
HOMEPAGE = "https://www.gnu.org/software/binutils/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/b/binutils/libctf0_2.44-3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/b/binutils/libctf0_2.44-3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "d73a3224826d5e9c72440b2ab7a556b8"
SRC_URI[deb0.sha1sum] = "6fbef1d79dee50ad3b9be361b21e1a22799b743e"
SRC_URI[deb0.sha256sum] = "120cafcd93132a276fa92a8fb4cf39b23d14e5a3e348f4f5580638d71ca95ac5"
SRC_URI[deb0.sha512sum] = "0a44ac50ddcca04332c85d51cb90b12cf9dc9b263cb96497bc6d7e0fa63966410c84da73811640e95b605f1cfeec238ffa3b7ba7faf7b21907998f15524d7bd1"
SRC_URI[deb1.md5sum] = "184a5d96561190e3826655151a86f1ec"
SRC_URI[deb1.sha1sum] = "8be7160562a6003a79039732fc655bd9372f2b72"
SRC_URI[deb1.sha256sum] = "12cb7df9eafd965c00c38a8720c5b78e7b0106390f69fe180a3b3589f407d550"
SRC_URI[deb1.sha512sum] = "b6266440c742093df1bebbbd2ab0cef9fe7965ef41b1aa499b663d2db3109dbac340f86a4605a53c381d21a0998f1c6e6a4e4d6d94ddb66bfa56ead4feb097bf"

RDEPENDS = " \
    libbinutils \
    libc6 \
    zlib1g \
"

