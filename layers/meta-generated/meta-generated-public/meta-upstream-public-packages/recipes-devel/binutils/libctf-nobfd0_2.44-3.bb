# This was autogenerated! Do not modify
SUMMARY = "Compact C Type Format library (runtime, no BFD dependency)"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "binutils"
HOMEPAGE = "https://www.gnu.org/software/binutils/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/b/binutils/libctf-nobfd0_2.44-3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/b/binutils/libctf-nobfd0_2.44-3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "ed41182f67ed47530cda4f54ef0f653b"
SRC_URI[deb0.sha1sum] = "549bb57042a6c6f519445ae550a38aa8b396c589"
SRC_URI[deb0.sha256sum] = "e280b2be3db6e584500e865c251605b95c346767d87ccb2524e44992048fc657"
SRC_URI[deb0.sha512sum] = "50c142bc4eab2ba5a7fe12475f20b805062585f2cd948898a7abf4ae0514d95508d7c1d40e23e27428dd23d11c5ebe9d7eae428a3738e0436a01b7ff0ac85df3"
SRC_URI[deb1.md5sum] = "736a90beca66d9a2f4c79d1faa10d251"
SRC_URI[deb1.sha1sum] = "a7e4656601379305f9d15b5d37684c9c393ebedc"
SRC_URI[deb1.sha256sum] = "7b1894cbd09bd59507af259ba680a1f5d3b68c6ba9e5d69508ea2d75b3f01be6"
SRC_URI[deb1.sha512sum] = "657269474921e52f2074e142bf0a689abe53af902460801f1f594bab468caca3aef21b7ba76c41842e5c46574a252e33d1d324eb494cf59ba41f3cfb340fa14b"

RDEPENDS = " \
    libc6 \
    zlib1g \
"

