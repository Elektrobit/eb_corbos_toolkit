# This was autogenerated! Do not modify
SUMMARY = "GNU assembler, linker and binary utilities"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "binutils"
HOMEPAGE = "https://www.gnu.org/software/binutils/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/b/binutils/binutils_2.44-3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/b/binutils/binutils_2.44-3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "326a3d0d8d666c707c89280eb8c06305"
SRC_URI[deb0.sha1sum] = "f6b0d5bc10135d7427e6164ea170bb1203941e59"
SRC_URI[deb0.sha256sum] = "6bc08c02539ba53b5e748142397144c499f9b20b5fa9bb56431545db124addeb"
SRC_URI[deb0.sha512sum] = "015d607cdd7820a3318d883eae923129af6d0b99e73abfb54431a46c251ccd429fa35bfbb9893c91fa01d85b445c622005036e884c53b72b8f0b6b3482f5cb42"
SRC_URI[deb1.md5sum] = "b6cb14fee23dd36579a400e126c8605b"
SRC_URI[deb1.sha1sum] = "dc6feaa5c3ef2a1f549f9cde070b441670c893eb"
SRC_URI[deb1.sha256sum] = "7228716cad15e78d1571f1cd4ec7141f64608790d0fbcba23a07f2eda6298272"
SRC_URI[deb1.sha512sum] = "224949247e325e0fc28b9976b22311cc541e522e11ddd0db7abe7f41c8a4be184e3960eaed7f47b93cd6684bb9a9c677f02c165301eba3704875edd929988e35"

RDEPENDS = " \
    binutils-common \
    libbinutils \
    libc6 \
    libgcc-s1 \
    libgprofng0 \
    libstdc++6 \
"
RDEPENDS:append:amd64 = " \
    binutils-x86-64-linux-gnu \
"
RDEPENDS:append:arm64 = " \
    binutils-aarch64-linux-gnu \
"

RPROVIDES = " \
    elf-binutils \
"
