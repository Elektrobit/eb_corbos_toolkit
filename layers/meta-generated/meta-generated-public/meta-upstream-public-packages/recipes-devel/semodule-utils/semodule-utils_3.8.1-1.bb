# This was autogenerated! Do not modify
SUMMARY = "SELinux core policy utilities (modules utilities)"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "semodule-utils"
HOMEPAGE = "https://github.com/SELinuxProject"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/semodule-utils/semodule-utils_3.8.1-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/semodule-utils/semodule-utils_3.8.1-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "24c8145d57afa31118c4a1abeef12da3"
SRC_URI[deb0.sha1sum] = "6b76f7ddfbe672c636abf245837e60256c9455b9"
SRC_URI[deb0.sha256sum] = "74261f47900b1f0452a59b8591b1cf7b5d6d881385fa1675e0ddcccfbf88b1e9"
SRC_URI[deb0.sha512sum] = "64b80e905b2dc434ac6428c44a9196fbf3effcc2e7d96fff0cc113686ea9a3f0756079ba7d677421a6507a877f971eb4d11d7a776672a9d46c7d5a7e5af9a642"
SRC_URI[deb1.md5sum] = "edd87c6b0c850bf3a2e460dc340432ed"
SRC_URI[deb1.sha1sum] = "debc475dfc8140fa767951459aca67990fa02307"
SRC_URI[deb1.sha256sum] = "13b869da86ca9b1d545adaf08f06446385b6532a154baebed368db9534de0136"
SRC_URI[deb1.sha512sum] = "a91bcea48e82d1a7cf6366932511235b5285b986c278a8756c4a13b70c855979c6d2420488f1dfb5ddf89b9641b3b3430b1b7d898f6fbc16237bae2949ab2329"

RDEPENDS = " \
    libc6 \
    libsepol2 \
"

