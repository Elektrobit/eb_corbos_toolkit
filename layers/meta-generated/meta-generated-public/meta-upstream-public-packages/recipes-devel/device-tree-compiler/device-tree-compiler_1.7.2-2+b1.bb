# This was autogenerated! Do not modify
SUMMARY = "Device Tree Compiler for Flat Device Trees"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "device-tree-compiler"
HOMEPAGE = "https://git.kernel.org/cgit/utils/dtc/dtc.git"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/d/device-tree-compiler/device-tree-compiler_1.7.2-2+b1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/d/device-tree-compiler/device-tree-compiler_1.7.2-2+b1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "43697e63e6e285b7e99648ea9aeb2aeb"
SRC_URI[deb0.sha1sum] = "be1d02a6ff1c045fb848ef38f05b827f9be57c9e"
SRC_URI[deb0.sha256sum] = "1d2ee77671eb76db21ad455a0e0211ece67f57c6d12b7501b92876bbcea390d6"
SRC_URI[deb0.sha512sum] = "7d04c7418ba55cd8b259f271ec1606a8c88c560331017b5259ee77035ed94c2d369e319822aa4b44cb2b483572623666fb60f26a2c880f6eba51e9d8335a79ea"
SRC_URI[deb1.md5sum] = "bfb69d4918e70b1b61619adf7594c153"
SRC_URI[deb1.sha1sum] = "db12ee2c4c077aa591a21a49086b57f061049a60"
SRC_URI[deb1.sha256sum] = "231b254d0233ea3e613fdfcd9a866cd80cab80c270143de9191ac4064a9058ed"
SRC_URI[deb1.sha512sum] = "1a2bb91868cb8062658eb216f4b80c1e20e92e2e482e7bb3fedf42110111ae04bd26da566d1d7c1d00add2e3f35091925a7c56426c72b514c349959cd43a3f46"

RDEPENDS = " \
    libc6 \
    libfdt1 \
    libyaml-0-2 \
"

