# This was autogenerated! Do not modify
SUMMARY = "Vertical Blanking Interval decoder (VBI) - common files"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "zvbi"
HOMEPAGE = "https://github.com/zapping-vbi/zvbi"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/z/zvbi/libzvbi-common_0.2.44-1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "abaa34c8080100c24eb716e63d67c3aa"
SRC_URI[deb0.sha1sum] = "3bdb04898b8213cbf533afc40635a0f3f44ced12"
SRC_URI[deb0.sha256sum] = "98ab88223df2380c79d048c6bd276449c64603eef4e43aa99d52406877ebee59"
SRC_URI[deb0.sha512sum] = "99ad669837e9328210bff0aa58d99b03908b238751ca4f910a9c3a318392d9282bfd059737373cac4353929c1257f16f9d3a212fbe06b31ebb4c9e8878e0e159"


