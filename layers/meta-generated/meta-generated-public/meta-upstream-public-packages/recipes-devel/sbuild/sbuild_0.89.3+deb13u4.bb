# This was autogenerated! Do not modify
SUMMARY = "Tool for building Debian binary packages from Debian sources"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "sbuild"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/sbuild/sbuild_0.89.3+deb13u4_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "24823bae8be22b91b457218534b5cf0c"
SRC_URI[deb0.sha1sum] = "c8ae1ccf767b76e73afe68adc374b656b1bdd308"
SRC_URI[deb0.sha256sum] = "544ca6dc2201741bb639a2ab52664d7d181e35877feecb743d54b80c55eb0b3f"
SRC_URI[deb0.sha512sum] = "cb929db560c39714234e6f1c4540b3a4c97873d8cdf598edd0774c420cc30b5f8b5d70bc207515e3aee6307790c8050d1e77f0d45b002b51299ee2b31aef40b1"

RDEPENDS = " \
    adduser \
    libsbuild-perl \
    perl \
"

