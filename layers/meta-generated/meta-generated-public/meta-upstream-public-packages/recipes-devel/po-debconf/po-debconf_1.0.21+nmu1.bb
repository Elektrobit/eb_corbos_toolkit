# This was autogenerated! Do not modify
SUMMARY = "tool for managing templates file translations with gettext"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "po-debconf"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/po-debconf/po-debconf_1.0.21+nmu1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "01b5728773ad7b560faf44929a8a0e77"
SRC_URI[deb0.sha1sum] = "c985dc67d0596293d22a6c050b33fcb78d30326f"
SRC_URI[deb0.sha256sum] = "613e31942c17b582e8c76db1077240f177f2f67bad22e5f4f8e5bee523d6f54b"
SRC_URI[deb0.sha512sum] = "3535d3388f498f99c0cb2aeec3e46dfc4b9a66b4ca5552b3973d51b6814139a3d98e1d4ce681b8dcdc7ee773e90a5eaf851a72157ca5767430712ad1231741f0"

RDEPENDS = " \
    gettext \
    intltool-debian \
    perl \
    sensible-utils \
"

