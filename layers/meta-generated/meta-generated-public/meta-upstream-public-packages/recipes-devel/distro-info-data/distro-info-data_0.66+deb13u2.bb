# This was autogenerated! Do not modify
SUMMARY = "information about the distributions' releases (data files)"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "distro-info-data"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/d/distro-info-data/distro-info-data_0.66+deb13u2_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "f10aaf9d2bcc0fdd8a1eb3d272295920"
SRC_URI[deb0.sha1sum] = "b48e5743ff5e39c3a4b442773a6d28cc89babb09"
SRC_URI[deb0.sha256sum] = "91bf35d6efa2a12e0d81abea1819e87fef2d292899f41c40a7ee1085e92cba60"
SRC_URI[deb0.sha512sum] = "6432ea562f9daba131e2fd71e72765a387012e011202cc809df4940ba88e3aa91cb2ebf3f2be68355c1304d24823e98bb1d9aa91489f46d23ea8e50b016a2282"


