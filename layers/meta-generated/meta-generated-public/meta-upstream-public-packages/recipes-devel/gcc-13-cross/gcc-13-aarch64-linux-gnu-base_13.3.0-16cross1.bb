# This was autogenerated! Do not modify
SUMMARY = "GCC, the GNU Compiler Collection (base package)"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "gcc-13-cross"
HOMEPAGE = "http://gcc.gnu.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "amd64"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gcc-13-cross/gcc-13-aarch64-linux-gnu-base_13.3.0-16cross1_amd64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "b63558de7a87c7b3ced03491ab6553b3"
SRC_URI[deb0.sha1sum] = "a98b9907e98f33c14c3dd7812ac06cc7ab892090"
SRC_URI[deb0.sha256sum] = "566f709d26c4280870a46dad34c20fe60f6920daf42320892645daa4e266a468"
SRC_URI[deb0.sha512sum] = "7a7b19f0d4f34fe27cfd2626c6356f75f886f7d444e906b097ff29d30d6cf8b1b3457bb5e9e4f00af04fa1b5fa43abc303dce5647416cfa655db2f538def26c3"


