# This was autogenerated! Do not modify
SUMMARY = "GNU C preprocessor for aarch64-linux-gnu"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "gcc-13-cross"
HOMEPAGE = "http://gcc.gnu.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "amd64"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gcc-13-cross/cpp-13-aarch64-linux-gnu_13.3.0-16cross1_amd64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "41423ed141d8780d6830789a7b387e48"
SRC_URI[deb0.sha1sum] = "e280b865a4d3c8ffc39b50ff0c9f9735c83de79e"
SRC_URI[deb0.sha256sum] = "1c5869f099581ae044bf25fc3cb2243449b6be8277126e5aa82c9083bc5608ac"
SRC_URI[deb0.sha512sum] = "a1d2e0c7f2971b18d4308b241dc0f75ebb1df9ed01d5badbba6e22f7c1605c823b1c1257d7e90ac026a69978cd22df4c6aa38539c1e1fa40860e971afb6519cb"

RDEPENDS = " \
    gcc-13-aarch64-linux-gnu-base \
    libc6 \
    libgmp10 \
    libisl23 \
    libmpc3 \
    libmpfr6 \
    libzstd1 \
    zlib1g \
"

