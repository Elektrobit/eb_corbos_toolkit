# This was autogenerated! Do not modify
SUMMARY = "GNU C++ compiler for aarch64-linux-gnu architecture"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "gcc-13-cross"
HOMEPAGE = "http://gcc.gnu.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "amd64"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gcc-13-cross/g++-13-aarch64-linux-gnu_13.3.0-16cross1_amd64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "1aee287cd7a2db454ae38622b9eb177c"
SRC_URI[deb0.sha1sum] = "d8140a56c41ffe3a7c672c8ed3966ccc8725da2c"
SRC_URI[deb0.sha256sum] = "68b01eb51b958254d5ef506a2f5c61513c832e16a5220338cc071a87053b55fe"
SRC_URI[deb0.sha512sum] = "5bc7d0ef1948badfee34a1488007d56666820f6022085297ad6b8437dbda06e04c48eeca2c46938f930077a1d0bd5f9f4d561ef872f5f020525805b55fbde33b"

RDEPENDS = " \
    gcc-13-aarch64-linux-gnu \
    gcc-13-aarch64-linux-gnu-base \
    libc6 \
    libgmp10 \
    libisl23 \
    libmpc3 \
    libmpfr6 \
    libstdc++-13-dev-arm64-cross \
    libzstd1 \
    zlib1g \
"

RPROVIDES = " \
    c++-compiler-aarch64-linux-gnu \
"
