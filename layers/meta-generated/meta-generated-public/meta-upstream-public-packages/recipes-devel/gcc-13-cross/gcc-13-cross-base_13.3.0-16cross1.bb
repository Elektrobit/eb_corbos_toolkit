# This was autogenerated! Do not modify
SUMMARY = "GCC, the GNU Compiler Collection (library base package)"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "gcc-13-cross"
HOMEPAGE = "http://gcc.gnu.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gcc-13-cross/gcc-13-cross-base_13.3.0-16cross1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "c9504d4da4c972b9c6d14ffd9c6ae436"
SRC_URI[deb0.sha1sum] = "1927de1b702fe96b6e4ae1969847602c4248b0f1"
SRC_URI[deb0.sha256sum] = "5b48202d55ae67bbb37866ecdd52b612242df8d1eb3c41ae0f7424babc040685"
SRC_URI[deb0.sha512sum] = "341edc772a8b4de00159b569e62541fc7c1681e548bfe50301a96811cbcd9f637ff1c04172ec279928b589db82dc47c615abd8900f978751322b727479593bf6"


