# This was autogenerated! Do not modify
SUMMARY = "standard C library tools"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "musl"
HOMEPAGE = "https://musl.libc.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/m/musl/musl-tools_1.2.5-3.1~deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/m/musl/musl-tools_1.2.5-3.1~deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "c80208a78591705dee4dbe9257c650a9"
SRC_URI[deb0.sha1sum] = "8e87951dc3c25e550deccd11cb8984a5eb5ef2bd"
SRC_URI[deb0.sha256sum] = "2ffc3e5f7ecffdc2b64eeac23ffc199b21b4c93dca8e7310dd2c9ab9cd42ddd4"
SRC_URI[deb0.sha512sum] = "421b44d463263c9fdb1eccf502391eaca6649c48a30780bc61b9c2461da8b01151edad914ec373400f861d4456f5fc5f78fb4ba22bc62d3eb0daf102adf9179c"
SRC_URI[deb1.md5sum] = "c9e879c78a0c2b03fb588a63cdaabdc5"
SRC_URI[deb1.sha1sum] = "843a55f52af6c9a1b591cf858a42e18be326bb1b"
SRC_URI[deb1.sha256sum] = "3d3a33291ee2bb651dae1940671fb302d0a1b90a0ad9bc2a1ae8e81151d811c7"
SRC_URI[deb1.sha512sum] = "e61b517e42cc621aca13f87dd6c68956d1ccc15b5d5b8f936578404fab0596e2a68f7b43650954ca4f20aeef482c51781d79b5fc3c6fa41f514f624523fbe1b8"

RDEPENDS = " \
    musl-dev \
"

