# This was autogenerated! Do not modify
SUMMARY = "GNU C compiler for the aarch64-linux-gnu architecture"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "gcc-14"
HOMEPAGE = "http://gcc.gnu.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gcc-14/gcc-14-aarch64-linux-gnu_14.2.0-19_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "2e732ae6376e3d6fbecf1de6068e1266"
SRC_URI[deb0.sha1sum] = "44c65c8edc92c70846fe21443e20485ae048e1a6"
SRC_URI[deb0.sha256sum] = "5ff736a332ba5d60ad463355ed25c8c39da1281acf9155cc2f8a55fc1d478be8"
SRC_URI[deb0.sha512sum] = "ab52f88c7d4dcb156613985a963c25082fe2a6bf2eb90e3dd9751270e1fcf3e10bf7a859abe6bbc601551a3bab58d2cf0ff06234d5ea182ff12c432abff462d6"

RDEPENDS = " \
    binutils-aarch64-linux-gnu \
    cpp-14-aarch64-linux-gnu \
    gcc-14-base \
    libc6 \
    libcc1-0 \
    libgcc-14-dev \
    libgcc-s1 \
    libgmp10 \
    libisl23 \
    libmpc3 \
    libmpfr6 \
    libstdc++6 \
    libzstd1 \
    zlib1g \
"

RPROVIDES = " \
    c-compiler-aarch64-linux-gnu \
"
