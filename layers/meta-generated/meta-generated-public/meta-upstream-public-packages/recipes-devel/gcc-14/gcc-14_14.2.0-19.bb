# This was autogenerated! Do not modify
SUMMARY = "GNU C compiler"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "gcc-14"
HOMEPAGE = "http://gcc.gnu.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gcc-14/gcc-14_14.2.0-19_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gcc-14/gcc-14_14.2.0-19_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "7b5c03a14224798e9ef3151c46fba48e"
SRC_URI[deb0.sha1sum] = "a8fad8c57c5cb5a4fa73af4c866d3347ba64fe83"
SRC_URI[deb0.sha256sum] = "21500408b5019d8d29f70ce58488e2eea469a1adb4b5fd7db45e819b5efcac4e"
SRC_URI[deb0.sha512sum] = "0e6adb45d93efcd65655ad2c0327442c1e325da521bdce6d9b7889e6c0e3b5864829d6cb2a6fa5dce46a006a42fa7fdc695c1f05bd4d1cbdfc3ae84a1db75892"
SRC_URI[deb1.md5sum] = "acb695abe98db3e39b1b4303d6634e9d"
SRC_URI[deb1.sha1sum] = "738418a4c4e96a217787fcf174cf2afa08936d4c"
SRC_URI[deb1.sha256sum] = "f4ba77903d7efc3c64c69a8a98c7efa8ea1ae4331521bb74abd76bcc43f1b576"
SRC_URI[deb1.sha512sum] = "aeafaf08463cdaeb4cabbcf6e409fd6ca6695425c8d62feb74c778cee13fde9bbc29b2ee32095c4dca71da078198804d2c057cd219abfcb53241baee4beb5704"

RDEPENDS = " \
    binutils \
    cpp-14 \
    gcc-14-base \
"
RDEPENDS:append:amd64 = " \
    gcc-14-x86-64-linux-gnu \
"
RDEPENDS:append:arm64 = " \
    gcc-14-aarch64-linux-gnu \
"

RPROVIDES = " \
    c-compiler \
"
