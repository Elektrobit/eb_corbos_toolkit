# This was autogenerated! Do not modify
SUMMARY = "GNU C++ compiler for aarch64-linux-gnu architecture"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "gcc-14"
HOMEPAGE = "http://gcc.gnu.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gcc-14/g++-14-aarch64-linux-gnu_14.2.0-19_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "926664adf4ba539cd36644d4be402a0f"
SRC_URI[deb0.sha1sum] = "fd70587480e2aabef7f38097533d75a2edb247d2"
SRC_URI[deb0.sha256sum] = "411dac8f1c1d0293e58deddeb170c641ad82c56d51a95f056ee12ba02c24288b"
SRC_URI[deb0.sha512sum] = "6a7ccf97c90fcf92b340847d84e6a8a7783e4fa52304947d8d98d3d1d44cb09017aac5bff6f8cdd6c90cb41571342cd67b7d3ea21ba9c0cb51115360915d57fd"

RDEPENDS = " \
    gcc-14-aarch64-linux-gnu \
    gcc-14-base \
    libc6 \
    libgmp10 \
    libisl23 \
    libmpc3 \
    libmpfr6 \
    libstdc++-14-dev \
    libzstd1 \
    zlib1g \
"

RPROVIDES = " \
    c++-compiler-aarch64-linux-gnu \
"
