# This was autogenerated! Do not modify
SUMMARY = "GNU C compiler for the x86_64-linux-gnu architecture"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "gcc-14"
HOMEPAGE = "http://gcc.gnu.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "amd64"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gcc-14/gcc-14-x86-64-linux-gnu_14.2.0-19_amd64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "ba8b61619308e4877d6609025c874e23"
SRC_URI[deb0.sha1sum] = "2b1ff33f18d295d06d1dfe4cbd51fb730157cd63"
SRC_URI[deb0.sha256sum] = "a17ef039f1ba482051c3efb5c2c24070002e60dd0bd09fd456ec31481a11b725"
SRC_URI[deb0.sha512sum] = "00eee03e610a19096222a43b5f284f9da5ec1f5664e2f5ef64dc4ec465ad43d886c17f0ce326de8569c01c2e543469c4f15d1ac14daca19e6e2d165448bb7647"

RDEPENDS = " \
    binutils-x86-64-linux-gnu \
    cpp-14-x86-64-linux-gnu \
    gcc-14-base \
    libc6 \
    libcc1-0 \
    libgcc-14-dev \
    libgcc-s1 \
    libgmp10 \
    libisl23 \
    libmpc3 \
    libmpfr6 \
    libstdc++6 \
    libzstd1 \
    zlib1g \
"

RPROVIDES = " \
    c-compiler-x86-64-linux-gnu \
"
