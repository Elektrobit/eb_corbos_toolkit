# This was autogenerated! Do not modify
SUMMARY = "GNU C++ compiler"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "gcc-14"
HOMEPAGE = "http://gcc.gnu.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gcc-14/g++-14_14.2.0-19_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gcc-14/g++-14_14.2.0-19_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "89a1ca982d17942fea5d8a5a6c9faeca"
SRC_URI[deb0.sha1sum] = "de29e541c6398dde3fa1bddc01dae89b95f103b5"
SRC_URI[deb0.sha256sum] = "4706ab29eab3d81e93582b45b229fdedc71f1eec3071996a448cf2c8beb83f3a"
SRC_URI[deb0.sha512sum] = "91ce41f4af44fc33c97faafeb2370665abcdb2c08306d00c2f04833bc55d66109adebff235e54425ba8cb3024a846580a7fa3677e0909f05f6f83a282989b603"
SRC_URI[deb1.md5sum] = "4fa0588a1435e0fd3d2f43204caa2e2a"
SRC_URI[deb1.sha1sum] = "cb4bc2b344dd4f3a0847bb62ec337cb1c012a635"
SRC_URI[deb1.sha256sum] = "f4813643994aa96c527e687c9c7d01855aa5fdd86e63cc8bd05c63ecc9373796"
SRC_URI[deb1.sha512sum] = "2e62ea56e5849143dc448bf0271bfec7d5dee367cb59e006b183300b00f1df00297f11bf3eddbdbc5861f934a52f9a1ff4ab83c47d4b0aedd8810086949e0bab"

RDEPENDS = " \
    gcc-14 \
    gcc-14-base \
"
RDEPENDS:append:amd64 = " \
    g++-14-x86-64-linux-gnu \
"
RDEPENDS:append:arm64 = " \
    g++-14-aarch64-linux-gnu \
"

RPROVIDES = " \
    c++-compiler \
    c++abi2-dev \
"
