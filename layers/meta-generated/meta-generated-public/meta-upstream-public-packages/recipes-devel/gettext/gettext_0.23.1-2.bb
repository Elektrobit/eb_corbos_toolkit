# This was autogenerated! Do not modify
SUMMARY = "GNU Internationalization utilities"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "gettext"
HOMEPAGE = "https://www.gnu.org/software/gettext/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gettext/gettext_0.23.1-2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gettext/gettext_0.23.1-2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "6d8f9f986f0aea8e6c468c5eec642d27"
SRC_URI[deb0.sha1sum] = "02f7ff01bd28d0201105b5b408996df69d0336b7"
SRC_URI[deb0.sha256sum] = "25293e75989db79a1d4a6b942674b0e7243da54a0985f8d9df1b345d255d262b"
SRC_URI[deb0.sha512sum] = "7e95d21d8260b5e88b473f4bed868cb1c25bde4916ec29e22cc9e2c8917c9373eeab9715cd6eb75c0d119b465b7a6158594c0d1e7c9d3947705d51da2ee59f0e"
SRC_URI[deb1.md5sum] = "9c2165fcdeae83b2f95ff490aa28f50b"
SRC_URI[deb1.sha1sum] = "58f281a4580867f4aa4d8457088b72f5237171d2"
SRC_URI[deb1.sha256sum] = "3eb171ecf06e9e72f1cd55aa280e5097beb3d8171f5e6456050c7e855247414e"
SRC_URI[deb1.sha512sum] = "0dc639087e2e2311c089f9b971dcdfe440da2032ddec6b8c69f4fcaa2c613512436ad403771a00401b4f32b761f103a5577a1069d9b32baca8cadfcbda0f0b37"

RDEPENDS = " \
    gettext-base \
    libacl1 \
    libattr1 \
    libc6 \
    libgomp1 \
    libtinfo6 \
    libunistring5 \
    libxml2 \
"

