# This was autogenerated! Do not modify
SUMMARY = "DWARF compression tool"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "dwz"
HOMEPAGE = "https://www.sourceware.org/dwz/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/d/dwz/dwz_0.15-1+b1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/d/dwz/dwz_0.15-1+b1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "427aade9d89b46f59cc1c25512e53d96"
SRC_URI[deb0.sha1sum] = "785d98c02f469c07263905d291be5f1e95d0f4eb"
SRC_URI[deb0.sha256sum] = "ad9f7205d8b951a7456511b9c8ed24b4a3571c403ef4e328400c96b31784dd15"
SRC_URI[deb0.sha512sum] = "3fd982894f04d68ac3f87c951d4db4b01b265806c044b36ddf6f0c0e5590ebcfa029d819b27d7efb667d3388b4745850b3a56984d5f979da57bf284dfe822f3e"
SRC_URI[deb1.md5sum] = "e9bc11f7c840d82086b300ba0db9a5ba"
SRC_URI[deb1.sha1sum] = "61456511e03820afe4371f4418e0f17f52227ab8"
SRC_URI[deb1.sha256sum] = "366f6e31c28897febc5bdae5532de3f64ce268c32f8c4e5986842d25e23b8bbf"
SRC_URI[deb1.sha512sum] = "1aa401f30aa541fdd418b743e99f80310bb01af9517fd88995bda434d2ebf5ee8c5309bd2d96545c7d01813be5c5f49d4a80af66dc59b09eac3e3ce756ae6762"

RDEPENDS = " \
    libc6 \
    libelf1t64 \
"

