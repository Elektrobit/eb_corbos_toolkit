# This was autogenerated! Do not modify
SUMMARY = "Linux Kernel Headers for development (for cross-compiling)"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "cross-toolchain-base"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/c/cross-toolchain-base/linux-libc-dev-amd64-cross_6.12.38-1cross1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "595e0311fccd3ae23d4f4ce1ee3c08b8"
SRC_URI[deb0.sha1sum] = "a0fb3fadfb03ff7c527361719e49512925465303"
SRC_URI[deb0.sha256sum] = "da463ddd3ee96b37c33f16da99c47b03b4e514888d3d853e73253ee73bd0d7d8"
SRC_URI[deb0.sha512sum] = "3c49fe3dd46f3811bc28920037327c41004b951c6607c75beb495e4116046bcbe059c338e3f94f32a837be2dc4f22e0fa9ddab3de7746f1758ee091ecce803e5"


RPROVIDES = " \
    linux-kernel-headers-amd64-cross \
    linux-libc-dev-amd64-dcv1 \
"
