# This was autogenerated! Do not modify
SUMMARY = "configuration to enable the Debian debug info server"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "elfutils"
HOMEPAGE = "https://sourceware.org/elfutils/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/e/elfutils/libdebuginfod-common_0.192-4_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "ca6ba9a1f788b839f16e0d909227ac90"
SRC_URI[deb0.sha1sum] = "4962f48f14a54e4e4ad83cdcd45416831e10173a"
SRC_URI[deb0.sha256sum] = "3c775d164b26fc5e8fb1a3606b3de99875cf8ee6e2d9a90018c4d82de2d47f7b"
SRC_URI[deb0.sha512sum] = "3a0cee1726426a8f46b8ea0a3f461fc3a916508cfeb3950a165e6a3858c52e3caa4d57488a0b26b6bd16607f9c1f11d6d2f15a916ded4b51e39edeb547c79b0e"

RDEPENDS = " \
    debconf \
    ucf \
"

