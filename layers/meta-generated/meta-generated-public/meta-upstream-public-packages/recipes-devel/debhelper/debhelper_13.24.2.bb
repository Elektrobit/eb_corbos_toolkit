# This was autogenerated! Do not modify
SUMMARY = "helper programs for debian/rules"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "debhelper"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/d/debhelper/debhelper_13.24.2_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "640ee9eb9c9df30cff5962020170f33a"
SRC_URI[deb0.sha1sum] = "7d5a9c212f57d84a3bd319a2407791b611707dce"
SRC_URI[deb0.sha256sum] = "04ba78ad4363df4f47cac2667dcca7a4bfe520625af5799ec1ede3cb6551f6fc"
SRC_URI[deb0.sha512sum] = "a03f9942b8adcd7b5bd8989481882a780721448b0fd74be0ebedef76519bb40ef0dbc9270cf5c52f146bf4a7281efbdfd29a7e433bf961538ef2fb2143369987"

RDEPENDS = " \
    autotools-dev \
    dh-autoreconf \
    dh-strip-nondeterminism \
    dpkg \
    dpkg-dev \
    dwz \
    file \
    libdebhelper-perl \
    libdpkg-perl \
    man-db \
    perl \
    po-debconf \
"

RPROVIDES = " \
    debhelper-compat \
    dh-buildinfo \
    dh-sequence-dwz \
    dh-sequence-elf-tools \
    dh-sequence-installinitramfs \
    dh-sequence-installsysusers \
    dh-sequence-movetousr \
    dh-sequence-single-binary \
    dh-sequence-systemd \
"
