# This was autogenerated! Do not modify
SUMMARY = "Tooling to work with remote images registries"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "skopeo"
HOMEPAGE = "https://github.com/containers/skopeo"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/skopeo/skopeo_1.18.0+ds1-1+b5_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/skopeo/skopeo_1.18.0+ds1-1+b5_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "fd346b913e957f0bbc86016c84579862"
SRC_URI[deb0.sha1sum] = "d58b9d3697d9855ab52ef4add3894108cb3fc97b"
SRC_URI[deb0.sha256sum] = "7ca44a3f31f3cddca9d9dc858029dd08c30faf6e93456753825509e6a59192e2"
SRC_URI[deb0.sha512sum] = "9f88056e6a877391b8f105860c98c2b917b501b91b84af343178842541032f1cad1bdb23662b667e3208e09a22e55b5b56a3e9cd015b9d7903895f2938fae748"
SRC_URI[deb1.md5sum] = "d45079c5b5fe1ddc05edfbf86c71819f"
SRC_URI[deb1.sha1sum] = "6ba05b2fa1f29d53b15b24e2fd4d8ba501afbf56"
SRC_URI[deb1.sha256sum] = "e11dd691d30ebc4c9af5628bb412dfb58c0c58bfc8ec8f38ee5bcb2c870b38b8"
SRC_URI[deb1.sha512sum] = "834d62c2879beac6974c19450873874ef3518994c2503e2f77ae1a9572169914334e953e4323ca93b299ae7f09a5a4d86f13844a6c08325c30cd365151ffeb1e"

RDEPENDS = " \
    golang-github-containers-common \
    libc6 \
    libgpgme11t64 \
    libsqlite3-0 \
"

