# This was autogenerated! Do not modify
SUMMARY = "Informational list of build-essential packages"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "build-essential"
HOMEPAGE = ""

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/b/build-essential/build-essential_12.12_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/b/build-essential/build-essential_12.12_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "e82c51bf7ee81f69363728c65d063443"
SRC_URI[deb0.sha1sum] = "a1f3edfc9367fa57d0bb09f81b86853ece2d5d15"
SRC_URI[deb0.sha256sum] = "a45159aebea0d98d6652ac5a56b7fff164a7733a7dc736b9f8715ca504519d3a"
SRC_URI[deb0.sha512sum] = "aedf328b841e8f1ea0b8379a0843f90c93f12eb37583ba3275912242ff549978ce14e46e1f94326107e03fb5b5a2a7ce8cf7d017b0d73df9440bf8bdd05a5fa8"
SRC_URI[deb1.md5sum] = "f05c25ec88e6299cf2aca6ff1e1fb6f1"
SRC_URI[deb1.sha1sum] = "04578ab5347a0145ff8727c6a29d4c528cc89393"
SRC_URI[deb1.sha256sum] = "3278c93c699f9c12b6f7fe8e03393aa50d1c6b1c4b35da8f15b1c7bae67dc961"
SRC_URI[deb1.sha512sum] = "f0a65478ac17c40d3f27f4e4508bddf656230a10bea016864a322533666ca42a07c97c91c422feb069d218b0510c0a790358c000a53295ff8d7299806a4fcf88"

RDEPENDS = " \
    dpkg-dev \
    g++ \
    gcc \
    libc6-dev \
    make \
"

