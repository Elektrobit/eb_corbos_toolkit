# This was autogenerated! Do not modify
SUMMARY = "Informational list of cross-build-essential packages"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "build-essential"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/b/build-essential/crossbuild-essential-amd64_12.12_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "5df04c7b29227dc447c52e0f060eb475"
SRC_URI[deb0.sha1sum] = "c1b5f757b13f73ff8594853467faff0efd0cc0ba"
SRC_URI[deb0.sha256sum] = "3c316474fc834c1ed713cbcdfcf896835a0b2f092c40f54ac80bdb139954944d"
SRC_URI[deb0.sha512sum] = "52de62aef7189b49cfabf106c037b743aa35f4bc0bb7949d9efb85ed3eb67c8791726b263caafdcc9fbe660c0b624a8340f42fe30b22e108131994e371c929b4"

RDEPENDS = " \
    g++-x86-64-linux-gnu \
    gcc-x86-64-linux-gnu \
"

