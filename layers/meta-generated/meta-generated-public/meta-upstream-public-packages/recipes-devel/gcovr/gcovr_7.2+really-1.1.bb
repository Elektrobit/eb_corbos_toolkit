# This was autogenerated! Do not modify
SUMMARY = "Manages the compilation of coverage information from gcov"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "gcovr"
HOMEPAGE = "http://gcovr.com/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gcovr/gcovr_7.2+really-1.1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "8c08819d860ba6d59440636ee4bc23ae"
SRC_URI[deb0.sha1sum] = "fbdf378f14f31802048756ae6b8cf730ec24dd64"
SRC_URI[deb0.sha256sum] = "762e2395cba4f766fe1efa73d4d973cefae9254c63bb347b1187e2b884847d6d"
SRC_URI[deb0.sha512sum] = "0e30d489ee4034f52e73eca005baaa83598ee9814d7ae276ed48097012a34d66599c849986d04b1d54042ab7c1420e028342048fd15c43621702fb7899a990f1"

RDEPENDS = " \
    python3 \
    python3-colorlog \
    python3-jinja2 \
    python3-lxml \
    python3-pkg-resources \
    python3-pygments \
    python3-tomli \
"

