# This was autogenerated! Do not modify
SUMMARY = "small build system closest in spirit to Make"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "ninja-build"
HOMEPAGE = "https://ninja-build.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "amd64"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/n/ninja-build/ninja-build_1.12.1-1_amd64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "d00406fa6137245b1b5d7af712fbe6d4"
SRC_URI[deb0.sha1sum] = "a71877399d96f10037463ec88513fc32fe9ec76a"
SRC_URI[deb0.sha256sum] = "bc172ce9270bd6fcd6d5335a83ff9d3c7ba0d13ec624cfdfa1b5aa06901dc453"
SRC_URI[deb0.sha512sum] = "5564794b3ee8c0576fb018c148b2ab66d64eec4d2bf79d48c1a3da7518af71a83046e6691560c1a2a7ec6cc5a74230f05baad097ca82d7490f9874bbd67d0372"

RDEPENDS = " \
    libc6 \
    libgcc-s1 \
    libstdc++6 \
"

