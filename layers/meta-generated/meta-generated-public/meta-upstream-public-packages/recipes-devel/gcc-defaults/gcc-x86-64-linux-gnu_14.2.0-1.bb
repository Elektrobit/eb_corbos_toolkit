# This was autogenerated! Do not modify
SUMMARY = "GNU C compiler for the amd64 architecture"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "gcc-defaults"
HOMEPAGE = ""

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gcc-defaults/gcc-x86-64-linux-gnu_14.2.0-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gcc-defaults/gcc-x86-64-linux-gnu_14.2.0-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "70a7403639e33049a8f87ad2833aee04"
SRC_URI[deb0.sha1sum] = "d04a7083effc3294a82a6db9f050f69bdf1b5adf"
SRC_URI[deb0.sha256sum] = "04c28c2760b0094b3d7758154ac095303dd00599b63ebad4086a325b607308b7"
SRC_URI[deb0.sha512sum] = "1080aeec08ea86ce5a9933b97939998ea05af0686477a570add7691a7cc88d757966cad8c6277cfe066937a6ffb9b7908a74e722e959c3665bd696e5fbc18504"
SRC_URI[deb1.md5sum] = "851ae1fa22fe107f5d4f2d9cb08f187c"
SRC_URI[deb1.sha1sum] = "c8a41521f5756800340b8d74929f2d28f2146f91"
SRC_URI[deb1.sha256sum] = "05778bc7a3f0f5a85dd50f865bf88ea5b160e22d429de445f90b2c5ff28e9d25"
SRC_URI[deb1.sha512sum] = "0240c10a57036a10c72bc1d70bf4061ee441db5278c2c855fa82d8888d0cb929c5ebc7b06fd7c770a3c17f5605c9bfc5e0c5d5af24b6ea5160c4371d28934f7b"

RDEPENDS = " \
    cpp-x86-64-linux-gnu \
    gcc-14-x86-64-linux-gnu \
"

