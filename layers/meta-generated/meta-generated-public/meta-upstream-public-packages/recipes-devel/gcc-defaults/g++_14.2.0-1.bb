# This was autogenerated! Do not modify
SUMMARY = "GNU C++ compiler"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "gcc-defaults"
HOMEPAGE = ""

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gcc-defaults/g++_14.2.0-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gcc-defaults/g++_14.2.0-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "995fd0e145217384a37c334812e51f27"
SRC_URI[deb0.sha1sum] = "c443c0c0f2742f280607b603b6d62a2ae6c2743d"
SRC_URI[deb0.sha256sum] = "f86661c021ab2acb39ceb87315e7c2d4d420fdadc19945d5d589f3953410445c"
SRC_URI[deb0.sha512sum] = "79a76be1b3e86aa68f51a7db9d5b173343fb6545809be9a64721b31e88aefb7ccdfc39c91df0301895a208a55e3df951f6c523c79706eb66672b0dbe8574b1a1"
SRC_URI[deb1.md5sum] = "004aea5ce3a9b5bb985bde7c175751d6"
SRC_URI[deb1.sha1sum] = "4354d08a72129f98b890adbfededafcf44224a59"
SRC_URI[deb1.sha256sum] = "e4b8f8fae7c838c40b9db29251b152c9af03a4d4463388d69efdda66c4e97e79"
SRC_URI[deb1.sha512sum] = "ef3fbf053047bfbf78eb89ff95e83f028023f026f4ab0f3593d022cb8adf13f3b3a76835e09005f101e0d9654e1209a90d92727ebfaaf5ff54fd923f4bb4d62b"

RDEPENDS = " \
    cpp \
    g++-14 \
    gcc \
    gcc-14 \
"
RDEPENDS:append:amd64 = " \
    cpp-x86-64-linux-gnu \
    g++-x86-64-linux-gnu \
"
RDEPENDS:append:arm64 = " \
    cpp-aarch64-linux-gnu \
    g++-aarch64-linux-gnu \
"

RPROVIDES = " \
    c++-compiler \
"
