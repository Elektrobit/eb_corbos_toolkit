# This was autogenerated! Do not modify
SUMMARY = "GNU C compiler"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "gcc-defaults"
HOMEPAGE = ""

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gcc-defaults/gcc_14.2.0-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gcc-defaults/gcc_14.2.0-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "222be33eae2b6768bbbedd4ef959fa3e"
SRC_URI[deb0.sha1sum] = "23aea262d2c56a31d6557ffe3c1a23c77772d304"
SRC_URI[deb0.sha256sum] = "eee65c41a441c57c05f754ced1b9d093956966a1c7da9938c3ec00d3dc2f905d"
SRC_URI[deb0.sha512sum] = "5ad6e33e207907ed0aca99204757d612ce67e174584c7b7aa4063c05f39753175538981d4100b9859b97cba0ee6e1fa84c3c52410c12ffa9f3a14c2b57a8337b"
SRC_URI[deb1.md5sum] = "3118deabc9b64d33934035d3fddfada1"
SRC_URI[deb1.sha1sum] = "a270555daf6a65b084fea556391ef05b527ad626"
SRC_URI[deb1.sha256sum] = "f543b52e29a6780a78c73cf08e551e8e524d623c1092c477cfd8beb5285a86f5"
SRC_URI[deb1.sha512sum] = "3889d67a1afea651cc650123ec05b4e1b0ff949e50692abf880510d9311dd38fb767fb5ac3188d5f44caaa136f6b3e5dd3d0d902e8f57aa17d38328dc2ea6df9"

RDEPENDS = " \
    cpp \
    gcc-14 \
"
RDEPENDS:append:amd64 = " \
    cpp-x86-64-linux-gnu \
    gcc-x86-64-linux-gnu \
"
RDEPENDS:append:arm64 = " \
    cpp-aarch64-linux-gnu \
    gcc-aarch64-linux-gnu \
"

RPROVIDES = " \
    c-compiler \
"
