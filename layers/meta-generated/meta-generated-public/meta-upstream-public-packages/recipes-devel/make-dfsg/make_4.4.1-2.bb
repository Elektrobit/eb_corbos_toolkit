# This was autogenerated! Do not modify
SUMMARY = "utility for directing compilation"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "make-dfsg"
HOMEPAGE = "https://www.gnu.org/software/make/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/m/make-dfsg/make_4.4.1-2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/m/make-dfsg/make_4.4.1-2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "350a0c1b4b19d2ea8d2ff98ba42a54da"
SRC_URI[deb0.sha1sum] = "22d70a0fdb62bb5301a59e3cf0b5ce66f3868009"
SRC_URI[deb0.sha256sum] = "70a9709e665383b06068ccd423d62ea191b65355f318a25565dbf324b254cec6"
SRC_URI[deb0.sha512sum] = "b899dee2aabee345ad73c6d8ff6797a37be4f92c88600a7573cf52e08b02b0adce8d0a93bd77f1771f49b9ad193c9746f4423c3eff8f0b704b46b8d265438225"
SRC_URI[deb1.md5sum] = "27504deae28b21e28c58632d9387014a"
SRC_URI[deb1.sha1sum] = "92538e8464b0c97b051f4674dcba32ddd5023f55"
SRC_URI[deb1.sha256sum] = "043219839669c431def9bb410c4a827f115ee5bf377469d55c4ed905f81f73be"
SRC_URI[deb1.sha512sum] = "e8ee4656d3aba666def960e3d131888bfe096eab8101f1b62b04dac9b5e90d790f359b24ce49d7985f7d0ecd10af5033b7380481bb1e5ac00aeb71b124f1c8cb"

RDEPENDS = " \
    libc6 \
"

