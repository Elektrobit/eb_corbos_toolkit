# This was autogenerated! Do not modify
SUMMARY = "cross-platform, open-source make system"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "cmake"
HOMEPAGE = "https://cmake.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/c/cmake/cmake_3.31.6-2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/c/cmake/cmake_3.31.6-2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "85582ec55dbba01f105d78bcdb9ac9ad"
SRC_URI[deb0.sha1sum] = "e6d3ca251ed02e00fdf6155719d523e18bac7251"
SRC_URI[deb0.sha256sum] = "dee2fc94973325240604ffbca677a3f16b462fb6520946bd81be1ecbac770a02"
SRC_URI[deb0.sha512sum] = "754a1f0e4d9ab461f2526b9ab697a1fd8b6cca873364ec68f0736e7bd9fbb77b5d727a71ecf3b7f67867be5af6f6343ee09cfc2f12b31ea94a83cc258e471bfd"
SRC_URI[deb1.md5sum] = "11c1eb1fb87d86dac946ca3ba869d0fd"
SRC_URI[deb1.sha1sum] = "2fe7008388e1bb8d42db32865f0e40e53d622aee"
SRC_URI[deb1.sha256sum] = "983aa00debd072f7bfae69f93b1b9e4628da0a914c3745b9022e4cd60215493b"
SRC_URI[deb1.sha512sum] = "65db0c306f56ba7b26aa6e2d02d1fad9cabedea2d4bca98d5eb753af36c262d13438b4be4ce2f983f4e424907b9655323272b075db531a03478192258b68ac77"

RDEPENDS = " \
    cmake-data \
    libarchive13t64 \
    libc6 \
    libcurl4t64 \
    libexpat1 \
    libgcc-s1 \
    libjsoncpp26 \
    librhash1 \
    libstdc++6 \
    libuv1t64 \
    procps \
    zlib1g \
"

