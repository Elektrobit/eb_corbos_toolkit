# This was autogenerated! Do not modify
SUMMARY = "Help i18n of RFC822 compliant config files"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "intltool-debian"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/i/intltool-debian/intltool-debian_0.35.0+20060710.6_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "e02891cff3d522b54477df07f67d19fb"
SRC_URI[deb0.sha1sum] = "ed449d06d1e84c56deb2487977971e46ba5cf699"
SRC_URI[deb0.sha256sum] = "058900c66cbc0d8b60139bdecc9a06cb9c3b479a03117354a78e5fa72aecd90c"
SRC_URI[deb0.sha512sum] = "7f59b34b3fe4aab11394bb657ec7bd743954d586e3ef185140e23421490e02964367c1eabb9fc072c95d19d52e817450841439b965c8ca990b8aaa276a4e15fa"

RDEPENDS = " \
    gettext \
    perl \
"

