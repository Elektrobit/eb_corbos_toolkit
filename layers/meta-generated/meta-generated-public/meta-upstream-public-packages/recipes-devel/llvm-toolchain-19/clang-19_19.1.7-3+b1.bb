# This was autogenerated! Do not modify
SUMMARY = "C, C++ and Objective-C compiler"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "llvm-toolchain-19"
HOMEPAGE = "https://www.llvm.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/l/llvm-toolchain-19/clang-19_19.1.7-3+b1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/l/llvm-toolchain-19/clang-19_19.1.7-3+b1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "6d740b5602fc3c82d834fdbba9c0983c"
SRC_URI[deb0.sha1sum] = "9d79fd4d965b6d51fe4f09f23cacf5be9b1383a4"
SRC_URI[deb0.sha256sum] = "bbb74458d782b7792b61b0eed92746df5e6d033778c045cf8c2b3835b7c4efc4"
SRC_URI[deb0.sha512sum] = "d1649d7c62b1e281d942f0a7c97baee06d4dc86d6ee4b82bb6231e6e1fe69b88a039063949b5f9a159544f60fdb6bde3a9e661a48d4d669ad3ed3c349b80418b"
SRC_URI[deb1.md5sum] = "7f6241b630a6bdba93fd194198c43016"
SRC_URI[deb1.sha1sum] = "10ab922566cfc2fa8a08b0401eb211d839b74d7d"
SRC_URI[deb1.sha256sum] = "4cb5d48c887e0c1071a058ae8eb30540db77379be50388fcd6b3f9ad1016d54c"
SRC_URI[deb1.sha512sum] = "280026465c905d4e8c874d0bb0f554cc5411aa5bdd22ae5a235c169965b790e44c10a773ba1ac8f5bf17ea7f205f6c246b4da9998b4d8765382fe28d66e694bc"

RDEPENDS = " \
    binutils \
    libc6 \
    libc6-dev \
    libclang-common-19-dev \
    libclang-cpp19 \
    libclang1-19 \
    libgcc-14-dev \
    libgcc-s1 \
    libllvm19 \
    libobjc-14-dev \
    libstdc++-14-dev \
    libstdc++6 \
    llvm-19-linker-tools \
"

RPROVIDES = " \
    c++-compiler \
    c-compiler \
    objc++-compiler \
    objc-compiler \
"
