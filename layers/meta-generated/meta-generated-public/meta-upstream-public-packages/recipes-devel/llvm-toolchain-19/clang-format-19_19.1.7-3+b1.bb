# This was autogenerated! Do not modify
SUMMARY = "Tool to format C/C++/Obj-C code"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "llvm-toolchain-19"
HOMEPAGE = "https://www.llvm.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/l/llvm-toolchain-19/clang-format-19_19.1.7-3+b1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/l/llvm-toolchain-19/clang-format-19_19.1.7-3+b1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "6e0be913927a6ae27da3a483870be342"
SRC_URI[deb0.sha1sum] = "a0fb5d188a195d7a61b0df065bbb966a19760cf5"
SRC_URI[deb0.sha256sum] = "25c849491d8cddc1d65e6f5f67d188a4406c5cdb8c78c490bef08c9477a4e150"
SRC_URI[deb0.sha512sum] = "98a900b03851bbec7d75c44b336c5b1f5ce2a6892b8da7a3f3e63a61e0540ca910d1bf37643cd6023f9a3eeee0622dec716ee04354076f52aeda9fa1a56339e2"
SRC_URI[deb1.md5sum] = "8f60b73f7931125b31074ebeaa5e22f6"
SRC_URI[deb1.sha1sum] = "5b63f667b885806c3889e89cb91c1e9a18a94411"
SRC_URI[deb1.sha256sum] = "1b92b2b45f258301dd9cadc85f7c6c6ff2d8dc8ad73751006564d03dcaee718a"
SRC_URI[deb1.sha512sum] = "6f09816f30524bedcf33bc07218f07b9df072967cb25a10503a31197e98a2e25daa057c171aa3ac7cfe8d9f54d1665cedf333577ed27b0d823a9cc347e488b51"

RDEPENDS = " \
    libc6 \
    libclang-cpp19 \
    libgcc-s1 \
    libllvm19 \
    libstdc++6 \
    python3 \
"

