# This was autogenerated! Do not modify
SUMMARY = "Modular compiler and toolchain technologies - Plugins"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "llvm-toolchain-19"
HOMEPAGE = "https://www.llvm.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/l/llvm-toolchain-19/llvm-19-linker-tools_19.1.7-3+b1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/l/llvm-toolchain-19/llvm-19-linker-tools_19.1.7-3+b1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "eda1f4644e7ad8ce9b2658058c1dc1ac"
SRC_URI[deb0.sha1sum] = "1c5bbac1e7938a5d6b5fff63287879ccf61fd18f"
SRC_URI[deb0.sha256sum] = "874a0a5cde797cda3e94e9310a0a9958608f526f177637414a8ce9620c804818"
SRC_URI[deb0.sha512sum] = "b9c4372bdf4fcd82f7906c4b5db74e34111a9b2b990ea2e0526eb2bc6dd1947c3e26307e0030c7b13e3c3522cd6cea2f34f65c041a65715aa76a937c75c309de"
SRC_URI[deb1.md5sum] = "becebceecde2e4758700e5191d9f880a"
SRC_URI[deb1.sha1sum] = "3a5563a6f15e442b45179980538d810d270913b5"
SRC_URI[deb1.sha256sum] = "2538a8ea604718a02cae7ffab7ee2d537fab2e5eed256584a0bd475bddc3da39"
SRC_URI[deb1.sha512sum] = "621bc1ea0560282696b2efe72fd42ccfbb3d1e229e1acb964e35e03bc12afc8640a9b5a9ea51d0e0d6b9741695b505bd248289b03b76f50fe9de3e9e3a082655"

RDEPENDS = " \
    libc6 \
    libgcc-s1 \
    libllvm19 \
    libstdc++6 \
"

