# This was autogenerated! Do not modify
SUMMARY = "LLVM-based linker"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "llvm-toolchain-17"
HOMEPAGE = "https://www.llvm.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/l/llvm-toolchain-17/lld-17_17.0.6-22+b2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/l/llvm-toolchain-17/lld-17_17.0.6-22+b2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "28377876ce641c36a47a9a327e8b581f"
SRC_URI[deb0.sha1sum] = "9350b24de412ec30976aaac10e2c3dccdabf8922"
SRC_URI[deb0.sha256sum] = "086d6dc39a3a551c833e30946c02d427e886ab760f0233a29e2cc5c0e6f7b146"
SRC_URI[deb0.sha512sum] = "6a4db1f431ea2f16de7337056818543d697166509922b12bd41b095491c896502459ab60f6f4a0a0e540ee4fcef175aea5971af97e35010c5999f2bfebbfeb2f"
SRC_URI[deb1.md5sum] = "c7c6ac773bd5e61597ac7bf807011ef9"
SRC_URI[deb1.sha1sum] = "9625170b787e1310b1397e6adfc591d7a513e294"
SRC_URI[deb1.sha256sum] = "7670ab06dbd1ed639568150ea4df06fd5ff36bc463ffe088e6178bf3ff33ab6e"
SRC_URI[deb1.sha512sum] = "ddcf4fe9de08275b30e0135d4537dd637385ae8797a0e6fe7ea83363d089b9e20b7a1575e58226f9ffb1ed464be4afdd156bd94c4e36049586c9127b885f9cea"

RDEPENDS = " \
    libc6 \
    libllvm17t64 \
    libstdc++6 \
    libzstd1 \
    zlib1g \
"

