# This was autogenerated! Do not modify
SUMMARY = "C, C++ and Objective-C compiler"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "llvm-toolchain-17"
HOMEPAGE = "https://www.llvm.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/l/llvm-toolchain-17/clang-17_17.0.6-22+b2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/l/llvm-toolchain-17/clang-17_17.0.6-22+b2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "dec6f69f923f95c6dbe2cf8a0b5c8ad9"
SRC_URI[deb0.sha1sum] = "c1821ad9941c4362f10e1b615e33195437a53347"
SRC_URI[deb0.sha256sum] = "22892d7d2af1084131153600611d7abb3a9fa475c28ae36c548fc7fb377b9de5"
SRC_URI[deb0.sha512sum] = "0fce83b8956774826c0fdeed1694de8bc8e8136a9b71581fc49ff3697784c617505c90999a22144a68ebd7019d9eecd3025a9c446f4d37ad0ec3ac6d3fa2a9cf"
SRC_URI[deb1.md5sum] = "31cbc366452aaf4f80addb2bc050c098"
SRC_URI[deb1.sha1sum] = "46f29e793627982a12178dcf31ed2532803ad87a"
SRC_URI[deb1.sha256sum] = "278643064666c94766f55e8e5f19aa514aab15d5c85e8471145ebdc98b3f7e8c"
SRC_URI[deb1.sha512sum] = "d5fecb0ca9ce40981e558a74c6580e81103dd4b674eb802822cee599d8ca78612bc6cbdac511d7d405e8885f078a354517072c0f24c9fa9930795a6cfd1191c1"

RDEPENDS = " \
    binutils \
    libc6 \
    libc6-dev \
    libclang-common-17-dev \
    libclang-cpp17t64 \
    libclang1-17t64 \
    libgcc-14-dev \
    libllvm17t64 \
    libobjc-14-dev \
    libstdc++-14-dev \
    libstdc++6 \
    llvm-17-linker-tools \
"

RPROVIDES = " \
    c++-compiler \
    c-compiler \
    objc-compiler \
"
