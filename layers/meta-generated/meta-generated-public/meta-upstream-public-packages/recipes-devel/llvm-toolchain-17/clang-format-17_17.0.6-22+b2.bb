# This was autogenerated! Do not modify
SUMMARY = "Tool to format C/C++/Obj-C code"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "llvm-toolchain-17"
HOMEPAGE = "https://www.llvm.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/l/llvm-toolchain-17/clang-format-17_17.0.6-22+b2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/l/llvm-toolchain-17/clang-format-17_17.0.6-22+b2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "e749a533aa215ad80da2f583d54fbee3"
SRC_URI[deb0.sha1sum] = "0e7809961fc66abffa8e5b70a72bf58e0a69bb46"
SRC_URI[deb0.sha256sum] = "2d8e9dae5a3ad94fa13dbdb8b48a7e67cf67409305e5ead92534b824d9a9617a"
SRC_URI[deb0.sha512sum] = "40e070c6f47fcb58cbb5528dca606552149fa287ad459aaf556e15aac4220b05684d75bf143d6a08ece8080474cb9c4a38f4075380fc3d6cfc29753294765365"
SRC_URI[deb1.md5sum] = "d4ab6f5d902a78eca3379f05c513c3f7"
SRC_URI[deb1.sha1sum] = "7814acc2644dae6713eab11de3ef1eae06bd2127"
SRC_URI[deb1.sha256sum] = "f26756fe4efd0c12a1a5c0de36607ebc71a8aa12c8ecc02448622de878d22542"
SRC_URI[deb1.sha512sum] = "27edc2633e0a2f67afb07efac8101d0ebe1459c07f6a1af4ca2aac128024116ab73208c8036feb4c08b2bd5eb155e454664b372b78ba21a9bf177b1e74a174d0"

RDEPENDS = " \
    libc6 \
    libclang-cpp17t64 \
    libllvm17t64 \
    libstdc++6 \
    python3 \
"

