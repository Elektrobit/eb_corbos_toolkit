# This was autogenerated! Do not modify
SUMMARY = "Modular compiler and toolchain technologies"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "llvm-toolchain-17"
HOMEPAGE = "https://www.llvm.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/l/llvm-toolchain-17/llvm-17_17.0.6-22+b2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/l/llvm-toolchain-17/llvm-17_17.0.6-22+b2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "fc1cf9b01249eda3118519b216295a7a"
SRC_URI[deb0.sha1sum] = "851af9421efd2e7f5ccb66d4b31ce6c37590a20b"
SRC_URI[deb0.sha256sum] = "b7fc9dc915f42c52800f35177b3e5bf9cb74c904377985497a22df6595a685f6"
SRC_URI[deb0.sha512sum] = "ae06333b7f378b3f5e73974cc93aa83670bd514ba60cbbed58602c33059792565d855edd66f86443655c80360f90a7feefc3c31d658a39d9e78b9e869998659f"
SRC_URI[deb1.md5sum] = "7949d9f8984baf8d6d9ff781552b2de0"
SRC_URI[deb1.sha1sum] = "c1f6dc5406e8a8d3dbd9542511e85a4198773ebc"
SRC_URI[deb1.sha256sum] = "2b41fb189d7cc3c6d9fb7e61948ce10322f98a26fe7d53a904037d8c74209467"
SRC_URI[deb1.sha512sum] = "7aaf6316b9e9766c586a2a1d2bb84c7d6dd87650ea41cf63e164bd6497cdb545aa25442a460ee75cf567b81ac3def358a8abd503ca94bbbdf463b79474136eaa"

RDEPENDS = " \
    libc6 \
    libcurl4t64 \
    libgcc-s1 \
    libllvm17t64 \
    libpfm4 \
    libstdc++6 \
    libtinfo6 \
    libzstd1 \
    llvm-17-linker-tools \
    llvm-17-runtime \
    zlib1g \
"

