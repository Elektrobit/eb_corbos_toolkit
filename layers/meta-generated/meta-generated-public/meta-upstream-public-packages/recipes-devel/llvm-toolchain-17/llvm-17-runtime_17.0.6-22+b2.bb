# This was autogenerated! Do not modify
SUMMARY = "Modular compiler and toolchain technologies, IR interpreter"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "llvm-toolchain-17"
HOMEPAGE = "https://www.llvm.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/l/llvm-toolchain-17/llvm-17-runtime_17.0.6-22+b2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/l/llvm-toolchain-17/llvm-17-runtime_17.0.6-22+b2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "e4cabb8ec2e89753605974db52af2753"
SRC_URI[deb0.sha1sum] = "1e896faf1ff0792dfce1e11cbf59a992b65f2a6b"
SRC_URI[deb0.sha256sum] = "7d3f67f7f641d9b44d5e0faa8279924bd9b5da8f03229769f275c62dcd62f50f"
SRC_URI[deb0.sha512sum] = "da166ac3c729b387223271434c105403cc951c025efc11840176d44609740d476dc1fe0e655319908124b0292b283af3d5e2188d07d933dc95ccb3592745ff5f"
SRC_URI[deb1.md5sum] = "8499aa27e84231ed8437dd78f0542009"
SRC_URI[deb1.sha1sum] = "d7f80afda38c1050f7a6a42e38fbc05aa553f508"
SRC_URI[deb1.sha256sum] = "bfb0125122be80ba4ef5372a01d62627796722c7a36305deb781c7af813b4f2c"
SRC_URI[deb1.sha512sum] = "c0a49fc8210b3126e14824ff7f98376a9f7349aca8806fdcfcb82459807f05d3ac2e1a6a3ca7e6a5327dbcdcffb140ece15302a13ebe6adb19b7dc2794407808"

RDEPENDS = " \
    libc6 \
    libgcc-s1 \
    libllvm17t64 \
    libstdc++6 \
    libtinfo6 \
"

