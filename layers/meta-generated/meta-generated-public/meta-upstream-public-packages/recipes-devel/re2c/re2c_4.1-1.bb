# This was autogenerated! Do not modify
SUMMARY = "lexer generator for C, C++, Go, Java, Python, Rust, and others"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "re2c"
HOMEPAGE = "https://re2c.org"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/r/re2c/re2c_4.1-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/r/re2c/re2c_4.1-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "b568b5404c581d9ecaf2c30748588b14"
SRC_URI[deb0.sha1sum] = "43f988c429184b7431b78dbaf3737edd46630e5d"
SRC_URI[deb0.sha256sum] = "51526cd228f45a1e137412ac2ab52b2304ee149cbcbbd622bb06c8356a841f04"
SRC_URI[deb0.sha512sum] = "3fba092eb199bc21913f04541ed13ebfaa8b9ccaa4e83f09bb4e8353cb00950839bef0b93fa072c655c66ad5e0f934e1a6a32a2aeabb46eca340323fb7cd7fc2"
SRC_URI[deb1.md5sum] = "fafd22aeebd967ca4c4439031162a145"
SRC_URI[deb1.sha1sum] = "fb7dd9e552eeca52c5638b80e6c7d74788969014"
SRC_URI[deb1.sha256sum] = "19c29caea52371f7d660a2ab12c0888d09632371c3ea03f28dcbc96578a30318"
SRC_URI[deb1.sha512sum] = "4b5f6c91f117d9582a2cf4c8b35a67c6dcabe187bd833712e9ee354233d63422ed6109d1133d4fa9618520b36aa7bf4fc57364acfa6808bccc490af4cb376de1"

RDEPENDS = " \
    libc6 \
    libgcc-s1 \
    libstdc++6 \
"

