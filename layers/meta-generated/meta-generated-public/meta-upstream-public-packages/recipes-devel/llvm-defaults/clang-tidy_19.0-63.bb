# This was autogenerated! Do not modify
SUMMARY = "clang-based C++ linter tool"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "llvm-defaults"
HOMEPAGE = ""

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/l/llvm-defaults/clang-tidy_19.0-63_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/l/llvm-defaults/clang-tidy_19.0-63_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "0c60a6fdc511adac83576ad8e4b29b05"
SRC_URI[deb0.sha1sum] = "789a42b313270499b0a9ab979dcf8360462f0b96"
SRC_URI[deb0.sha256sum] = "1f232fd990659d444af050ee4d8ddc4de18defb7821867139c8388670fe10970"
SRC_URI[deb0.sha512sum] = "056825818445375b211f32c015f49d1690ac48b34873eac308ad6359dd066009d4bd2f445dc26f7829fd0cd8583927507746c767f2320226f5e9c55035b9588b"
SRC_URI[deb1.md5sum] = "066e9676f4735b505d6b80f4ced693ce"
SRC_URI[deb1.sha1sum] = "76e304e9876d137f8418e827101c88ace49c64f9"
SRC_URI[deb1.sha256sum] = "024391ce238325b0ef43448c4bc7a8dab22574dd0c48f5e6ad5cad88dbf8d727"
SRC_URI[deb1.sha512sum] = "0b86baa27ea6fa4e0110e170056a58e37fdc35393495ff745b2ff4264eb04be29c06eaa723a134507db09ebde96bb17603e56709e508bacc518b3206c255b164"

RDEPENDS = " \
    clang-tidy-19 \
"

