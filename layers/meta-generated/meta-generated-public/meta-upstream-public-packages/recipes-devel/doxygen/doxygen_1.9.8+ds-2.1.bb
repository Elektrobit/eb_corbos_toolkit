# This was autogenerated! Do not modify
SUMMARY = "Generate documentation from source code"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "doxygen"
HOMEPAGE = "https://www.doxygen.nl/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/d/doxygen/doxygen_1.9.8+ds-2.1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/d/doxygen/doxygen_1.9.8+ds-2.1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "17b0976c9470e21349deabfe92ab9ad3"
SRC_URI[deb0.sha1sum] = "7f21fddc4e47df03ea3e21dadce9cf4af4841828"
SRC_URI[deb0.sha256sum] = "9cc450ed7b3fa48618c7f4ec7a2b48d5ab84f9aeb74294cbb1d906b76e7d505c"
SRC_URI[deb0.sha512sum] = "ae6312fdaff5e48c22490d816b183950b6fc254897e86f83d052b948e47aec7bde54cf5f580dc2d1344efa41fb36f01da2c3c483b6d8ac3562ec0998a1bb7791"
SRC_URI[deb1.md5sum] = "c64cc558f84b1845544889c9d1e58976"
SRC_URI[deb1.sha1sum] = "237483d14648e92cb69dc852c10be3cfbd78f67b"
SRC_URI[deb1.sha256sum] = "19be7c73edc995668f6722be219d98b468874894066fd873e9ca19b22997f333"
SRC_URI[deb1.sha512sum] = "384c27bee32cd503696d5b2366306dfcf77979629633f333aa5a9994eabb5d97fa5d212d4b7a47470e617cc77ee5c23efcee021dc31226ab93b20c6de29fb032"

RDEPENDS = " \
    libc6 \
    libclang-cpp19 \
    libclang1-19 \
    libfmt10 \
    libgcc-s1 \
    libllvm19 \
    libsqlite3-0 \
    libstdc++6 \
    libxapian30 \
"

RPROVIDES = " \
    dh-sequence-doxygen \
"
