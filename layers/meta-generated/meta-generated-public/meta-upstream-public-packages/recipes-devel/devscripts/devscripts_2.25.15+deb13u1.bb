# This was autogenerated! Do not modify
SUMMARY = "scripts to make the life of a Debian Package maintainer easier"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "devscripts"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/d/devscripts/devscripts_2.25.15+deb13u1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "705a2de490f9eeacbf3458818ad6bea4"
SRC_URI[deb0.sha1sum] = "32b3765679b891368ef25327116cb06fe32c2fa7"
SRC_URI[deb0.sha256sum] = "100db3217cc5c16507f4aa98ba576d0a658edf27c3a67d1dfb59c6084307360f"
SRC_URI[deb0.sha512sum] = "b67d2dff9f0233f6b03ad1d2f9639adea67aec726257ce8bb85139f42486e1436c63b4014cc7df282a794d2b44ffa895e9410f90467ea51bb9829a5d7cf32eac"

RDEPENDS = " \
    dpkg-dev \
    file \
    gpg \
    gpg-agent \
    libdpkg-perl \
    libfile-dirlist-perl \
    libfile-homedir-perl \
    libfile-touch-perl \
    libmoo-perl \
    libwww-perl \
    patchutils \
    perl \
    python3 \
    sensible-utils \
    sopv \
    wdiff \
"

