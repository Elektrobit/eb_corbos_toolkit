# This was autogenerated! Do not modify
SUMMARY = "GNU C compiler for the aarch64-linux-gnu architecture"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "gcc-13"
HOMEPAGE = "http://gcc.gnu.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gcc-13/gcc-13-aarch64-linux-gnu_13.3.0-16_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "4087cb988be442a425a291e2a8c1fc0a"
SRC_URI[deb0.sha1sum] = "48a65c861d7269d858acb852d2d47d761e16f759"
SRC_URI[deb0.sha256sum] = "4139935728b225ac0f97a48ab3d96ba9cbf4f1b0b9bdecbdba5b061a4d892d35"
SRC_URI[deb0.sha512sum] = "c5e3af12b6ea7efe0cfc219db26e486894241cee6f3f1dde53f5880b7ad084a5ade8f544228c006e75f56a577d4a5b7853b4637684c887a9351531d045433857"

RDEPENDS = " \
    binutils-aarch64-linux-gnu \
    cpp-13-aarch64-linux-gnu \
    gcc-13-base \
    libc6 \
    libcc1-0 \
    libgcc-13-dev \
    libgcc-s1 \
    libgmp10 \
    libisl23 \
    libmpc3 \
    libmpfr6 \
    libstdc++6 \
    libzstd1 \
    zlib1g \
"

RPROVIDES = " \
    c-compiler-aarch64-linux-gnu \
"
