# This was autogenerated! Do not modify
SUMMARY = "GNU C++ compiler for aarch64-linux-gnu architecture"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "gcc-13"
HOMEPAGE = "http://gcc.gnu.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gcc-13/g++-13-aarch64-linux-gnu_13.3.0-16_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "174db1f45a9e6acde9de9cf53be7b1f9"
SRC_URI[deb0.sha1sum] = "d139dddc407477751184521c095b6c8319c941ed"
SRC_URI[deb0.sha256sum] = "aea66cf6e4be4ecbb46215e14305519a82c1736a3163f2cfa4e075384b257af7"
SRC_URI[deb0.sha512sum] = "def5e8b7bfd8d9526d92fc8cd176c6b6e5907b663c449474ee2fd0c45d8b64bb99f4489d2389c32c872e13e438bf34d855c7c7b90c34483de5e76cfe035a9249"

RDEPENDS = " \
    gcc-13-aarch64-linux-gnu \
    gcc-13-base \
    libc6 \
    libgmp10 \
    libisl23 \
    libmpc3 \
    libmpfr6 \
    libstdc++-13-dev \
    libzstd1 \
    zlib1g \
"

RPROVIDES = " \
    c++-compiler-aarch64-linux-gnu \
"
