# This was autogenerated! Do not modify
SUMMARY = "SELinux core policy utilities (development utilities)"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "selinux-python"
HOMEPAGE = "https://selinuxproject.org"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/selinux-python/policycoreutils-dev_3.8.1-2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/selinux-python/policycoreutils-dev_3.8.1-2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "54aa004a742f4da5eca70223fb05469c"
SRC_URI[deb0.sha1sum] = "06aa6d831e00f5f28f0872a4d6f8fe7e3cdf238c"
SRC_URI[deb0.sha256sum] = "7cf126460a45b93b5a69c2671375656177a3beeb29d95f7e0cce565232fca00d"
SRC_URI[deb0.sha512sum] = "96fdd8806501dfecbb9df6b3ca134417d75ed053445354bbc2d9f2e88b9135c1694f8590ad74902e7a9edf3a26fd521d342a37ac9ab3a098e9b52307e6329a78"
SRC_URI[deb1.md5sum] = "e425c134e89dc359610a945336d7b22c"
SRC_URI[deb1.sha1sum] = "0315dcc6aa0bd0787c846624c4181f95973756ab"
SRC_URI[deb1.sha256sum] = "6aa6afdcc0e5d6572d5a54fd37c74fb353acb3fbf1c643b5fe6e9bad16af4c13"
SRC_URI[deb1.sha512sum] = "6ef9c0e154ce6dff47d9a2a4c5f164f327d4dc9614a549f41fae2fc3169d5ad9512971bb987f9864deb76199519ee1081bc35f33d94771b1210bc6515d9ffde9"

RDEPENDS = " \
    binutils \
    libc6 \
    libselinux1 \
    policycoreutils \
    python3 \
    python3-selinux \
    python3-sepolgen \
    python3-sepolicy \
    semodule-utils \
"

