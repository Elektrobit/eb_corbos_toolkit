# This was autogenerated! Do not modify
SUMMARY = "Update infrastructure for config.{guess,sub} files"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "autotools-dev"
HOMEPAGE = "https://savannah.gnu.org/projects/config/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/a/autotools-dev/autotools-dev_20240727.1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "539242d220a29bd5959d38a1dff06592"
SRC_URI[deb0.sha1sum] = "62a4f1119b1849b0cc9d676ad90e4a8ac5d3b721"
SRC_URI[deb0.sha256sum] = "d07d476c1fcd713ed04695f25ac290c3ae2317e6fd974ad6b2168e3be1c795c3"
SRC_URI[deb0.sha512sum] = "aecb58b7fe1ee2188d5e2246e743bdb1ce2f6d125e84c196e79e7e0fea8d598720417f7768ec26106f9b9cc4c6191d4d0bc33ce600939060459b70c2f04d9623"


