# This was autogenerated! Do not modify
SUMMARY = "GNU Debugger (remote server)"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "gdb"
HOMEPAGE = "https://www.gnu.org/s/gdb/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gdb/gdbserver_16.3-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gdb/gdbserver_16.3-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "11cbe9465134859302ccb6eeb0bf318a"
SRC_URI[deb0.sha1sum] = "c117ad4b62ff94bf1c61303bebaf5009f65449a6"
SRC_URI[deb0.sha256sum] = "6d2f2029e24df9fc099d720f1e020a25f574d74bd69e5f5647350f5c787fd990"
SRC_URI[deb0.sha512sum] = "55cabae649960604beb2a3e580e62d030e0e9b011c6dd16008f7e742a616e48e2973e577f6f31e5e4e4bf59ff5f22ee33fe92f2e21f06199a300cb73f8910d96"
SRC_URI[deb1.md5sum] = "126859a006fca824de44c6e0c09b0a41"
SRC_URI[deb1.sha1sum] = "3faba8418c70249a7a219363272a7a7804e06975"
SRC_URI[deb1.sha256sum] = "b749a29afca991a43f82b04b42f8dedc2ad3182a020cd776a327568a3660e1bb"
SRC_URI[deb1.sha512sum] = "23e410423f104fa492729d69a5878a6ca5ad77475dc3f290d19e751e4a4b110d5941205a5121a0dd4345de1282c7bc7fa474df2eafb18a50dc6c35f9ad12d734"

RDEPENDS = " \
    libc6 \
    libgcc-s1 \
    libstdc++6 \
"

