# This was autogenerated! Do not modify
SUMMARY = "GNU Debugger"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "gdb"
HOMEPAGE = "https://www.gnu.org/s/gdb/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gdb/gdb_16.3-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gdb/gdb_16.3-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "6908aa9da7f39382bf77bc97b173f5a7"
SRC_URI[deb0.sha1sum] = "f508dcb9357751a4bbba7d8822cc580bf65fbeed"
SRC_URI[deb0.sha256sum] = "f0cd9b3e7b47685cbc43ebfe3207760830cb7b570e615daee6dc91e50040c127"
SRC_URI[deb0.sha512sum] = "1140878d3b68b71d15bd045ea1c5ccb561336d883ae904fdee6260d3b3982c25c3f7c4eb30a50e68b73a6eae8e4eea4d5e72f0dd9c09660fb024e621c824dcc8"
SRC_URI[deb1.md5sum] = "01764b8a83aeb12437b8306a69513ee1"
SRC_URI[deb1.sha1sum] = "f1812d375ca073a19156e9326a64be17dfc30323"
SRC_URI[deb1.sha256sum] = "bcebc0f6453202b7eb96673cac53d2469e9a6b4097f0a0bef36a88ba4591020a"
SRC_URI[deb1.sha512sum] = "5c7e0fcf52e325dcd06a81065b4c68c53b418c19f2f825da678c9170064a902414e6f3599635f46fa0a716b4b83a5039365e86e17ddaf5cea455a100ede4e93d"

RDEPENDS = " \
    libbabeltrace1 \
    libc6 \
    libdebuginfod1t64 \
    libexpat1 \
    libgcc-s1 \
    libgmp10 \
    liblzma5 \
    libmpfr6 \
    libncursesw6 \
    libpython3.13 \
    libreadline8t64 \
    libsource-highlight4t64 \
    libstdc++6 \
    libtinfo6 \
    libxxhash0 \
    libzstd1 \
    zlib1g \
"
RDEPENDS:append:amd64 = " \
    libipt2 \
"

RPROVIDES = " \
    gdb-minimal \
"
