# This was autogenerated! Do not modify
SUMMARY = "GNU Debugger (with support for multiple architectures)"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "gdb"
HOMEPAGE = "https://www.gnu.org/s/gdb/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gdb/gdb-multiarch_16.3-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gdb/gdb-multiarch_16.3-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "7920ec0fec1ce18ea26de86bdbb6e003"
SRC_URI[deb0.sha1sum] = "c5111b6272e2296bb7136b8d6520fd495b50e906"
SRC_URI[deb0.sha256sum] = "36f4251601833ce2f9dd3d289f4201372bc517699273ba35db87772bbe2d5463"
SRC_URI[deb0.sha512sum] = "8a54866e0116cee46f9f006f2ab6f6e2265b4dc7d16f6163314401d4572ee62e701b638f170c17861afa5a2c73cd106ddd458f245cd941e844c076dfbe2de6dd"
SRC_URI[deb1.md5sum] = "29c117affe420b754099e4528387ed33"
SRC_URI[deb1.sha1sum] = "b1c232306d96ab32b3c0fe8b33ee02328cd14a8a"
SRC_URI[deb1.sha256sum] = "da917928df26a0f2ea38f6c3b83dc0c3ab8bc660cb55d3e9ec3ca4970b99ef3a"
SRC_URI[deb1.sha512sum] = "392bc0f6a49ee2dceadaaeb7cf0ac130dad0f11992ea5970ddeffbe4dc77236928875b45a74ad7598f3c3f35c99d28f1b9b0cf90e004e0831cd84e4663df6418"

RDEPENDS = " \
    gdb \
    libbabeltrace1 \
    libc6 \
    libdebuginfod1t64 \
    libexpat1 \
    libgcc-s1 \
    libgmp10 \
    liblzma5 \
    libmpfr6 \
    libncursesw6 \
    libpython3.13 \
    libreadline8t64 \
    libsource-highlight4t64 \
    libstdc++6 \
    libtinfo6 \
    libxxhash0 \
    libzstd1 \
    zlib1g \
"
RDEPENDS:append:amd64 = " \
    libipt2 \
"

