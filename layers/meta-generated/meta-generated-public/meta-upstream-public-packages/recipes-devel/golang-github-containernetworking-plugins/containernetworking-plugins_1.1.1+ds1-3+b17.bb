# This was autogenerated! Do not modify
SUMMARY = "standard networking plugins - binaries"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "golang-github-containernetworking-plugins"
HOMEPAGE = "https://github.com/containernetworking/plugins"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/golang-github-containernetworking-plugins/containernetworking-plugins_1.1.1+ds1-3+b17_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/golang-github-containernetworking-plugins/containernetworking-plugins_1.1.1+ds1-3+b17_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "ecaf83929426dc344b3a1a22214d69f0"
SRC_URI[deb0.sha1sum] = "c562e26cf0e80f5a646db27301043939f52cc7d8"
SRC_URI[deb0.sha256sum] = "296dd0e2b087a135bedb07599061d27b20f4c38fc8a9b4662e2866c2eb829123"
SRC_URI[deb0.sha512sum] = "334b0a289b8c419a7aa1553932e0f21e8c13002d669edef8a416eda9726901db24b03c406c2cf2b32a47eb7e648a26e3bbb0f5cb0b2d76d3170841d7d70ba095"
SRC_URI[deb1.md5sum] = "671999c55d16db11f7d94a28e0faf6f9"
SRC_URI[deb1.sha1sum] = "2b823720091964f5d6b6f2e8639706f23a532458"
SRC_URI[deb1.sha256sum] = "b8600dbeac613b9cacd2bfffb5590f2a4ba427765c6b7cae86d7535db2c3d3a9"
SRC_URI[deb1.sha512sum] = "934ead3683372bfe0a5ec6c2b4c13089bb3e9da32bdf9b6dc4439ea1f2adf326c0424ba913cc73120f7006e30d39b4fed4e53f7a62e786841929b8990f74acfa"

RDEPENDS = " \
    iptables \
    libc6 \
"

RPROVIDES = " \
    container-network-stack \
"
