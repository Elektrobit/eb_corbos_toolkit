# This was autogenerated! Do not modify
SUMMARY = "manage compile and link flags for libraries (binaries)"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "pkgconf"
HOMEPAGE = "http://pkgconf.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/pkgconf/pkgconf-bin_1.8.1-4_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/pkgconf/pkgconf-bin_1.8.1-4_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "e20354ec0d20b5e329c0db835fdb3b6b"
SRC_URI[deb0.sha1sum] = "a0ef37aac3d7e82078b20aab895985693d0df628"
SRC_URI[deb0.sha256sum] = "54efef2aef4db5fcb5e0f5b7746465000c6a779b06f3686d0ec3d2a901b20aeb"
SRC_URI[deb0.sha512sum] = "de1ed2370f581dfaafe972d5b6887eb1f8d4d9a4fa1372e519846b0da63de65416d02abcdc4619bfa0bd5f060b2f59c8da646c4e0e695f8e87158e8f826d6578"
SRC_URI[deb1.md5sum] = "6912343b63bf38801caab0be7e01550d"
SRC_URI[deb1.sha1sum] = "ca73c8b8561f9a2aae759092ba8441864862261b"
SRC_URI[deb1.sha256sum] = "bce0638102650b61224901da320c2f867a91cfc133532a5fb526d2ce05465fe6"
SRC_URI[deb1.sha512sum] = "3a70a5a90cc56c736fd304f89f9b6faa64709754132eebfdd9c07509fce28855815d9d5e4a62eed7a2b5b949fbf383d2901594443c84ef665bcc6d11c9ad78f0"

RDEPENDS = " \
    libc6 \
    libpkgconf3 \
"

