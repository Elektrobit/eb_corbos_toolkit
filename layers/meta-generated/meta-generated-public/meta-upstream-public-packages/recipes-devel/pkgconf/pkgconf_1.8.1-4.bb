# This was autogenerated! Do not modify
SUMMARY = "manage compile and link flags for libraries"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "pkgconf"
HOMEPAGE = "http://pkgconf.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/pkgconf/pkgconf_1.8.1-4_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/pkgconf/pkgconf_1.8.1-4_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "55209921730a0fff7aed409f06676f00"
SRC_URI[deb0.sha1sum] = "b5e47d8c8c8a2532ea659d81df839aca048f6c13"
SRC_URI[deb0.sha256sum] = "f1fcad470ca3ac80b4a0f4af6f03cd215089473996b07e508b3ee342bbb11af7"
SRC_URI[deb0.sha512sum] = "5fdfcf069c86f63e99cf1703d15222de826b057916e7b9bbc61092cf455e8808eca3f52be527cd2c2be76c51b7e73bebe42f41ce26cd3c7fd0b8d29a52392286"
SRC_URI[deb1.md5sum] = "d448cda6841ad78b73ebdfba9894a08c"
SRC_URI[deb1.sha1sum] = "29f64c8c63c1cc6b4cc26885166d010ac2949883"
SRC_URI[deb1.sha256sum] = "aaf89947e9a5a6d980d14f43dfde8d0ad4e869b5cd33567321ca8baeb7ee7740"
SRC_URI[deb1.sha512sum] = "0a4c13cab9c17e5bee74bbe99f8417a78fce8203c12a13d7863eb1d9f22ab29ff131b108a1d1090c870ccc53b1b40df74fd59ccc7d99cde05151fdd257bd1479"

RDEPENDS = " \
    pkgconf-bin \
"

RPROVIDES = " \
    pkg-config \
"
