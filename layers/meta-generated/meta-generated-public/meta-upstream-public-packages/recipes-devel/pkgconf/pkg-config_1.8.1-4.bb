# This was autogenerated! Do not modify
SUMMARY = "manage compile and link flags for libraries (transitional package)"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "pkgconf"
HOMEPAGE = "http://pkgconf.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/pkgconf/pkg-config_1.8.1-4_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/pkgconf/pkg-config_1.8.1-4_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "fd7ce28e7289a2178b9a670fbbab2afa"
SRC_URI[deb0.sha1sum] = "b9454d227e40e030eacc9b929f34e6e50ac81c80"
SRC_URI[deb0.sha256sum] = "385209ba52e5c97808bbdc2fc4da22aea9020f96fbab6fbfb144921c4a31d400"
SRC_URI[deb0.sha512sum] = "4e995351f8145573583fec7ce022d049d7f79890cfad167a59ac749cf130712781bbcf4c2620cd8983e290162c6d26926105b0851933a3352c8a0b363df7545b"
SRC_URI[deb1.md5sum] = "97f02f90615af74304526935286a0160"
SRC_URI[deb1.sha1sum] = "a890526d9ee29f64733af99e994a4e9b61a11ce3"
SRC_URI[deb1.sha256sum] = "fef9662964fa4ff2ebbeefe076adffad79374f744274085c8ce931d5feb462a1"
SRC_URI[deb1.sha512sum] = "1599747a0c9acc3af855cc7809ce2b53545809746dc895cb5d9a5ca01f1a8256eb23a635b341fbf9de180bb215802cdec6d71fc163c4087f4afe6d65996f0b22"

RDEPENDS = " \
    pkgconf \
"

