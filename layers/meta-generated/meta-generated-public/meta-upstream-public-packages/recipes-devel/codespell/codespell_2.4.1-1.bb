# This was autogenerated! Do not modify
SUMMARY = "Find and fix common misspellings in text files"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "codespell"
HOMEPAGE = "https://github.com/codespell-project/codespell/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/c/codespell/codespell_2.4.1-1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "d723b2be929f585bd09582543784dd1f"
SRC_URI[deb0.sha1sum] = "b3f3a0e6cc995cfc0cb3cf8423a74a203c3b5e45"
SRC_URI[deb0.sha256sum] = "c39fb9ca105f5e637f77970d920dba82511b11523cfd0cb9cf60968e86dc6771"
SRC_URI[deb0.sha512sum] = "7d915ee1298412859c82b9966014c27586579448c9dba83d1d59609461a789bb58924d0b3092b88408f041edcc734a3e844cbf6f5ecba2385da9cac1caed8e14"

RDEPENDS = " \
    python3 \
    python3-chardet \
"

