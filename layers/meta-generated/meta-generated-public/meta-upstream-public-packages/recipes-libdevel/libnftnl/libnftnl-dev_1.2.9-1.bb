# This was autogenerated! Do not modify
SUMMARY = "Development files for libnftnl"
DESCRIPTION = ""
SECTION = "libdevel"
SOURCE_PACKAGE = "libnftnl"
HOMEPAGE = "https://git.netfilter.org/libnftnl"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libn/libnftnl/libnftnl-dev_1.2.9-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libn/libnftnl/libnftnl-dev_1.2.9-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "b4d341d565665710d39ac13d9a87f1d9"
SRC_URI[deb0.sha1sum] = "c0776ad4c45fbc64aebaad5380fa928f215af301"
SRC_URI[deb0.sha256sum] = "6379e99cfd0043a86b839ba10f4d5fca3613835fe0244dbb2532f5be86e775b8"
SRC_URI[deb0.sha512sum] = "9b6c83a85a701548a0c5f024f893b40b3a577374147b64b720043cb87eb37db24ec327db0e685bf3200a6d07a8035e5d145af9f664f5011d93c862b64aceba9c"
SRC_URI[deb1.md5sum] = "0d45e308a5c3cbd7ebe356c818932894"
SRC_URI[deb1.sha1sum] = "af56dcddd32153971fe9c76ac9bed70f9fd197f1"
SRC_URI[deb1.sha256sum] = "1de432f83144f5e0c6badc5debeaccf3840020699f34aa9272a7f05f331c40e1"
SRC_URI[deb1.sha512sum] = "b0c649cb48887cc7c365eac7fd55a61d7288b6457f545d0588bae164e9c45b352f786f565d012b6d95076530ea51ff919c608be5e0c1ede10864d7552f0e6f4c"

RDEPENDS = " \
    libnftnl11 \
    pkgconf \
"

