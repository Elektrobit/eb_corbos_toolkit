# This was autogenerated! Do not modify
SUMMARY = "libcrypt development files"
DESCRIPTION = ""
SECTION = "libdevel"
SOURCE_PACKAGE = "libxcrypt"
HOMEPAGE = ""

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libx/libxcrypt/libcrypt-dev_4.4.38-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libx/libxcrypt/libcrypt-dev_4.4.38-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "ef4a9106931e8c0994e1881047aa0f12"
SRC_URI[deb0.sha1sum] = "b94ecbf88226ed3c5175ba9c1f7e37bcd66c78cc"
SRC_URI[deb0.sha256sum] = "98e2333aea8d64ca68f9b75c16256d3a05492fd8f9e6dba96adbc6f19e4f5a09"
SRC_URI[deb0.sha512sum] = "a56257c5846c0fbd222b524556caf80e258b79698b384a4b00016b64dd5ab58c339ae5cdb7a60edb47c121809e7d4357ba112cef29a0985da0bedd6917a49dcb"
SRC_URI[deb1.md5sum] = "b8d0f2fd2cd9d7cd84a362766a11f83c"
SRC_URI[deb1.sha1sum] = "a3ad4703b35fcb9a1695a6dcb597f75728536e0f"
SRC_URI[deb1.sha256sum] = "eec6d4658495cdb8ce505cad91e0918edb8086677f280f3851c07ccd70543054"
SRC_URI[deb1.sha512sum] = "f8fcf7d22bbe65b1095eb1c776ecae7208b0ea636afed266ce7a69b9e1e692b499e9ca4d10be44323c39510c20a0d6f37f34f87f8bac0ee0e563540cd026ce02"

RDEPENDS = " \
    libcrypt1 \
"

RPROVIDES = " \
    libcrypt1-dev \
"
