# This was autogenerated! Do not modify
SUMMARY = "JSON manipulation library - development files"
DESCRIPTION = ""
SECTION = "libdevel"
SOURCE_PACKAGE = "json-c"
HOMEPAGE = "https://github.com/json-c/json-c/wiki"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/j/json-c/libjson-c-dev_0.18+ds-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/j/json-c/libjson-c-dev_0.18+ds-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "efc3630c4a5da001f13a53ff2d6432da"
SRC_URI[deb0.sha1sum] = "a1d730a4c5d5b755b037a079bbcde050d2cceb57"
SRC_URI[deb0.sha256sum] = "8e0c93929bdaf7a5e5f9f25848f1533fc34f916d7f2ba44bda782f7f32415db6"
SRC_URI[deb0.sha512sum] = "bde1009158f073f56889c58a5f72c63003ed1a7b1248346f40c48cb6bfe701d26c97606281d63417b804222347e0e0a25abaae06fe3517bc3530b28a2288ba3d"
SRC_URI[deb1.md5sum] = "624be6e56959ed6e94b1b50dd3333d00"
SRC_URI[deb1.sha1sum] = "a6276478c19b3e53ea7bf4b67ed7543082ef5796"
SRC_URI[deb1.sha256sum] = "3251d28e925629b443dda9965ba2343ddb05d5a35f48a7ec3b8d956eb098ba5a"
SRC_URI[deb1.sha512sum] = "3d4d6553c03736545046cb7accfce50f70810bb5a6c666f95c3c61734fe449daf964a90b374b2e5964538495b3836da7cea958bc805f8cce8c41375a4e97535b"

RDEPENDS = " \
    libjson-c5 \
"

