# This was autogenerated! Do not modify
SUMMARY = "common error description library - headers and static libraries"
DESCRIPTION = ""
SECTION = "libdevel"
SOURCE_PACKAGE = "e2fsprogs"
HOMEPAGE = "http://e2fsprogs.sourceforge.net"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/e/e2fsprogs/comerr-dev_2.1-1.47.2-3+b11_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/e/e2fsprogs/comerr-dev_2.1-1.47.2-3+b11_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "ac7907b22b842a8c72ee8ba2bb949ea8"
SRC_URI[deb0.sha1sum] = "9d33b1cb3fed84c29a8623cce03b2ba4d2cb8791"
SRC_URI[deb0.sha256sum] = "403200f03c6220e63e71d6a82111f7092fea0e9f62acf50822ee895c72cbfd8b"
SRC_URI[deb0.sha512sum] = "f73ce1a00fba7a46179a5ee41d3b8e9156b7442d945d6ee1da4710be12de1de00f46a5f70f3c10d420460d35ff08c4449beaf7d1aaca6e41baa10afd4dc1498b"
SRC_URI[deb1.md5sum] = "86106b5894be4a5608ad4ea1cd38d1ae"
SRC_URI[deb1.sha1sum] = "9ba5541a96f7de01c0d343e78296b07e2672051f"
SRC_URI[deb1.sha256sum] = "490511f32afe59303e1fa2b4c54fd174de0d98f5f3cf9702e0f2784b834792e4"
SRC_URI[deb1.sha512sum] = "8e1887be4993f29d3c6bc3b7ad96b32200d6c5586cdc5161202127a6e861db7c4488d463a03a2d025e06393d1bba89e30bb9bd2a45fe7cc8eb5b846666f83657"

RDEPENDS = " \
    libc6-dev \
    libcom-err2 \
"

