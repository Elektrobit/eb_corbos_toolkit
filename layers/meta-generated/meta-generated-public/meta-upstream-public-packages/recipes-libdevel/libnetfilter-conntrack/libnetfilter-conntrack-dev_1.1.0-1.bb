# This was autogenerated! Do not modify
SUMMARY = "Development files for libnetfilter-conntrack3"
DESCRIPTION = ""
SECTION = "libdevel"
SOURCE_PACKAGE = "libnetfilter-conntrack"
HOMEPAGE = "https://www.netfilter.org/projects/libnetfilter_conntrack/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libn/libnetfilter-conntrack/libnetfilter-conntrack-dev_1.1.0-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libn/libnetfilter-conntrack/libnetfilter-conntrack-dev_1.1.0-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "494d62145d1e9cf3c5bfa9a12ae1f11e"
SRC_URI[deb0.sha1sum] = "c9b8f218d011f67c9e461a4fde7cde21ed9aef51"
SRC_URI[deb0.sha256sum] = "44bfec051da136611d1ee0f9639dac16e408ee8d7bd15d00938d7042f028bb4b"
SRC_URI[deb0.sha512sum] = "748bd3c18fa93b793d17e2aa058f7f88f12fea2572e92626b379558f35ff2a90c4e37e388b00efc94494dbbc5c056e543ec845e4ab1c98b416aad4b3e64853a6"
SRC_URI[deb1.md5sum] = "7c7e8df1c5419c92616f8b45d9feb03f"
SRC_URI[deb1.sha1sum] = "70262c9ed7329a4695ecb98a98643cfb1bd9241e"
SRC_URI[deb1.sha256sum] = "0a72d1f13eaf49aee8cb8322bdff4aa51978f9651f5aa8ab55d0b0db9a1572c9"
SRC_URI[deb1.sha512sum] = "9e8bd9f29e9877c2e9d240aba304fd7f51991f7ab29fbd5a878ca3ce1de66c2162ccc822045e178efcfc7d8629e19f1d5484bee6dedf81a8d844c58d9ec0e5c9"

RDEPENDS = " \
    libnetfilter-conntrack3 \
    libnfnetlink-dev \
    pkgconf \
"

