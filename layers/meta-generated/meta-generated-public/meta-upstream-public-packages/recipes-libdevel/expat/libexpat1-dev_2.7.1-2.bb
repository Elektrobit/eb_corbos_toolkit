# This was autogenerated! Do not modify
SUMMARY = "XML parsing C library - development kit"
DESCRIPTION = ""
SECTION = "libdevel"
SOURCE_PACKAGE = "expat"
HOMEPAGE = "https://libexpat.github.io/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/e/expat/libexpat1-dev_2.7.1-2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/e/expat/libexpat1-dev_2.7.1-2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "4c3f9c7bb5264a2c19531970c69f9429"
SRC_URI[deb0.sha1sum] = "d718845c00344d7965787ca08877a6d1bc51ef71"
SRC_URI[deb0.sha256sum] = "ac1e7f8ad81578b61bc7c54c725ec639b06684e560766eac278490a1b2064372"
SRC_URI[deb0.sha512sum] = "56edf266de7818d2b31b8a624a8819d4480b98f4eab6ebc2b400b6944894d4e74ca6263082e2262b90be6b5ccc5dbc320d2f41e0f49da96d5b147f5308ceaf98"
SRC_URI[deb1.md5sum] = "ffb496b565f638e1c91e5ca438bdee28"
SRC_URI[deb1.sha1sum] = "b0fd006c705d3b52a70b6378819d3478dec226f1"
SRC_URI[deb1.sha256sum] = "b219482f10e9a0e52474db2a6f239057ea27fea0db0071e3ddb41e8a8a06064c"
SRC_URI[deb1.sha512sum] = "1662803631ae359fad6501f8473563cc187cc99d60bf8554045f6536e35574dc88d9ef44b346ab8fb17eebe4de9c15bbd908401a23a3b058ba596e54069f89af"

RDEPENDS = " \
    libc6-dev \
    libexpat1 \
"

RPROVIDES = " \
    libexpat-dev \
"
