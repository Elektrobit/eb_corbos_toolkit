# This was autogenerated! Do not modify
SUMMARY = "development library and headers for libnl-3"
DESCRIPTION = ""
SECTION = "libdevel"
SOURCE_PACKAGE = "libnl3"
HOMEPAGE = "https://github.com/thom311/libnl"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libn/libnl3/libnl-3-dev_3.7.0-2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libn/libnl3/libnl-3-dev_3.7.0-2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "35f7216e301f856d3fec2b8d7523afe8"
SRC_URI[deb0.sha1sum] = "ed0ed995983d7406734b08c266e2e5bda6205731"
SRC_URI[deb0.sha256sum] = "a33e1f6c8f04f621c3604b98880e84d2a7d50da57fe15107ed3006c8ed9085ef"
SRC_URI[deb0.sha512sum] = "d5be2b0bf923eed77bb23c9b35ea244497764048a0634beeb398b94d92b4c6cd8181de2d625e2b06f4b59ee63ac311e19156c367babaefe2c712513744d3e1da"
SRC_URI[deb1.md5sum] = "0ba83c0df0a00225febf752fa0f9d690"
SRC_URI[deb1.sha1sum] = "e37cd6caea8153b6a30640e9add3566958839332"
SRC_URI[deb1.sha256sum] = "6832cb3cd490d166e4d07e24b11850148b02f25cdb6a1607dd20790657bbf8f3"
SRC_URI[deb1.sha512sum] = "bdaf450913dffb55b7d986eba7ea0aef5de81772b921eed08c72f11866d9fb54c60940f1f057d2017b28c443d8a5b72599863742a94df0687597fe7aa50f0ef6"

RDEPENDS = " \
    libnl-3-200 \
"

