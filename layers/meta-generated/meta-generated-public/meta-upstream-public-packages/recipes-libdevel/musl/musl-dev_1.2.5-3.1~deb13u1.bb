# This was autogenerated! Do not modify
SUMMARY = "standard C library development files"
DESCRIPTION = ""
SECTION = "libdevel"
SOURCE_PACKAGE = "musl"
HOMEPAGE = "https://musl.libc.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/m/musl/musl-dev_1.2.5-3.1~deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/m/musl/musl-dev_1.2.5-3.1~deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "5362d43f0589e05c91e3447aeaf3e030"
SRC_URI[deb0.sha1sum] = "f18c391f35feb8fc584b6ab741b13dbea6d73f1b"
SRC_URI[deb0.sha256sum] = "a3f7d47e452129bb65aae201d6c115abf4d5d3efb136b38b7c6b4fa03ec065e9"
SRC_URI[deb0.sha512sum] = "11efc13237cb7d5ec01f89d9063c07534dab983ae1bf20891a3b952d9830e09da18b0ab24bd5114cc9254fd594c84b00990dd47c53f249f33fe24ac0292a6488"
SRC_URI[deb1.md5sum] = "ee0bc395b4948c2141f49ea4c35d9466"
SRC_URI[deb1.sha1sum] = "e0c0f9fdda5053d869b1fd8ba27f7f926a79499e"
SRC_URI[deb1.sha256sum] = "384ea029e3694baac696d3993d93246f9a4b3741c493697e1ceb7256d8820748"
SRC_URI[deb1.sha512sum] = "315a6f12672d0d6cf44e0fca487b058aabedcf421fae92a799ab50749df2d5bbf9910d599d8a7ed6a5d6509ac938884ee3be61358c3717f7d1bec46b7660b711"

RDEPENDS = " \
    musl \
"
RDEPENDS:append:amd64 = " \
    gcc-x86-64-linux-gnu \
"
RDEPENDS:append:arm64 = " \
    gcc-aarch64-linux-gnu \
"

RPROVIDES = " \
    musl-fts \
"
