# This was autogenerated! Do not modify
SUMMARY = "libelf1t64 development libraries and header files"
DESCRIPTION = ""
SECTION = "libdevel"
SOURCE_PACKAGE = "elfutils"
HOMEPAGE = "https://sourceware.org/elfutils/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/e/elfutils/libelf-dev_0.192-4_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/e/elfutils/libelf-dev_0.192-4_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "a8bb4d6f0ff832e3b9e35335019aa5aa"
SRC_URI[deb0.sha1sum] = "1728d431bbec07c4eee7edebce1f2370d59bc4cb"
SRC_URI[deb0.sha256sum] = "7a67f944281523d6e3c55c1797449bab223b08665cc6ad8b51293056b65d9bd6"
SRC_URI[deb0.sha512sum] = "17ec4ea131a5a72ef952e01f78b30ba5b568637bb9e1ff525a1bba10be0c1abd5581b706332f129658be1cb89ff1d4b1abbc5632583a861a653471fcff8be976"
SRC_URI[deb1.md5sum] = "a483de45132287400855bc81104248e5"
SRC_URI[deb1.sha1sum] = "40d7e9f6e01ee1b2ccf9ad8b9f5e286af54d9f40"
SRC_URI[deb1.sha256sum] = "cc8a4f93ef8addf167b1a011a4b2ccb00060be51c6bffb2205f8438fa8c7527e"
SRC_URI[deb1.sha512sum] = "8f98e6dd5b0a391355f079526127bff40522f040162ebaa14379256f211cf14367e262d5b7c8065fee603ca53e99f59d8ba197f84f19875d6367cb5703e7b744"

RDEPENDS = " \
    libelf1t64 \
    libzstd-dev \
    zlib1g-dev \
"

