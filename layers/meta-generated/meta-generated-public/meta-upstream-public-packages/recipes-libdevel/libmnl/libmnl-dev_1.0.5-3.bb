# This was autogenerated! Do not modify
SUMMARY = "minimalistic Netlink communication library (devel)"
DESCRIPTION = ""
SECTION = "libdevel"
SOURCE_PACKAGE = "libmnl"
HOMEPAGE = "https://netfilter.org/projects/libmnl/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libm/libmnl/libmnl-dev_1.0.5-3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libm/libmnl/libmnl-dev_1.0.5-3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "ef9e2e7e83e0b8a2c7e4865a43c7fee8"
SRC_URI[deb0.sha1sum] = "da1d767902d4c1cfc9ce8c213a0e67c45541b537"
SRC_URI[deb0.sha256sum] = "7f9a7c3f470ec400171981816df189ec86b11083c3f8d391d0800ed09a87bfc3"
SRC_URI[deb0.sha512sum] = "b3d41433d9a2fc0e4113dfa56a638bb6aff32f4b490be45662c5a5bc7c3907725cc41407398df8ff5b1a136b9eb047174cb4880734534ba8eb88ec633deabd79"
SRC_URI[deb1.md5sum] = "3f79b6dd8e06a863e7eeea211f4110b8"
SRC_URI[deb1.sha1sum] = "5cf94438d8084d8f39857b216376db97820916b7"
SRC_URI[deb1.sha256sum] = "046ecea98bfb827fffdc9a19c3efd75b9862995e3532987a9272787e70a3a9b6"
SRC_URI[deb1.sha512sum] = "bebe2fba30e2b72101da8abcadd35710aba02b9c2fd8c28ee5fb0b2fee2a4c831db0ca03cd5950d1f309ae3fcb227c953a6318e6ff0bcde6c0e20ca4b6643b10"

RDEPENDS = " \
    libmnl0 \
"

