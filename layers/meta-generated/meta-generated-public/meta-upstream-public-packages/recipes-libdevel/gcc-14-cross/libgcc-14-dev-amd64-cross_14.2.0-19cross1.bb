# This was autogenerated! Do not modify
SUMMARY = "GCC support library (development files)"
DESCRIPTION = ""
SECTION = "libdevel"
SOURCE_PACKAGE = "gcc-14-cross"
HOMEPAGE = "http://gcc.gnu.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gcc-14-cross/libgcc-14-dev-amd64-cross_14.2.0-19cross1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "b54b0a51007843090d679220e84b04b8"
SRC_URI[deb0.sha1sum] = "a83593dddfa28571ca8b56019d2a4cad03d05b01"
SRC_URI[deb0.sha256sum] = "c6642e5d83ad232573c2a45efb5b407b06eb61af2220eb1c922d0380dd446286"
SRC_URI[deb0.sha512sum] = "5d25736e87cb11a225605b3753529b7f0aa97f2dd5770449e31d6455c4f611fb8eb4e205482699ce15d2fa6dbd1bbdb44ec69d5a8bb410fcac571f767fcf3d9f"

RDEPENDS = " \
    gcc-14-cross-base \
    libasan8-amd64-cross \
    libatomic1-amd64-cross \
    libgcc-s1-amd64-cross \
    libgomp1-amd64-cross \
    libhwasan0-amd64-cross \
    libitm1-amd64-cross \
    liblsan0-amd64-cross \
    libquadmath0-amd64-cross \
    libtsan2-amd64-cross \
    libubsan1-amd64-cross \
"

