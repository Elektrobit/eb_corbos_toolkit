# This was autogenerated! Do not modify
SUMMARY = "GCC support library (development files)"
DESCRIPTION = ""
SECTION = "libdevel"
SOURCE_PACKAGE = "gcc-13-cross"
HOMEPAGE = "http://gcc.gnu.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gcc-13-cross/libgcc-13-dev-arm64-cross_13.3.0-16cross1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "388b4e763b67538b5b4d5f326431ad19"
SRC_URI[deb0.sha1sum] = "e0d1e716ef80067371ce0e353911245cf343456e"
SRC_URI[deb0.sha256sum] = "176c868de9315267fa9b52c8a687f2d6203a3521b56fe4af0317795c6151c4ca"
SRC_URI[deb0.sha512sum] = "a37d85181aef5a601894105d42caed1344dc9b596f13208a9eaa7a816554f4ea9e5586fa2212a7367fbf7a6efe9b45588e7c8b0c7cda63caee743a84061ae743"

RDEPENDS = " \
    gcc-13-cross-base \
    libasan8-arm64-cross \
    libatomic1-arm64-cross \
    libgcc-s1-arm64-cross \
    libgomp1-arm64-cross \
    libhwasan0-arm64-cross \
    libitm1-arm64-cross \
    liblsan0-arm64-cross \
    libtsan2-arm64-cross \
    libubsan1-arm64-cross \
"

