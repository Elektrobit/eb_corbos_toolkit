# This was autogenerated! Do not modify
SUMMARY = "Google's framework for writing C++ tests"
DESCRIPTION = ""
SECTION = "libdevel"
SOURCE_PACKAGE = "googletest"
HOMEPAGE = "https://github.com/google/googletest"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/googletest/libgtest-dev_1.16.0-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/googletest/libgtest-dev_1.16.0-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "9abbe0524c1f0a6f7ef19a4ec637447d"
SRC_URI[deb0.sha1sum] = "c1bb91cc92e1cdcdb2370c4170de6de02c9ce5e0"
SRC_URI[deb0.sha256sum] = "f5d63c4358da653d2f8d97b68af6d8446edba7bd169d818e840729d606b8e5c9"
SRC_URI[deb0.sha512sum] = "3a00a35ef28c969c3610a0563850e63a7626728bdfbb254786681755a183183165bc745323d075aca0d9390d985d774cb6559084c9b644779440828125dab44a"
SRC_URI[deb1.md5sum] = "9ae7c342a8a568e8744d153dabe8ae63"
SRC_URI[deb1.sha1sum] = "daa9ede6403ec108c0c03e51f393c2d8b5b6c9c8"
SRC_URI[deb1.sha256sum] = "36410a1e6dfd0d671cdab692ac602d02048f1af3921031b874c8d3978a5e8428"
SRC_URI[deb1.sha512sum] = "cc27ecf98fe54286d0870801e903bf6a70049f07c2914f2b5fc6687339597a072729c462b304d213f8ab7830d0b2a35408445b69c39c0aed053ada5936e125a6"

RDEPENDS = " \
    googletest \
"

