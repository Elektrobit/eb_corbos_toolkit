# This was autogenerated! Do not modify
SUMMARY = "Google's framework for writing C++ tests"
DESCRIPTION = ""
SECTION = "libdevel"
SOURCE_PACKAGE = "googletest"
HOMEPAGE = "https://github.com/google/googletest"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/googletest/libgmock-dev_1.16.0-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/googletest/libgmock-dev_1.16.0-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "490ba5c9b8fffca33b9d5ac466912f97"
SRC_URI[deb0.sha1sum] = "1167a8961e37eaacb3ec1194f44595c372e2d38f"
SRC_URI[deb0.sha256sum] = "f79ea47877b2684d0519b7ed9efbfb3fe4a75fd19af65b70b380f8b9a2f208c8"
SRC_URI[deb0.sha512sum] = "b2c9f5d8b1c2ae2d1e4b60e3a400f00a1e14f263ccfc7306037e6ccdcf8cd651334d8a732fb7079cf6382f6116e3d2b8e070b5a0a65a4157113a551f41f75321"
SRC_URI[deb1.md5sum] = "633b1f6df9154e5ed462628f6699346b"
SRC_URI[deb1.sha1sum] = "254a1978bf78239b52354528bc9dff4f0793b60b"
SRC_URI[deb1.sha256sum] = "2eeae76109427033e0b9c2b6c1f22e83705553de106dbbbf443f217b54ac9804"
SRC_URI[deb1.sha512sum] = "f49db03abeddf0723fd8a67c4ea9231abb5ef6750a00f1581234301d6481073be3a086764007fb6038e6236dd9380b484775aac2454ffb2a9e7340f78443c2e1"

RDEPENDS = " \
    libgtest-dev \
"

