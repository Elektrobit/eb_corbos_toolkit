# This was autogenerated! Do not modify
SUMMARY = "simple interprocess messaging system (development headers)"
DESCRIPTION = ""
SECTION = "libdevel"
SOURCE_PACKAGE = "dbus"
HOMEPAGE = "https://dbus.freedesktop.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/d/dbus/libdbus-1-dev_1.16.2-2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/d/dbus/libdbus-1-dev_1.16.2-2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "8ac2f742ce02c32abbe5a8dfd35fa615"
SRC_URI[deb0.sha1sum] = "7737741dce84cbdf1adbb71dd0a1c42f1138da66"
SRC_URI[deb0.sha256sum] = "83767cf52f88de6d6f370cee30e717828c6fd22cb55d1fb84b38a3e911742887"
SRC_URI[deb0.sha512sum] = "876c4ac3f9ab2a593d25bb4767490a58dc382b74ab2f50e1f0c56a0f77aa40c0394456aff17579c060398061c800ee38f28de2c43fab8f4ffdd3b77d244e5fbd"
SRC_URI[deb1.md5sum] = "6185a7fb8489efed453bdd7632a36314"
SRC_URI[deb1.sha1sum] = "93ebcc2e25ef5c10f3ed9683851c7bb57516c472"
SRC_URI[deb1.sha256sum] = "305788b468ae2daba9074e59906a26df34d3f6f347d3191f13043f5a9224f90b"
SRC_URI[deb1.sha512sum] = "0e7681900d6c89f47109dfb2715522c1cacd5d75d2d395cf32d313da27c75fd86ada410044d1c1e128045ef84e4e002f55708adcae0956bab3ae56b0352ef9ed"

RDEPENDS = " \
    libdbus-1-3 \
    libsystemd-dev \
    pkgconf \
    xml-core \
"

