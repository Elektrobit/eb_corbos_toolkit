# This was autogenerated! Do not modify
SUMMARY = "LibESMTP SMTP client library (development files)"
DESCRIPTION = ""
SECTION = "libdevel"
SOURCE_PACKAGE = "libesmtp"
HOMEPAGE = "https://libesmtp.github.io/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libe/libesmtp/libesmtp-dev_1.1.0-3.2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libe/libesmtp/libesmtp-dev_1.1.0-3.2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "ca33473096ae058526a94f8a859a77a7"
SRC_URI[deb0.sha1sum] = "18c607a07e635c3124708cbc959b9ac4280968f1"
SRC_URI[deb0.sha256sum] = "8a07f000837b08af1d876e7e888fd365eecce688ce4d3b32c8c9e838400a22af"
SRC_URI[deb0.sha512sum] = "d289f7eda5ab3487923c1f5e5a698d5917928b1dc5a7854e4e912e28c98ba7d1e52b1fe05bed850efd5858b44d5782595ac11be70e268765708db6284cfcc89f"
SRC_URI[deb1.md5sum] = "65d0a75068bd6a4119f705aaafd9d56f"
SRC_URI[deb1.sha1sum] = "f7d8f6580538734eed64c72c9e4fa696ff4d0fb8"
SRC_URI[deb1.sha256sum] = "134209bfba15cc02bfd7135c0461a2181faa58623f29b3f07d4e9bc33dc2380e"
SRC_URI[deb1.sha512sum] = "cea0ed7d3e8c5921024bfe4c298bda38bf902ccd90366e4e17ceb3889747e893f97b2f4d6e7b03d1db47933f10d78c0b4099d2e8d40767060dee24273926881b"

RDEPENDS = " \
    libc6-dev \
    libesmtp6 \
    libssl-dev \
"

