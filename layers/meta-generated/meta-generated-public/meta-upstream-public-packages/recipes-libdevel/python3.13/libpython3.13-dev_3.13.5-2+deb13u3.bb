# This was autogenerated! Do not modify
SUMMARY = "Header files and a static library for Python (v3.13)"
DESCRIPTION = ""
SECTION = "libdevel"
SOURCE_PACKAGE = "python3.13"
HOMEPAGE = ""

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python3.13/libpython3.13-dev_3.13.5-2+deb13u3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python3.13/libpython3.13-dev_3.13.5-2+deb13u3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "28e5bde32d9fbb9e197e1280931191da"
SRC_URI[deb0.sha1sum] = "419543b11e684ffed3b5cafe05b88bb411243a31"
SRC_URI[deb0.sha256sum] = "771dcc0c854e8102c2b5e7928430722c0d7cd3bbf687389a7445b2e5038635ca"
SRC_URI[deb0.sha512sum] = "014a8f3caa1a435d50e2ad8bb7ca84757c89c3e87f5a81b0a9e70b179d798af0aa23227ed338a5066d6621c310718f93747b8a4876639455956e3ecbb4eacfc1"
SRC_URI[deb1.md5sum] = "d1a98a1bd4f156d41d4977e9c7c0ffd1"
SRC_URI[deb1.sha1sum] = "4e99751b0c1a830907cd56a1a168a30b5489a889"
SRC_URI[deb1.sha256sum] = "ce0c5915309140d090113b6aae67569bc272185cacf7017d3e6da08e1568ef37"
SRC_URI[deb1.sha512sum] = "e7d24ca008801a2cc3719d325da5b3ad6530fb45c98897377a7b090dbd00449ae58ab2dcb98ead161b69ab5481e383599a709fec3de2ae27db29a74fba928023"

RDEPENDS = " \
    libexpat1-dev \
    libpython3.13 \
    libpython3.13-stdlib \
    zlib1g-dev \
"

