# This was autogenerated! Do not modify
SUMMARY = "Header files and a static library for Python (v3.13)"
DESCRIPTION = ""
SECTION = "libdevel"
SOURCE_PACKAGE = "python3.13"
HOMEPAGE = ""

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python3.13/libpython3.13-dev_3.13.5-2+deb13u4_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/python3.13/libpython3.13-dev_3.13.5-2+deb13u4_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "80cd2a03957874e0111c761cd4360f5f"
SRC_URI[deb0.sha1sum] = "3cb20569f34ff9c1f8537215183f7ce639a343f7"
SRC_URI[deb0.sha256sum] = "dabada7ca12f95a17a31d19c3be4a8708a6a37207ac3b46cd1c344503825b0ee"
SRC_URI[deb0.sha512sum] = "f8a8ef09f3ad44c7351a2c1cac39cdbfa82552906d8fbe4376e1f6c0c15cf7164607f9da323d33564beb3b98db5f0abb4ffc721455d3974fe4a2b791d21ec94d"
SRC_URI[deb1.md5sum] = "ce08a25e88341f62ca85971ae84f2fb1"
SRC_URI[deb1.sha1sum] = "f0907e7116933f0437ac671e9946e4740fcef10b"
SRC_URI[deb1.sha256sum] = "fd62da71db387aba934e4bd17cceaf0db1454ae9e1eae378c4d8329fbe856883"
SRC_URI[deb1.sha512sum] = "8460aa03f54946670c9c5c2c768c96492c2115fa29a577be2ca26e29224dc034b22fb207206fd9bb47b22324602e024bd48168e9d88151534737bc371c7060ac"

RDEPENDS = " \
    libexpat1-dev \
    libpython3.13 \
    libpython3.13-stdlib \
    zlib1g-dev \
"

