# This was autogenerated! Do not modify
SUMMARY = "development files for the CMocka unit testing framework"
DESCRIPTION = ""
SECTION = "libdevel"
SOURCE_PACKAGE = "cmocka"
HOMEPAGE = "https://cmocka.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/c/cmocka/libcmocka-dev_1.1.7-3+b1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/c/cmocka/libcmocka-dev_1.1.7-3+b1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "7c64d1163eb4cc4bbc5694293a8a92df"
SRC_URI[deb0.sha1sum] = "ed39f287018fd161a9cedc8ddaf3f1ba3a614e7f"
SRC_URI[deb0.sha256sum] = "41ca3ee1b4115a849a8b2ce68666d91981769c3517137204cbe5fbd233298649"
SRC_URI[deb0.sha512sum] = "e43aef92d6e945af226d7d1bdb5aed1316f8ea95d0a2005f4f1d91e5ec6e3c2cd8121c8c23ea6f4d9c16181e36f9e48062176dbc69ba4b9bdd186e38ddcb41ca"
SRC_URI[deb1.md5sum] = "560b9a80b6047699c7b4fc08685514f7"
SRC_URI[deb1.sha1sum] = "0a2efc8aa6d9a8ca898581d385c7bc1f87212b4a"
SRC_URI[deb1.sha256sum] = "b07a77ac250175dc422e2bac63ee9b5ab4a2a23b75fca76c5eb033be41dffbb0"
SRC_URI[deb1.sha512sum] = "54f87c3ec7855e0cd95d406af1ce1dd40a5e9724c81868830b5277c723b5c075c0ddc523473a72c819de9852a7c7acd1beee89329c7e3a802da5aa87be9df3d4"

RDEPENDS = " \
    libcmocka0 \
"

