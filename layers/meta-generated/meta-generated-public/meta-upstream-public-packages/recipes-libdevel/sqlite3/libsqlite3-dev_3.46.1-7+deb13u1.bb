# This was autogenerated! Do not modify
SUMMARY = "SQLite 3 development files"
DESCRIPTION = ""
SECTION = "libdevel"
SOURCE_PACKAGE = "sqlite3"
HOMEPAGE = "https://www.sqlite.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/sqlite3/libsqlite3-dev_3.46.1-7+deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/sqlite3/libsqlite3-dev_3.46.1-7+deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "db1ed690b84bb5263a129110e455b737"
SRC_URI[deb0.sha1sum] = "969398860a44cef81b3a35d34f78bb8c0c615cb8"
SRC_URI[deb0.sha256sum] = "4641e695c645393afbf710e5813a5384edfb9f2de5cc4af175e000d2e864b797"
SRC_URI[deb0.sha512sum] = "00586e9f1ceaa2f18909257ebd6de84781f75500fba1a885c13f7394f2e67896ef3eb50726f8182ccc05f96bd0955f0f82330cd58c4e2c556c602c1ec11d3a2e"
SRC_URI[deb1.md5sum] = "6e142627a07af7ce22ad389c6ea33c21"
SRC_URI[deb1.sha1sum] = "ee927a8e6afc545c22cb2b8f49b77c39155c6dd8"
SRC_URI[deb1.sha256sum] = "80ddd308b8853b5ee192537cd629a2abe607f031c37884433ad3fdea9d08e23e"
SRC_URI[deb1.sha512sum] = "d992c2c7c0075b4a3f27027277661de03ff8a9fca8247a43fe53c206cf8391251f7768fabbdbcac9158583df3f2be0a22f7142cf587ccd799a19fe563d2a60be"

RDEPENDS = " \
    libc-dev \
    libsqlite3-0 \
"

