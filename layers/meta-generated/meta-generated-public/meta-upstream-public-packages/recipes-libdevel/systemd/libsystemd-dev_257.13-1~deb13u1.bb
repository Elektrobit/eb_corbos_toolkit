# This was autogenerated! Do not modify
SUMMARY = "systemd utility library - development files"
DESCRIPTION = ""
SECTION = "libdevel"
SOURCE_PACKAGE = "systemd"
HOMEPAGE = "https://systemd.io"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/systemd/libsystemd-dev_257.13-1~deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/s/systemd/libsystemd-dev_257.13-1~deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "039f951bfa1021537f4b1b3407fffbd1"
SRC_URI[deb0.sha1sum] = "b54fde6d28d662e39b9a1d5d1e5389b3973bac0a"
SRC_URI[deb0.sha256sum] = "4db2d02ce32dfd9f2994a565a51c640b8e7a96a2e2b277484f9a2de7c0cd63e4"
SRC_URI[deb0.sha512sum] = "44c7011f8cb41e8575f0f64cc4251b10625620d5e43fd50e64c2b0c9b44a80dea20ce5e5e31e56108d002b6078423850e89314de414ec0960116c1bcb532aac9"
SRC_URI[deb1.md5sum] = "8b136dc1bbd4888c458774d0a0f9120e"
SRC_URI[deb1.sha1sum] = "3b8a32abe6baf956b40b7209a6e707db9b27dcb5"
SRC_URI[deb1.sha256sum] = "06239173236c0cfee4ee4310ddeb428b094d3b4e34a80b173587da277d9a1199"
SRC_URI[deb1.sha512sum] = "68629a011be7fa0ea2197188c44da5dc74a1588475e3154fc69b895859dcddbc63c17e444a15a34ac2fd16c4c435680372883e80edada83534bcc3da7719caaa"

RDEPENDS = " \
    libcap-dev \
    libsystemd0 \
"

