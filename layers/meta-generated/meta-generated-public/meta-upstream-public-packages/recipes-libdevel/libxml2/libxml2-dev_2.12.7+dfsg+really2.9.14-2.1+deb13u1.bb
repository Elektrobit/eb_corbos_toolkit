# This was autogenerated! Do not modify
SUMMARY = "GNOME XML library - development files"
DESCRIPTION = ""
SECTION = "libdevel"
SOURCE_PACKAGE = "libxml2"
HOMEPAGE = "http://xmlsoft.org"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libx/libxml2/libxml2-dev_2.12.7+dfsg+really2.9.14-2.1+deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libx/libxml2/libxml2-dev_2.12.7+dfsg+really2.9.14-2.1+deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "58240c1df6fb3cf7e0c6dfdab7495065"
SRC_URI[deb0.sha1sum] = "572ef1fd0da66e56bdd436996255a52ac102dfb4"
SRC_URI[deb0.sha256sum] = "842e07476d0093b9c1ebdc16d1efa093cf9934c9f88cda26a2e33b982deb48df"
SRC_URI[deb0.sha512sum] = "d2255008efa64e5007270cb738d7ae0fc8ab663f5dfadf56502d69bbc11634c80abaed97961aed0ddefaaf540c8a37366e596a20621d204835e086ffcd8531d6"
SRC_URI[deb1.md5sum] = "a9e7ae39cc911b5198437511777eed83"
SRC_URI[deb1.sha1sum] = "88d3cbb2d67b6c6fd1011da3ae1a6deeeb6576c5"
SRC_URI[deb1.sha256sum] = "7c76f0859f71cad883b44975dc1c0b80424cfec0ea14c4052d4832b453b9788a"
SRC_URI[deb1.sha512sum] = "e4984135d0237afae9c023f02d54af0bfa88e8f49c9913c5bf10878c81db765a5c4ba2a63081760fb257a62be5135bed8f70984721fb613943dfbb3e4f01d8f5"

RDEPENDS = " \
    libxml2 \
"

