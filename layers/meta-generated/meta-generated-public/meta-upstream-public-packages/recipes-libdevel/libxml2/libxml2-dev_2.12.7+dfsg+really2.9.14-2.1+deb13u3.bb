# This was autogenerated! Do not modify
SUMMARY = "GNOME XML library - development files"
DESCRIPTION = ""
SECTION = "libdevel"
SOURCE_PACKAGE = "libxml2"
HOMEPAGE = "http://xmlsoft.org"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libx/libxml2/libxml2-dev_2.12.7+dfsg+really2.9.14-2.1+deb13u3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libx/libxml2/libxml2-dev_2.12.7+dfsg+really2.9.14-2.1+deb13u3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "2b320a38b9295e9df8541ababf09c1f3"
SRC_URI[deb0.sha1sum] = "cb78895d351a518eb44a699eedfb91e6108f055e"
SRC_URI[deb0.sha256sum] = "2d1a5825cabb43cf4be6848a4acc4a73c50d9c3740ab0c76e2fed80a3e5c6398"
SRC_URI[deb0.sha512sum] = "0bec5f7d0be9f37f407c4ee134f4c4626db8d9dc1b94ad1017acf63bcbd74a2d99ec38886a1ee26b9e061205710e63a4148c52ea1dddb1d3e89f469e5d23f63c"
SRC_URI[deb1.md5sum] = "bb61961673186cf7493af9bbc9b3d88b"
SRC_URI[deb1.sha1sum] = "ae76b0ab3b03c6bc163e6dab4381c324c132c06f"
SRC_URI[deb1.sha256sum] = "f8113dcd311bcef8f98264971c39e66ca93db60ed0a38730bd86911d54d06129"
SRC_URI[deb1.sha512sum] = "0d404342087d188ad4b2af42be4f5ed53509243fca7237725c9ce50f1849857c0c3966f7584f210a4232d3d97cbb3ca4267e468f2f53d8a3e6f11cbe1ec862ea"

RDEPENDS = " \
    libxml2 \
"

