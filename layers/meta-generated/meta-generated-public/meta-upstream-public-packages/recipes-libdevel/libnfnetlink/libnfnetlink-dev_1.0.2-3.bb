# This was autogenerated! Do not modify
SUMMARY = "Development files for libnfnetlink0"
DESCRIPTION = ""
SECTION = "libdevel"
SOURCE_PACKAGE = "libnfnetlink"
HOMEPAGE = "https://git.netfilter.org/libnfnetlink"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libn/libnfnetlink/libnfnetlink-dev_1.0.2-3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libn/libnfnetlink/libnfnetlink-dev_1.0.2-3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "23e35cadea86674ba81364b150d96b85"
SRC_URI[deb0.sha1sum] = "ee68e600e3f333cdadc460e325674819144faf0c"
SRC_URI[deb0.sha256sum] = "0410f26903630a2e3f0c4fb62a1949a5167dfeef23b8abe3ce89a1518dde9192"
SRC_URI[deb0.sha512sum] = "d55ff8dea432d4b4265bd19ccbb79dc26df6ff9e96bd59ce15951f53b2e0b2cf7f5b07c254fa6a3f3677844c465a9bc9dc54e4d4c5634d03c64e4e8b560a7094"
SRC_URI[deb1.md5sum] = "9da1cedd585b7e57c3e12ae1d9183803"
SRC_URI[deb1.sha1sum] = "4605c207a4479647fa9de7017177c1ee92f2140e"
SRC_URI[deb1.sha256sum] = "31bfa04d7a11847fccc01d040c8485048ca88758f5ef35289843a4be52b9071b"
SRC_URI[deb1.sha512sum] = "ca79fa3655fe7e8178ab9713d756bfcf96393615caa62aee123217ecc6226d390301e2343cd9b37f3531cf2a9cc87c1fa7ed78e24db62de9d84aa039c6e107cd"

RDEPENDS = " \
    libnfnetlink0 \
    pkgconf \
"

