# This was autogenerated! Do not modify
SUMMARY = "Library for Public Suffix List (development headers)"
DESCRIPTION = ""
SECTION = "libdevel"
SOURCE_PACKAGE = "libpsl"
HOMEPAGE = "https://github.com/rockdaboot/libpsl"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libp/libpsl/libpsl-dev_0.21.2-1.1+b1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libp/libpsl/libpsl-dev_0.21.2-1.1+b1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "f6749d6e0c5146e51895974fcae4e939"
SRC_URI[deb0.sha1sum] = "3444473028318007d5e7467d0bff7c0587aea704"
SRC_URI[deb0.sha256sum] = "3f609ce40be2e3a259b98dd8b7f1b0520044ca495adf7d7b9f55f5d93de5a15e"
SRC_URI[deb0.sha512sum] = "11dbab4f2672bebc6be7b9b7cdeb0016cf208590bd1a8a5164472f12cf74a5078e20e5a9f17e417e521fb01019babdfac76e5c27538988ded869c1923e2cb151"
SRC_URI[deb1.md5sum] = "75bdcd2f0491cdd464ecc32d956e96a5"
SRC_URI[deb1.sha1sum] = "648aab5a1edd40aa4e0a82e3264a8e60ff364a49"
SRC_URI[deb1.sha256sum] = "ae29329028b9663b78640ea28143be61b6729727c25c6deb0b7c010595f1858f"
SRC_URI[deb1.sha512sum] = "4c87c9a63d96c3238112da7284f413f705fc342236316ccb6a5a2b4fa427c94c7541fc31f06006a02de99ad996fc745498003440d45679522cb6927248c8f82b"

RDEPENDS = " \
    libpsl5t64 \
"

