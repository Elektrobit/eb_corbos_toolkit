# This was autogenerated! Do not modify
SUMMARY = "GNU TLS library - development files"
DESCRIPTION = ""
SECTION = "libdevel"
SOURCE_PACKAGE = "gnutls28"
HOMEPAGE = "https://www.gnutls.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gnutls28/libgnutls28-dev_3.8.9-3+deb13u4_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gnutls28/libgnutls28-dev_3.8.9-3+deb13u4_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "fe3220e2731ef7a7de095435d7137f9c"
SRC_URI[deb0.sha1sum] = "36ab8dd7417696cf1bc2373c97cbbe269637ee26"
SRC_URI[deb0.sha256sum] = "f7048cead574f6142449a3b4089b042a42372a6b76d900324156ae97dbeb08ed"
SRC_URI[deb0.sha512sum] = "4015fa13dc5950381482b918cd0805c0477be0418ba29434838cc45cc535c1351804c958af5465e13f79e7dfce826a1f682da1d23271bd3f474d47a1c4b567df"
SRC_URI[deb1.md5sum] = "2b3de3783dc1ec9a26c7106e14015437"
SRC_URI[deb1.sha1sum] = "49ae615625fdad4f48f57d220d2a37bf83473ca9"
SRC_URI[deb1.sha256sum] = "409dc73f83c024bccf85e4b1a754bd90a5bd7e10a0aa08e328f9051997523776"
SRC_URI[deb1.sha512sum] = "f37ba6536c9f41d71a1427c13701b3a7c438ee9a7267b0290ed5c3ee211d711268ff2d823950d5a9495d94ad107fb12e0e9feaa0794117731f7f6878730ab8b2"

RDEPENDS = " \
    libc6-dev \
    libgnutls-dane0t64 \
    libgnutls-openssl27t64 \
    libgnutls30t64 \
    libidn2-dev \
    libp11-kit-dev \
    libtasn1-6-dev \
    nettle-dev \
"

RPROVIDES = " \
    gnutls-dev \
    libgnutls-openssl-dev \
"
