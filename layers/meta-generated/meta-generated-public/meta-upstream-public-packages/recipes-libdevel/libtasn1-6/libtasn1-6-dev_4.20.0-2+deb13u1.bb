# This was autogenerated! Do not modify
SUMMARY = "Manage ASN.1 structures (development)"
DESCRIPTION = ""
SECTION = "libdevel"
SOURCE_PACKAGE = "libtasn1-6"
HOMEPAGE = "https://www.gnu.org/software/libtasn1/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libt/libtasn1-6/libtasn1-6-dev_4.20.0-2+deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libt/libtasn1-6/libtasn1-6-dev_4.20.0-2+deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "ada5e48a10af7681aec8f441563d3250"
SRC_URI[deb0.sha1sum] = "964d83dffe9ce9a51eb6b6296cf6a9cb0e0676cb"
SRC_URI[deb0.sha256sum] = "5e00e22434b179100b94c80483eb22793029bf2d1c2fa40688825f0062395a54"
SRC_URI[deb0.sha512sum] = "5f5032741a679f51cbfb19b02b4a7b4da334668fdef8cc931500461fd90f8776e101c26a9750d4d835c5eb035ac685251ab2cca916dff676f8fba1b3806f53c6"
SRC_URI[deb1.md5sum] = "bc6cc7e6a5edc16e2abda65ad021a86e"
SRC_URI[deb1.sha1sum] = "7ca1aaef07242148736fb651bb1e665ca9addfdf"
SRC_URI[deb1.sha256sum] = "d83948124f19b06583d7d6deb8c059c120967148c486b16f49cfec074d35f94c"
SRC_URI[deb1.sha512sum] = "19c8029222b5d4bd5be003cfdbba2258c6668f8d6d54f793ea5958112ad4332d9f1d80435e57993392328f9b74292de73f817948f22d3b56dd157404bbed874a"

RDEPENDS = " \
    libtasn1-6 \
"

RPROVIDES = " \
    libtasn1-dev \
"
