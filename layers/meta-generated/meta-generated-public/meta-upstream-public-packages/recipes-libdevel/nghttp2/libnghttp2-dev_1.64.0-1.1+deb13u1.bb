# This was autogenerated! Do not modify
SUMMARY = "library implementing HTTP/2 protocol (development files)"
DESCRIPTION = ""
SECTION = "libdevel"
SOURCE_PACKAGE = "nghttp2"
HOMEPAGE = "https://nghttp2.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/n/nghttp2/libnghttp2-dev_1.64.0-1.1+deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/n/nghttp2/libnghttp2-dev_1.64.0-1.1+deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "4f577fbe487d0e32999c00d69caa9c11"
SRC_URI[deb0.sha1sum] = "26c38f7eb7c93b85135fff86b150114ea8f905aa"
SRC_URI[deb0.sha256sum] = "8729ae4b34c3884ecd068c66a7643a1c7a5a89597b9d8879bac85ec335df6179"
SRC_URI[deb0.sha512sum] = "a7c35db534d566d30e0c2eb514e065481672304d4731d46138f409128e961d3eb733efd6277a943284ef5252f9a165c7fd430d3a8fa3c42f1328cb46ed9fa5db"
SRC_URI[deb1.md5sum] = "9c2fad61192952faf501303a36958cfc"
SRC_URI[deb1.sha1sum] = "bc11e09c95bf3fa43c54022c16d9493d593fd346"
SRC_URI[deb1.sha256sum] = "361de4929817975feff6363a896734ac32de74418a5a75c32b05b3d7e81d74a8"
SRC_URI[deb1.sha512sum] = "9e06480cac940d0f7f9edbb7233d3ca692db21ed263cb03d9400678f2c61ce0bb1a1c3b20dad49f3964227a89aa5e14e13aef14f53a3ad6bf031067f9da75bfa"

RDEPENDS = " \
    libnghttp2-14 \
    pkgconf \
"

