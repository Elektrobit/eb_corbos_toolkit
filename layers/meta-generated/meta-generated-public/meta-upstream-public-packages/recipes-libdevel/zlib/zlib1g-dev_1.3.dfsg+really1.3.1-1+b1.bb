# This was autogenerated! Do not modify
SUMMARY = "compression library - development"
DESCRIPTION = ""
SECTION = "libdevel"
SOURCE_PACKAGE = "zlib"
HOMEPAGE = "http://zlib.net/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/z/zlib/zlib1g-dev_1.3.dfsg+really1.3.1-1+b1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/z/zlib/zlib1g-dev_1.3.dfsg+really1.3.1-1+b1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "7aae72d49ea07a191cdb37b3980f3aff"
SRC_URI[deb0.sha1sum] = "e0df83113384442c8973fe35be13326370c99fd8"
SRC_URI[deb0.sha256sum] = "76ed5c858e1aef38b7be93acce5910e457e77bd6271471b9d05fb42e78826224"
SRC_URI[deb0.sha512sum] = "0edc6fb83a06e65b37d7c9acfeea73bf6b734950ce4030b9eb9053cb7418049051372e448d4fd9bfea23e6970ba5bb67399059af84788bf9a8f9aeb3239c63d1"
SRC_URI[deb1.md5sum] = "c18342ee20443dc6775b05f41e502a9e"
SRC_URI[deb1.sha1sum] = "8888190ff945f3e4c03d53e7bc4521afcbfeb84d"
SRC_URI[deb1.sha256sum] = "745ebcf1fa115e230af76216355d7290a24f1790fe3780249b519c0e4d30534f"
SRC_URI[deb1.sha512sum] = "c5c9e526fc88ef1a3f575652e1b8b486dd7ef88350c0f48343e3a370c132a664c4d18f097515eaf33199e32df31276116fa09997be0432d8bb297b99478026fb"

RDEPENDS = " \
    libc6-dev \
    zlib1g \
"

RPROVIDES = " \
    libz-dev \
"
