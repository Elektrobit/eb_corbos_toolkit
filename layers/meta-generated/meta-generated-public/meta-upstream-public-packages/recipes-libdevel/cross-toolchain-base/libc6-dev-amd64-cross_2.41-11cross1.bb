# This was autogenerated! Do not modify
SUMMARY = "GNU C Library: Development Libraries and Header Files (for cross-compiling)"
DESCRIPTION = ""
SECTION = "libdevel"
SOURCE_PACKAGE = "cross-toolchain-base"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/c/cross-toolchain-base/libc6-dev-amd64-cross_2.41-11cross1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "25979626fd2de6aa12d683c65e04c67b"
SRC_URI[deb0.sha1sum] = "e71ed3b123afca43513ff35490d2c3479ac56620"
SRC_URI[deb0.sha256sum] = "54ef8425cbc7c45888981e6ef23529df4d056688a6c71a415fcc95a404522b9f"
SRC_URI[deb0.sha512sum] = "a07d93032e7bfbb857189e387e1ade33f0420a3d4923fb364ab8a27b104af7e2ddd6e8c27c3d67b805193a8a355a82176f4a5044943b7a901b6965e16163e426"

RDEPENDS = " \
    libc6-amd64-cross \
    linux-libc-dev-amd64-cross \
"

RPROVIDES = " \
    libc-dev-amd64-cross \
    libc6-dev-amd64-dcv1 \
"
