# This was autogenerated! Do not modify
SUMMARY = "GNU C Library: Development Libraries and Header Files (for cross-compiling)"
DESCRIPTION = ""
SECTION = "libdevel"
SOURCE_PACKAGE = "cross-toolchain-base"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/c/cross-toolchain-base/libc6-dev-arm64-cross_2.41-11cross1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "d85ade7c030e88841a3e9b4043a2925f"
SRC_URI[deb0.sha1sum] = "88e3eff10479ae42161a1a7e7d8d5cfa2407810d"
SRC_URI[deb0.sha256sum] = "61e0b87dec4929abc9fb345ef324139498bf23ddbf0b10ca3a743b59c8ddf8bb"
SRC_URI[deb0.sha512sum] = "b89935ae8f4b788cb55d2948a41f0cb35dbd2c9b4d9baef17f5114e4a08c64f5d4388322336ffb1c6a7056188357c1bcdf32fefc04c2ca6feeb902fbb792dca8"

RDEPENDS = " \
    libc6-arm64-cross \
    linux-libc-dev-arm64-cross \
"

RPROVIDES = " \
    libc-dev-arm64-cross \
    libc6-dev-arm64-dcv1 \
"
