# This was autogenerated! Do not modify
SUMMARY = "Clang library - Common development package"
DESCRIPTION = ""
SECTION = "libdevel"
SOURCE_PACKAGE = "llvm-toolchain-17"
HOMEPAGE = "https://www.llvm.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/l/llvm-toolchain-17/libclang-common-17-dev_17.0.6-22+b2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/l/llvm-toolchain-17/libclang-common-17-dev_17.0.6-22+b2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "e4f23798b07d953c6e2a6701aa06af8f"
SRC_URI[deb0.sha1sum] = "4de7ae61401e83e64a5d55d18db6008e7ee86b3f"
SRC_URI[deb0.sha256sum] = "ecaffac9fbb23cabc893e682ebaef38d446f8135dc104c2dbd83e21a599f1810"
SRC_URI[deb0.sha512sum] = "854a10209a22344a754bba262b745a835ec59f89391b7ed0a30be371720124ce8e94a1725f46a0a27f8e1533c574169d54f0444558566f49d4e5d3060029a8a6"
SRC_URI[deb1.md5sum] = "147658d1f7004ecccf37df4f744ddda6"
SRC_URI[deb1.sha1sum] = "ba7ce76ae6e703756ef9fb0e20ef7c6501fbaee4"
SRC_URI[deb1.sha256sum] = "20429e9da03300985f8233b3c5c2969dae899428f74a6962bd7fb99be2b0b4c6"
SRC_URI[deb1.sha512sum] = "7abece18e3ec2ce5fef6b2163efbadf979c1808674db17d6efc83926d1b185b03f9393e1c0a1e179ece68e48afdd96762c1094d25cb71c0cc107c96decce687a"


