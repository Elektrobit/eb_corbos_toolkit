# This was autogenerated! Do not modify
SUMMARY = "development library for libpcap (transitional package)"
DESCRIPTION = ""
SECTION = "libdevel"
SOURCE_PACKAGE = "libpcap"
HOMEPAGE = "https://www.tcpdump.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libp/libpcap/libpcap-dev_1.10.5-2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libp/libpcap/libpcap-dev_1.10.5-2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "764c79bf7560824504c04a43583d568c"
SRC_URI[deb0.sha1sum] = "0b52f536d9415d0d01297bb7b323164928e5a566"
SRC_URI[deb0.sha256sum] = "cb7c638a01e956d9e60a721b49808cb87ae74d4c2692dfd377dc33ec09a7b74e"
SRC_URI[deb0.sha512sum] = "d0611e0515bbf80f8d044c4dfebc201d57735b21eb895fd4a99cd8293c67b311f6cee7fd25c9965cb4d784ab09fe465d32f160fff61c725ec7946af192df280f"
SRC_URI[deb1.md5sum] = "54be0c40393df862e0c18a8d1c80ee6b"
SRC_URI[deb1.sha1sum] = "bf42afb64bc70e069e1e56434d0d588748a05e16"
SRC_URI[deb1.sha256sum] = "4704cf3d760fd45735cc27b0e4f2d4f8438af6980eb756a382307099bed92786"
SRC_URI[deb1.sha512sum] = "3fbb1798e454d8361957413f136e439f24f51b11122cce6469a7996fc9ee261e865bb3c85883b68a5e2f36d44509a7ae44a8a7e5a7b818ff77c49e4e814b4160"

RDEPENDS = " \
    libpcap0.8-dev \
"

