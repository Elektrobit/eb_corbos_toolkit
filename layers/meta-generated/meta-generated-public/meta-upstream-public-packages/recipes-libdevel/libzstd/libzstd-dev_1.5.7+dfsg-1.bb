# This was autogenerated! Do not modify
SUMMARY = "fast lossless compression algorithm -- development files"
DESCRIPTION = ""
SECTION = "libdevel"
SOURCE_PACKAGE = "libzstd"
HOMEPAGE = "https://github.com/facebook/zstd"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libz/libzstd/libzstd-dev_1.5.7+dfsg-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libz/libzstd/libzstd-dev_1.5.7+dfsg-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "9af76873fec47f09a9e9b0646fed1e15"
SRC_URI[deb0.sha1sum] = "d4d9826409b4f834f9f354b9156cf22c2288595d"
SRC_URI[deb0.sha256sum] = "de5f8aabcf4cb5cd1b441495ea4c24838e88ecbb30ae22c032a1b3b68a9d6f1e"
SRC_URI[deb0.sha512sum] = "abf1d590cbe38fd34ea02741e24c7a1211ac40c31de51fe79f23479a75cf2b116de6946fee2f127571a7d74898da8d7e1dc592027d15fd9d9086425bbdc50cab"
SRC_URI[deb1.md5sum] = "00ef03842ce1aa1a4baf57451f67167b"
SRC_URI[deb1.sha1sum] = "421abc1835dfec3e418580eb02cbe8cbbf7e8380"
SRC_URI[deb1.sha256sum] = "05cf42de5c9fdf17f49f663b47bfe736f10fbc7080fcc3a86ac43d5d670de149"
SRC_URI[deb1.sha512sum] = "e90349ebd801a3988da1aa75c9bff7dc6491c2605fed3c8f491b7b4395e9d6981f46eccb55706351e1b2b9b779f99287b0548d6f7eeb82821abaf1fe3c482c12"

RDEPENDS = " \
    libzstd1 \
"

