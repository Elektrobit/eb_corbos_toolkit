# This was autogenerated! Do not modify
SUMMARY = "GNU C Library: Development Libraries and Header Files"
DESCRIPTION = ""
SECTION = "libdevel"
SOURCE_PACKAGE = "glibc"
HOMEPAGE = "https://www.gnu.org/software/libc/libc.html"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/glibc/libc6-dev_2.41-12+deb13u3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/glibc/libc6-dev_2.41-12+deb13u3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "8216d95a967ba64cc7a45dcb697d1f53"
SRC_URI[deb0.sha1sum] = "fbb9e46e11e1a8365a4f067eb9d6ec10251df100"
SRC_URI[deb0.sha256sum] = "53a9b789bb02415d758f652ef5ac913d89fed29782610e9fe0fd2488e4f2e465"
SRC_URI[deb0.sha512sum] = "d5e82d45dca16468b2b5fa8871ef46c52e5b5dc1c78f67f3be695feaa4ae9438102492202560ff0c4dde5b3172a034b759e491498da79181eded8c159aeb3c29"
SRC_URI[deb1.md5sum] = "99d07a022cdf0f7183384f2e4559d4fb"
SRC_URI[deb1.sha1sum] = "b009545d0ef35bce018084a2ca524f3cbe3481e0"
SRC_URI[deb1.sha256sum] = "b2d2660900bd0bfe110b485532367774589d86d2e57b4ed74d8f06e3208a6959"
SRC_URI[deb1.sha512sum] = "ce199e33b6af63ea42f3bd72769eb9306a9545cc8464d2560c5190bbcc50c0b6e0ca359bf3b5dcb38e31e78bf1282d7ca380c9226238dffcc60a00804d985145"

RDEPENDS = " \
    libc-dev-bin \
    libc6 \
    libcrypt-dev \
    linux-libc-dev \
    rpcsvc-proto \
"

RPROVIDES = " \
    libc-dev \
"
