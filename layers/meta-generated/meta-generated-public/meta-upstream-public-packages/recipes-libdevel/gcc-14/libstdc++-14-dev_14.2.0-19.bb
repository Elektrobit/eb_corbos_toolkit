# This was autogenerated! Do not modify
SUMMARY = "GNU Standard C++ Library v3 (development files)"
DESCRIPTION = ""
SECTION = "libdevel"
SOURCE_PACKAGE = "gcc-14"
HOMEPAGE = "http://gcc.gnu.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gcc-14/libstdc++-14-dev_14.2.0-19_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gcc-14/libstdc++-14-dev_14.2.0-19_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "43bb5c62f553c0241d0ea1e2388397cf"
SRC_URI[deb0.sha1sum] = "cece15016d9bd18e9069e361ef1381a8a6667382"
SRC_URI[deb0.sha256sum] = "4b962fac5f1af0bd8b1b3f97e0f47b9d8e9a79e88802143f00ebfbd78ad87a7b"
SRC_URI[deb0.sha512sum] = "a886fb29d7c9108b8f5c5f3b7df1140f4419d20469faf270c4a684f75c49cc78e089edd381d40aacb69e9b0e0d811581f1c0810fc049610500af60bffdabdb4b"
SRC_URI[deb1.md5sum] = "48aa77f7427f3ac9aeadc8a930ae38ef"
SRC_URI[deb1.sha1sum] = "0ce58dc9b1c0b9fb4bb2d11d2115d3b0efe1a16e"
SRC_URI[deb1.sha256sum] = "8760122d044cd8eb8c69426311d6b5ce7bb8f0f76e9cda1944d153ae878138f8"
SRC_URI[deb1.sha512sum] = "9624e653a975d90bee676693ed312d79c8eb31e18bc43bcf8f5254ae3e84671c2d07a0a73c2e7b09cdfe94fc5e4062fe0f27d2278c4a1912de5d159514f79971"

RDEPENDS = " \
    gcc-14-base \
    libc6-dev \
    libgcc-14-dev \
    libstdc++6 \
"

RPROVIDES = " \
    libstdc++-dev \
"
