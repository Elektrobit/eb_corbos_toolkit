# This was autogenerated! Do not modify
SUMMARY = "Multiprecision arithmetic library developers tools"
DESCRIPTION = ""
SECTION = "libdevel"
SOURCE_PACKAGE = "gmp"
HOMEPAGE = "https://gmplib.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gmp/libgmp-dev_6.3.0+dfsg-3_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/gmp/libgmp-dev_6.3.0+dfsg-3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "36adea3ec912977d18c79057bc63a4ab"
SRC_URI[deb0.sha1sum] = "89c31c2173171aee7f43869578fd0011f6ae50f3"
SRC_URI[deb0.sha256sum] = "68f392cc03f896ecc3764eb4844d2a898ff016f47dda160465f152f811152b81"
SRC_URI[deb0.sha512sum] = "c5865115b939cad09d3100c610ce3f6e4d3de564e4ee01b0ece5931eb3cdfbd6a3b0f27819e761f149da2dea2f8aefc8d1b2d9e8ed9711c66e89a877a37d2d5c"
SRC_URI[deb1.md5sum] = "c5206c013e38691e07d5f346b91aa059"
SRC_URI[deb1.sha1sum] = "54c926b3beebf91b18f673b74e377d357e7416e4"
SRC_URI[deb1.sha256sum] = "903664ffe628948ffdcb0d7036d24437e477d7b02fc0c4f04a22f4b67447efae"
SRC_URI[deb1.sha512sum] = "8e55e8f5ab4731b3a4b3e8da1f69442443dbb81b23a10d25e31661b0630f2a014b0623fd72695c24325285e9634cb785e60479f21717cc044cd82fe27597243d"

RDEPENDS = " \
    libgmp10 \
    libgmpxx4ldbl \
"

RPROVIDES = " \
    libgmp10-dev \
"
