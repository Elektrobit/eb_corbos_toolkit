# This was autogenerated! Do not modify
SUMMARY = "developer's libraries for ncurses"
DESCRIPTION = ""
SECTION = "libdevel"
SOURCE_PACKAGE = "ncurses"
HOMEPAGE = "https://invisible-island.net/ncurses/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/n/ncurses/libncurses-dev_6.5+20250216-2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/n/ncurses/libncurses-dev_6.5+20250216-2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "6c7bedd5fca11443baaad1a5816f9569"
SRC_URI[deb0.sha1sum] = "e14183a68d59c151293b551e0e0923c189d94b3b"
SRC_URI[deb0.sha256sum] = "6bd7804e243fc08e2a2af380c341998bb6d21dd35550588ecc430d7c488a410d"
SRC_URI[deb0.sha512sum] = "940838e7ffe4a7be3144e27efded7e64ccae762e3b00d660a7f4437f978980c0c8e9ee728f0ddfaeb01d73e5c3f73f66953e56b3f6dc4d1a84aa0eb1f015944f"
SRC_URI[deb1.md5sum] = "94ff6654b7e2df16c2fe1025d6c531dc"
SRC_URI[deb1.sha1sum] = "b7da09d36b0f50d6cc24accb350fe832f8ea3e2b"
SRC_URI[deb1.sha256sum] = "3fec94323267a79e04073a62deb7f022fd9b1106330537849639aabd20efc396"
SRC_URI[deb1.sha512sum] = "ad033a5d9b354958dedab372b663488c03872680da89e17a0be23c7938c00f7f654ecef3191d7c671363b141feabe18c9244bf5988f49d124cafa093743a93f6"

RDEPENDS = " \
    libc6-dev \
    libncurses6 \
    libncursesw6 \
    libtinfo6 \
"

RPROVIDES = " \
    libncurses5-dev \
    libncursesw5-dev \
    libtinfo-dev \
    ncurses-dev \
"
