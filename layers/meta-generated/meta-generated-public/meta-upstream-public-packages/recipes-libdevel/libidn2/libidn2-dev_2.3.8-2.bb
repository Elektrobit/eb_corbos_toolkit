# This was autogenerated! Do not modify
SUMMARY = "Internationalized domain names (IDNA2008/TR46) development files"
DESCRIPTION = ""
SECTION = "libdevel"
SOURCE_PACKAGE = "libidn2"
HOMEPAGE = "https://www.gnu.org/software/libidn/#libidn2"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libi/libidn2/libidn2-dev_2.3.8-2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libi/libidn2/libidn2-dev_2.3.8-2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "6c8c06f09f8758a368c51c8cd009cb14"
SRC_URI[deb0.sha1sum] = "23cde0a1bbd1600e8dd9e675d4def6f2980e51f2"
SRC_URI[deb0.sha256sum] = "aeb3e0b149c7ca594065891c1f16e800689680f08f9119f90f95d1089f322a15"
SRC_URI[deb0.sha512sum] = "fc8441485b2ed689b039eaea9dfa2fd81cbdca252c8adc7eaab44e09d6ece1500c93e841cff16fdfebe6b778d7022636c63234fb799441fd98b59a8129e8d9aa"
SRC_URI[deb1.md5sum] = "55c910f8a5630300a1f68cb7f11bb059"
SRC_URI[deb1.sha1sum] = "2399b8a890d33da3a97465bb200d8412f990398a"
SRC_URI[deb1.sha256sum] = "c15483eaf07bdb7d1b84a263d5fce7cf27e4476b3c9fc74cb40ce4b388d3ed10"
SRC_URI[deb1.sha512sum] = "5c024f82510a3742e2dc7a03edecb91a7ba6b8c2575cb9501199bb418a48b949224e869ca77a50c10a78a77a334c2e554e7425e95497665b7123037809815992"

RDEPENDS = " \
    libidn2-0 \
"

RPROVIDES = " \
    libidn2-0-dev \
"
