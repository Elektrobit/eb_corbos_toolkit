# This was autogenerated! Do not modify
SUMMARY = "OpenLDAP development libraries"
DESCRIPTION = ""
SECTION = "libdevel"
SOURCE_PACKAGE = "openldap"
HOMEPAGE = "https://www.openldap.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/o/openldap/libldap-dev_2.6.10+dfsg-1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/o/openldap/libldap-dev_2.6.10+dfsg-1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "589a94b7f269a3e536d8b63780778239"
SRC_URI[deb0.sha1sum] = "48253ef88eec5ef1d3dee0a59bc0cd154301e417"
SRC_URI[deb0.sha256sum] = "f8543c82b923b0e137a0843e57d6fb96e3b9ca3f2e98fdb6d65e8b6d9c20e592"
SRC_URI[deb0.sha512sum] = "7712e8c5e4f3147e386172e105a8d2f2704a6ca200aeb1d863c28d06fa8178d1e23a1bddaee3f4590a3780b1994871dceeef4ce0eea40f942b89c023f876cf4e"
SRC_URI[deb1.md5sum] = "55fe11a290791f8281d88b1f47019e20"
SRC_URI[deb1.sha1sum] = "d0197b0b822664d51cc671070fa78f1afd8118eb"
SRC_URI[deb1.sha256sum] = "eb997ad6e35e2dc2812151b7154a286725fb464c2eae0179ab8fd0f7537c369f"
SRC_URI[deb1.sha512sum] = "2c18dc230030d7a5260a0b2e1289bddade762fb617ce3242eeadd36043d7ee6d509841d45492e61546556b7fa29663854b0dfdc1f7bcf48a7941a562ec1184c6"

RDEPENDS = " \
    libldap2 \
"

RPROVIDES = " \
    libldap2-dev \
"
