# This was autogenerated! Do not modify
SUMMARY = "Universally Unique ID library - headers and static libraries"
DESCRIPTION = ""
SECTION = "libdevel"
SOURCE_PACKAGE = "util-linux"
HOMEPAGE = "https://github.com/util-linux/util-linux"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/u/util-linux/uuid-dev_2.41-5_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/u/util-linux/uuid-dev_2.41-5_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "eeee16adb087bebf6b63916c1fe6fb63"
SRC_URI[deb0.sha1sum] = "05b9652f442e9b33da16bb41cc69283e2a9b7c33"
SRC_URI[deb0.sha256sum] = "fbc76c5c549192f52e7a03949108cdf28b1dc0751261495b7ef17cb8bf39dd8d"
SRC_URI[deb0.sha512sum] = "f3e81e65339d6391f202a65708146bfd9d967ad5a94f16c8981a7c6312bd78f179122c0253e28ca1360da70bffbc6c0ccd3d1418d34ba5c9b76c1af048016892"
SRC_URI[deb1.md5sum] = "0a0bdc27c384b4f6c2aa1a89845be7c3"
SRC_URI[deb1.sha1sum] = "cb5244c39df10c7ce2573dbf21944fe03d8a436b"
SRC_URI[deb1.sha256sum] = "142f2c809a9c239b94a1a09dccc02a49cc4b20990da687b60f849cda84dd580a"
SRC_URI[deb1.sha512sum] = "e6c2bbb4638bdcd435cded701369049d75b148b867b2e5ab2fc947a585298c697a910cce738d734f332a52c5e9a5b88ddbc9c704e352152db8809a97a0df4818"

RDEPENDS = " \
    libc6-dev \
    libuuid1 \
"

