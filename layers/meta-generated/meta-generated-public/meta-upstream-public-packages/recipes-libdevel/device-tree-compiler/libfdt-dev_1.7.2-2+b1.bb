# This was autogenerated! Do not modify
SUMMARY = "Flat Device Trees manipulation library - development files"
DESCRIPTION = ""
SECTION = "libdevel"
SOURCE_PACKAGE = "device-tree-compiler"
HOMEPAGE = "https://git.kernel.org/cgit/utils/dtc/dtc.git"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/d/device-tree-compiler/libfdt-dev_1.7.2-2+b1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/d/device-tree-compiler/libfdt-dev_1.7.2-2+b1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "64da04743c15a9e03acb9690a0bd37e1"
SRC_URI[deb0.sha1sum] = "dd5aa47f4e2c8811a44df1fa19d12e8fd9eeda1e"
SRC_URI[deb0.sha256sum] = "887d342dbf900697d830fcb72364afca3f15101edabf850e60c984e3733c898f"
SRC_URI[deb0.sha512sum] = "cb5a4d9657a49f98cecccede63a36749a969fc36cf7ea9b733b2457b12e778c6e252a3497a7cd39568bbdeaf39daee3d25f2331b2baef374997b7cde32bca073"
SRC_URI[deb1.md5sum] = "7d8f8b1605d40ef3f74a949cb1af8f75"
SRC_URI[deb1.sha1sum] = "6710da32038696111abfbebb7e839903847da2d3"
SRC_URI[deb1.sha256sum] = "1a36fda015c7a0354a308f98015e36eb87bba17c15937ecf0f89f2e91fdd6b9f"
SRC_URI[deb1.sha512sum] = "61c523f465673bffa614259376b6e38437c10f043bdbec08c5754d3e033dc51a4b0d374cc594d97458f57ad345da9faaf0c5aa7ef2c21387cff65694e6047dfe"

RDEPENDS = " \
    libfdt1 \
"

