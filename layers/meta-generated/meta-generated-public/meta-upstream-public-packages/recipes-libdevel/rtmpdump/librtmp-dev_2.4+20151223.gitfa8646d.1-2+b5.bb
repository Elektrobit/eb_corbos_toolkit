# This was autogenerated! Do not modify
SUMMARY = "toolkit for RTMP streams (development files)"
DESCRIPTION = ""
SECTION = "libdevel"
SOURCE_PACKAGE = "rtmpdump"
HOMEPAGE = "http://rtmpdump.mplayerhq.hu/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/r/rtmpdump/librtmp-dev_2.4+20151223.gitfa8646d.1-2+b5_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/r/rtmpdump/librtmp-dev_2.4+20151223.gitfa8646d.1-2+b5_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "c541a1caddcfedec112053cabac29ee3"
SRC_URI[deb0.sha1sum] = "dfbc57f734cb0fdfd4351c38062b6fa101134603"
SRC_URI[deb0.sha256sum] = "a888ac5f02cc5a51668a04d1d5477b6a1f29d32288c244839094dd7a26ac889c"
SRC_URI[deb0.sha512sum] = "e04cd7e9c48af8f4d80631fb71da33d3b2aeae47b5b35b66a48ee329620359c94a0874b9d5dc367b63149bd9f79be99dbeea4e6834d0bb86e185d3635ba51185"
SRC_URI[deb1.md5sum] = "dd8411302f2ef2f5abe94cc760229b60"
SRC_URI[deb1.sha1sum] = "5c61aa4be0873ae1ed0e1d15fd6e260915bf4298"
SRC_URI[deb1.sha256sum] = "c069718790422ca59e2b11a8d0e13ab4976ec795c616547058e3a417965a9bc8"
SRC_URI[deb1.sha512sum] = "b142f59dfd7f5616f57d77988fc679311ead209b7ecb846f82134f354fbca910bdbbacff7c0cb1cdd665d78a4968fcf1c0484947c0e8186f164f3aec4c01b046"

RDEPENDS = " \
    libgmp-dev \
    libgnutls28-dev \
    librtmp1 \
    nettle-dev \
    zlib1g-dev \
"

