# This was autogenerated! Do not modify
SUMMARY = "headers and development libraries for MIT Kerberos"
DESCRIPTION = ""
SECTION = "libdevel"
SOURCE_PACKAGE = "krb5"
HOMEPAGE = "https://web.mit.edu/kerberos/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/k/krb5/libkrb5-dev_1.21.3-5+deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/k/krb5/libkrb5-dev_1.21.3-5+deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "a94f101462154da80f761f9c50a23c43"
SRC_URI[deb0.sha1sum] = "4fef5fafa9bcf0df24e4cc6ad971283da129ffa7"
SRC_URI[deb0.sha256sum] = "62c3dbd746163878e73e22206d1dcc01f0f5296d3ca4ece5fb8cb7cb80396e4f"
SRC_URI[deb0.sha512sum] = "3fc9d044f67d9189c6f455e9c2dc3977b4319a2196635f72beb1bae4b5aab93fe3642120867f9381fc2c9465302cfb9e6f35d17268aa89081e0c7d030247a2a0"
SRC_URI[deb1.md5sum] = "20b08560b195cc02ba66e6e87fbda560"
SRC_URI[deb1.sha1sum] = "64beadcb3a742e5104045034f4813fed74c94569"
SRC_URI[deb1.sha256sum] = "c7923bdb8babd38ab443b7e7aac56e5f094c8a9031dd4f392716a563510f676e"
SRC_URI[deb1.sha512sum] = "7fc036804a119092010781d2536356bbf712b28163fff5e3f7b49a7fc760c00cc056408877f9b84f6a1c11792cef50575349e1f80c5c95bc1b074eb26e7820ae"

RDEPENDS = " \
    krb5-multidev \
"

