# This was autogenerated! Do not modify
SUMMARY = "Clang library - Common development package"
DESCRIPTION = ""
SECTION = "libdevel"
SOURCE_PACKAGE = "llvm-toolchain-19"
HOMEPAGE = "https://www.llvm.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/l/llvm-toolchain-19/libclang-common-19-dev_19.1.7-3+b1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/l/llvm-toolchain-19/libclang-common-19-dev_19.1.7-3+b1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "b1f7f1ccffbf0ace6fae3f0e1ca74e97"
SRC_URI[deb0.sha1sum] = "d2a65dae91f68289610efcfd9eb4c4308132cf36"
SRC_URI[deb0.sha256sum] = "4018e40e2d4144fe38c45822e68cca63c1bf6c7872c3073ebb262ad4b2f9b8bc"
SRC_URI[deb0.sha512sum] = "7fb5416b734e95720d11d274715028de08536027ae3fb5890d3f952758ed6d79eb31a6dd03c453acc464ee17636c4d719fac199e1a51185d07456b38f956dead"
SRC_URI[deb1.md5sum] = "a8850b194730fc521dadb73678e37463"
SRC_URI[deb1.sha1sum] = "0f0cd56391f65783ef63daf43d43de41fcab4391"
SRC_URI[deb1.sha256sum] = "fc0f2c5ffd2b2d7cd0119ed4fb1050c5757d0ed20a4f5c0964d8d737c73b0843"
SRC_URI[deb1.sha512sum] = "108ec9d483f47c34e8a6e430f6ef954575d256ece5333b85eeec1d7985eeb24795b9473e728246e31cf6c733bf20e29bad3c4a7fe37df325a832060b2c1981d5"


