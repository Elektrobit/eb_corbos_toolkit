# This was autogenerated! Do not modify
SUMMARY = "POSIX 1003.1e capabilities (development)"
DESCRIPTION = ""
SECTION = "libdevel"
SOURCE_PACKAGE = "libcap2"
HOMEPAGE = "https://sites.google.com/site/fullycapable/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libc/libcap2/libcap-dev_2.75-10+deb13u1+b1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libc/libcap2/libcap-dev_2.75-10+deb13u1+b1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "c42444a34bd5d7038b239a494c0e4b57"
SRC_URI[deb0.sha1sum] = "0f1157b480b41fa81255ebfe58b11b0767c5bbc6"
SRC_URI[deb0.sha256sum] = "cabb54ec097f89dd130902689a6bf38a67782fbf2aeca5f226ea656468843ec7"
SRC_URI[deb0.sha512sum] = "bcd09b63fb154bb53e1601199c225e636667900d16557f3a673cc9627fa7228983eb42249db288b6c4f981eace5478a13263d14d184479336967e1c48dc40cb2"
SRC_URI[deb1.md5sum] = "689b9e313c99b8b1bb9f545e72d66260"
SRC_URI[deb1.sha1sum] = "a5c6a45aae0d443be8f13ebc6eddfb3e83e23b55"
SRC_URI[deb1.sha256sum] = "f1c0687bb0f6ad192b9cbe64429fc76029ce2a11939b155051139caf1683b447"
SRC_URI[deb1.sha512sum] = "89af57a31acc28719157fc45828fc512cdee5935126fb318a130b551700465aa1adc4a1d471191f12ac62b1f78cf68a799464b73ec137fbb6cf34c467100fd42"

RDEPENDS = " \
    libc6 \
    libcap2 \
"

RPROVIDES = " \
    libcap2-dev \
"
