# This was autogenerated! Do not modify
SUMMARY = "Common utility API's used in elos and samconf"
DESCRIPTION = "Library of common utility API's used in elos and samconf. \
 \
Runtime library package."
SECTION = "libs"
SOURCE_PACKAGE = "safu"
HOMEPAGE = "https://github.com/Elektrobit/safu"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/s/safu/libsafu0_0.0.1_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "dcea1e50868372367cb514cd84c6c7f3"
SRC_URI[deb0.sha1sum] = "0559b594dcdd030171737aaad736d14972f9c7bd"
SRC_URI[deb0.sha256sum] = "e40723f94c833de3c985a62a3c9f36b59f36fd817ed7a436210d75d6d084c167"

RDEPENDS = " \
    libc6 \
    libjson-c5 \
"

