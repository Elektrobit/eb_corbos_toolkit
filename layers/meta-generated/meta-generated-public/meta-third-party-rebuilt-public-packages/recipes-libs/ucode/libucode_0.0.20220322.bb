# This was autogenerated! Do not modify
SUMMARY = "Shared library for the ucode interpreter"
DESCRIPTION = "Ucode is a tiny script language featuring ECMA script syntax, builtin JSON \
support and templating using Jinja inspired markup. The ucode VM is provided \
as shared library with a C API allowing embedding into host applications and \
interchanging data between ucode and C programs. The ucode VM can also be \
used as stand-alone multi purpose scripting language through the provided \
ucode cli interpreter. \
 \
This package contains the libucode VM runtime, it should not be needed to \
install it explicitly."
SECTION = "libs"
SOURCE_PACKAGE = "ucode"
HOMEPAGE = "https://github.com/jow-/ucode"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/u/ucode/libucode_0.0.20220322_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "ed0d0d37211460ecb417817a954c5846"
SRC_URI[deb0.sha1sum] = "bc8d8d8ab8361c6a0329d70f4e28373cf224cc61"
SRC_URI[deb0.sha256sum] = "a72563591b0ab554159cce9c35d2507f4941adfd54f6e6472173080aba91bf97"

RDEPENDS = " \
    libc6 \
    libjson-c5 \
"

