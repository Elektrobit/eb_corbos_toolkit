# This was autogenerated! Do not modify
SUMMARY = "Signed and mergable configuration"
DESCRIPTION = "It stands for signed and mergable configuration. It is used by elos. The \
goal of the library is to manage program configuration options from various \
sources including support for verification of the configuration sources."
SECTION = "libs"
SOURCE_PACKAGE = "samconf"
HOMEPAGE = "https://github.com/Elektrobit/samconf"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/s/samconf/libsamconf0_0.0.1_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "77509525fa2ba904c35f4498bb167ce7"
SRC_URI[deb0.sha1sum] = "00d2458e22043ee7682e476f0381985005bdcc31"
SRC_URI[deb0.sha256sum] = "ebde7ff4fed23052ffc1834a32bcfe41d5e03c734e84282529ca032252068189"

RDEPENDS = " \
    libc6 \
    libjson-c5 \
    libsafu0 \
    libssl3t64 \
"

