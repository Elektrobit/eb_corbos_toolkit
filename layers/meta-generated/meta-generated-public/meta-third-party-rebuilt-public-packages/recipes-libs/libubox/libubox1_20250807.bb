# This was autogenerated! Do not modify
SUMMARY = "A library used by many OpenWrt projects"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libubox"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/libu/libubox/libubox1_20250807_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "1dbb3a871c91c378b6b8840f4588c431"
SRC_URI[deb0.sha1sum] = "7cfdf6110a6e0dc367a09c81783dfb9f4cbd30cf"
SRC_URI[deb0.sha256sum] = "92ba7a5655710054ffc80a9c38096d9e1f8f6ca96edfcfba9c521220adccfb7c"

RDEPENDS = " \
    libc6 \
"

