# This was autogenerated! Do not modify
SUMMARY = "Event logging and management with normalized output-format (shmem plugin)"
DESCRIPTION = "elos is a tool to collect, store and publish various system events (i.e. \
syslogs, core dumps, measurements obtained from proc- and sys-fs, ...) \
while providing easy access to the collected data. \
 \
Shmem scanner plugin."
SECTION = "libs"
SOURCE_PACKAGE = "elos"
HOMEPAGE = "https://github.com/Elektrobit/elos"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/e/elos/elos-plugin-scanner-shmem_0.0.1_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "8d71b270fe79bc504ba6c438d04e3629"
SRC_URI[deb0.sha1sum] = "73079374a6c53b4b4db27c4523fc2a8968fe77e0"
SRC_URI[deb0.sha256sum] = "81fd54419106a9202d9c9df4559bbcd0aff45ab055c10b297cbe507b96267680"

RDEPENDS = " \
    libc6 \
    libelosplugin1 \
    libsafu0 \
    libsamconf0 \
"

