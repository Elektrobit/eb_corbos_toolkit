# This was autogenerated! Do not modify
SUMMARY = "Event logging and management with normalized output-format (DLT plugin)"
DESCRIPTION = "elos is a tool to collect, store and publish various system events (i.e. \
syslogs, core dumps, measurements obtained from proc- and sys-fs, ...) \
while providing easy access to the collected data. \
 \
DLT backend plugin."
SECTION = "libs"
SOURCE_PACKAGE = "elos"
HOMEPAGE = "https://github.com/Elektrobit/elos"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/e/elos/elos-plugin-backend-dlt_0.0.1_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "cc28ee4dada6e4024c56dfe82376dc97"
SRC_URI[deb0.sha1sum] = "1f7abb6ff38491f569a1a39b3e952e27c0cece66"
SRC_URI[deb0.sha256sum] = "2f0dbf24e40c4f7574bcca63c0ffd15a30798121863e10db53d02834d2b8cefb"

RDEPENDS = " \
    libc6 \
    libelosdlt1 \
    libelosplugin1 \
    libsafu0 \
    libsamconf0 \
"

