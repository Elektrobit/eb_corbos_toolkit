# This was autogenerated! Do not modify
SUMMARY = "Event logging and management with normalized output-format (Dummy plugin)"
DESCRIPTION = "elos is a tool to collect, store and publish various system events (i.e. \
syslogs, core dumps, measurements obtained from proc- and sys-fs, ...) \
while providing easy access to the collected data. \
 \
Dummy backend plugin."
SECTION = "libs"
SOURCE_PACKAGE = "elos"
HOMEPAGE = "https://github.com/Elektrobit/elos"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/e/elos/elos-plugin-backend-dummy_0.0.1_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "1d9236fab2c7411103266ca5fbfcd847"
SRC_URI[deb0.sha1sum] = "f91681c37204cb2f33fd6774b31210fe66dccd96"
SRC_URI[deb0.sha256sum] = "1cf3e5b68ea2ccca4aed7ece4e66bb7013128866285c029211f0121fa20860b7"

RDEPENDS = " \
    libc6 \
    libelosplugin1 \
    libsafu0 \
"

