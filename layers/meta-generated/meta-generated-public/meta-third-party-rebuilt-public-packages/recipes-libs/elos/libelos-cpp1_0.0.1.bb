# This was autogenerated! Do not modify
SUMMARY = "Event logging and management with normalized output-format C++ library"
DESCRIPTION = "elos is a tool to collect, store and publish various system events (i.e. \
syslogs, core dumps, measurements obtained from proc- and sys-fs, ...) \
while providing easy access to the collected data. \
 \
C++ shared library package."
SECTION = "libs"
SOURCE_PACKAGE = "elos"
HOMEPAGE = "https://github.com/Elektrobit/elos"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/e/elos/libelos-cpp1_0.0.1_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "be1ef06630e8926b209365ab0999a74e"
SRC_URI[deb0.sha1sum] = "911cb4968dfb408a2daf62349d295039d1fbe480"
SRC_URI[deb0.sha256sum] = "881afe38547c554fa0f25c33e8bb47a90d98a6607436f0a4e3046bb3625e2901"

RDEPENDS = " \
    libc6 \
    libelos-common1 \
    libelos1 \
    libgcc-s1 \
    libsafu0 \
    libstdc++6 \
"

