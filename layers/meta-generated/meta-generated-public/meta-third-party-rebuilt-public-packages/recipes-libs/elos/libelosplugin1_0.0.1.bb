# This was autogenerated! Do not modify
SUMMARY = "Event logging and management with normalized output-format plugin library"
DESCRIPTION = "elos is a tool to collect, store and publish various system events (i.e. \
syslogs, core dumps, measurements obtained from proc- and sys-fs, ...) \
while providing easy access to the collected data. \
 \
Plugin shared library package."
SECTION = "libs"
SOURCE_PACKAGE = "elos"
HOMEPAGE = "https://github.com/Elektrobit/elos"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/e/elos/libelosplugin1_0.0.1_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "5325c551cdcc64e545398efd5ab2dc30"
SRC_URI[deb0.sha1sum] = "713f700028bfef4f61ce2cdb0962593048bae98b"
SRC_URI[deb0.sha256sum] = "e0a238fc3bde4144f214b1b0d1809200602a9249bea6b996efd0468a292032da"

RDEPENDS = " \
    libc6 \
    libelos-common1 \
    libjson-c5 \
    libsafu0 \
    libsamconf0 \
"

