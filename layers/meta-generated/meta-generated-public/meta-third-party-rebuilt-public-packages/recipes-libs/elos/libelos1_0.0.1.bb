# This was autogenerated! Do not modify
SUMMARY = "Event logging and management with normalized output-format library"
DESCRIPTION = "elos is a tool to collect, store and publish various system events (i.e. \
syslogs, core dumps, measurements obtained from proc- and sys-fs, ...) \
while providing easy access to the collected data. \
 \
Shared library package."
SECTION = "libs"
SOURCE_PACKAGE = "elos"
HOMEPAGE = "https://github.com/Elektrobit/elos"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/e/elos/libelos1_0.0.1_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "8ad10fb1d8b2f3f38366a1d6c1a6a5a2"
SRC_URI[deb0.sha1sum] = "bea641da61ddbfec47a4b6262b214d4a8af1eaee"
SRC_URI[deb0.sha256sum] = "e6d5e4a522e12527b220e238b491cf6578ebb3c14cf4437f8d853e0c3990e7c5"

RDEPENDS = " \
    libc6 \
    libelos-common1 \
    libjson-c5 \
    libsafu0 \
"

