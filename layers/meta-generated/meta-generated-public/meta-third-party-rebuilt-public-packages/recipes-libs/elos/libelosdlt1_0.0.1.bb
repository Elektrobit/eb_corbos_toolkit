# This was autogenerated! Do not modify
SUMMARY = "Event logging and management with normalized output-format DLT library"
DESCRIPTION = "elos is a tool to collect, store and publish various system events (i.e. \
syslogs, core dumps, measurements obtained from proc- and sys-fs, ...) \
while providing easy access to the collected data. \
 \
DLT shared library package."
SECTION = "libs"
SOURCE_PACKAGE = "elos"
HOMEPAGE = "https://github.com/Elektrobit/elos"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/e/elos/libelosdlt1_0.0.1_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "b54de4aa94de65c8bc073fd3976d5e61"
SRC_URI[deb0.sha1sum] = "847b804e49056198cf8e2e363bda0e276e7f6b16"
SRC_URI[deb0.sha256sum] = "4b8c2fab2fd47f68b2134f9d04e57d37ae6735f3c1c763cc08c1546306333455"

RDEPENDS = " \
    libc6 \
    libsafu0 \
"

