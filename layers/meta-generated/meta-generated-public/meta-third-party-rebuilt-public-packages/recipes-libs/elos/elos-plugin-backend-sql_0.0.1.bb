# This was autogenerated! Do not modify
SUMMARY = "Event logging and management with normalized output-format (SQL plugin)"
DESCRIPTION = "elos is a tool to collect, store and publish various system events (i.e. \
syslogs, core dumps, measurements obtained from proc- and sys-fs, ...) \
while providing easy access to the collected data. \
 \
DLT backend plugin."
SECTION = "libs"
SOURCE_PACKAGE = "elos"
HOMEPAGE = "https://github.com/Elektrobit/elos"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/e/elos/elos-plugin-backend-sql_0.0.1_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "63ac869b0cebe2b2e5fd41aa146c39b7"
SRC_URI[deb0.sha1sum] = "373c8cdbfd3f37dcb8497362e65a083817b99d9d"
SRC_URI[deb0.sha256sum] = "6c0b25dfe3c964135a0e66daf79af92b1e6072d2e414b0cb638ad1ea5c56d5e3"

RDEPENDS = " \
    libc6 \
    libelosplugin1 \
    libsafu0 \
    libsamconf0 \
    libsqlite3-0 \
"

