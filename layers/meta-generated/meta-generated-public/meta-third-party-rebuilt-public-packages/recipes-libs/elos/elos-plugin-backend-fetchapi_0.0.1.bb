# This was autogenerated! Do not modify
SUMMARY = "Event logging and management with normalized output-format (Dummy plugin)"
DESCRIPTION = "elos is a tool to collect, store and publish various system events (i.e. \
syslogs, core dumps, measurements obtained from proc- and sys-fs, ...) \
while providing easy access to the collected data. \
 \
A backend which implements the fetch API, thus elos can provide historical events."
SECTION = "libs"
SOURCE_PACKAGE = "elos"
HOMEPAGE = "https://github.com/Elektrobit/elos"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/e/elos/elos-plugin-backend-fetchapi_0.0.1_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "503fd1a0ee6aa382a467ef4c460779d9"
SRC_URI[deb0.sha1sum] = "54796c5f940b402764522b0bab33207a0a4dc33a"
SRC_URI[deb0.sha256sum] = "37f1ad624a1a4cd05461c624c1746f750dd060b7ce5c5557c5e63466bc6139da"

RDEPENDS = " \
    libelosplugin1 \
    libgcc-s1 \
    libsafu0 \
    libsamconf0 \
    libstdc++6 \
"

