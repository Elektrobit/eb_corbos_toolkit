# This was autogenerated! Do not modify
SUMMARY = "Event logging and management with normalized output-format (syslog plugin)"
DESCRIPTION = "elos is a tool to collect, store and publish various system events (i.e. \
syslogs, core dumps, measurements obtained from proc- and sys-fs, ...) \
while providing easy access to the collected data. \
 \
Syslog scanner plugin."
SECTION = "libs"
SOURCE_PACKAGE = "elos"
HOMEPAGE = "https://github.com/Elektrobit/elos"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/e/elos/elos-plugin-scanner-syslog_0.0.1_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "dc1833a67087961731bd353a01bf64f6"
SRC_URI[deb0.sha1sum] = "9e913f2e55137c3d872b163546e479f0d580480e"
SRC_URI[deb0.sha256sum] = "89dbf4bf2a6528097cb26ecbe5610c824c9586c924a5f8282d1402a5481465df"

RDEPENDS = " \
    libc6 \
    libelosplugin1 \
    libsafu0 \
    libsamconf0 \
"

