# This was autogenerated! Do not modify
SUMMARY = "Event logging and management with normalized output-format (JSON plugin)"
DESCRIPTION = "elos is a tool to collect, store and publish various system events (i.e. \
syslogs, core dumps, measurements obtained from proc- and sys-fs, ...) \
while providing easy access to the collected data. \
 \
JSON backend plugin."
SECTION = "libs"
SOURCE_PACKAGE = "elos"
HOMEPAGE = "https://github.com/Elektrobit/elos"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/e/elos/elos-plugin-backend-json_0.0.1_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "7a66bfc9b86f1a915f566b1141b59320"
SRC_URI[deb0.sha1sum] = "f80f05ad072e6269492bd9e97ebf3bec5131fb97"
SRC_URI[deb0.sha256sum] = "b4c3c4639c18c062d16e8b03dedeb1384acd5a00bb9d907476589ce1c05f3358"

RDEPENDS = " \
    libc6 \
    libelosplugin1 \
    libsafu0 \
    libsamconf0 \
"

