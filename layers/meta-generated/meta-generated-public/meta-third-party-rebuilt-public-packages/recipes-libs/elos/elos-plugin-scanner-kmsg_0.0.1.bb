# This was autogenerated! Do not modify
SUMMARY = "Event logging and management with normalized output-format (kmsg scanner plugin)"
DESCRIPTION = "elos is a tool to collect, store and publish various system events (i.e. \
syslogs, core dumps, measurements obtained from proc- and sys-fs, ...) \
while providing easy access to the collected data. \
 \
Kmsg scanner plugin."
SECTION = "libs"
SOURCE_PACKAGE = "elos"
HOMEPAGE = "https://github.com/Elektrobit/elos"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/e/elos/elos-plugin-scanner-kmsg_0.0.1_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "5815f2fc6a46e747f113262d25a77e4c"
SRC_URI[deb0.sha1sum] = "c3bc879f99841865c786df1d91bb1ee8a1a186c2"
SRC_URI[deb0.sha256sum] = "31384d188eb32f6fb9320260228a8ba27cbc410f518386175c10be1a40347a8f"

RDEPENDS = " \
    libc6 \
    libelosplugin1 \
    libsafu0 \
    libsamconf0 \
"

