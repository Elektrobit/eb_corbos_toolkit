# This was autogenerated! Do not modify
SUMMARY = "Event logging and management with normalized output-format (InfluxDB plugin)"
DESCRIPTION = "elos is a tool to collect, store and publish various system events (i.e. \
syslogs, core dumps, measurements obtained from proc- and sys-fs, ...) \
while providing easy access to the collected data. \
 \
InfluxDB backend plugin."
SECTION = "libs"
SOURCE_PACKAGE = "elos"
HOMEPAGE = "https://github.com/Elektrobit/elos"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/e/elos/elos-plugin-backend-influxdb_0.0.1_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "98ad2db30ecd1e2477683a9c9caa005d"
SRC_URI[deb0.sha1sum] = "34ae8f4e65c1f1436eee7c4a2b21e4dbc4b12338"
SRC_URI[deb0.sha256sum] = "896ef5a7f681cad1b352c9d97f50e92b42775e64e37d3b05179673e6ee28cf15"

RDEPENDS = " \
    libc6 \
    libcurl4t64 \
    libelosplugin1 \
    libjson-c5 \
    libsafu0 \
"

