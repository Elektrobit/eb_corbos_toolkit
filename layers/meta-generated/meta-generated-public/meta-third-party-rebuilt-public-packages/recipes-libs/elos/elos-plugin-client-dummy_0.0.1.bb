# This was autogenerated! Do not modify
SUMMARY = "Event logging and management with normalized output-format (Dummy client plugin)"
DESCRIPTION = "elos is a tool to collect, store and publish various system events (i.e. \
syslogs, core dumps, measurements obtained from proc- and sys-fs, ...) \
while providing easy access to the collected data. \
 \
Dummy client plugin."
SECTION = "libs"
SOURCE_PACKAGE = "elos"
HOMEPAGE = "https://github.com/Elektrobit/elos"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/e/elos/elos-plugin-client-dummy_0.0.1_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "6d645659057c6d6e2e0f26d3737b42b2"
SRC_URI[deb0.sha1sum] = "793ddb82bfb7b82c77ed76f5b6e2cab138aa1c4b"
SRC_URI[deb0.sha256sum] = "3fb5b5325b3c7b53118e57b85ff75d0c00786a41b9f644cf7b28f156d72d21be"

RDEPENDS = " \
    libc6 \
    libelosplugin1 \
    libsafu0 \
"

