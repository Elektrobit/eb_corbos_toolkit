# This was autogenerated! Do not modify
SUMMARY = "Event logging and management with normalized output-format (Dummy plugin)"
DESCRIPTION = "elos is a tool to collect, store and publish various system events (i.e. \
syslogs, core dumps, measurements obtained from proc- and sys-fs, ...) \
while providing easy access to the collected data. \
 \
Dummy scanner plugin."
SECTION = "libs"
SOURCE_PACKAGE = "elos"
HOMEPAGE = "https://github.com/Elektrobit/elos"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/e/elos/elos-plugin-scanner-dummy_0.0.1_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "f765062e7d58eff5e9a15137f9474652"
SRC_URI[deb0.sha1sum] = "0ca90e05c4b8fe9a9904083b15cb7dad0d10c359"
SRC_URI[deb0.sha256sum] = "2d1dab44d583cf14662cdefb952e22d5f1e9852a131b5a9fc2e98031acc0ff4f"

RDEPENDS = " \
    libc6 \
    libelosplugin1 \
    libsafu0 \
"

