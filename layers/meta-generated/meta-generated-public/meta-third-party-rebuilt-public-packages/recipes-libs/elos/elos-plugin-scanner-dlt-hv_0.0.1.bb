# This was autogenerated! Do not modify
SUMMARY = "Event logging and management with normalized output-format (dlt scanner plugin)"
DESCRIPTION = "elos is a tool to collect, store and publish various system events (i.e. \
syslogs, core dumps, measurements obtained from proc- and sys-fs, ...) \
while providing easy access to the collected data. \
 \
DLT-HV scanner plugin."
SECTION = "libs"
SOURCE_PACKAGE = "elos"
HOMEPAGE = "https://github.com/Elektrobit/elos"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/e/elos/elos-plugin-scanner-dlt-hv_0.0.1_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "491e55bccd4b7d6ba5e9447e0cd4844a"
SRC_URI[deb0.sha1sum] = "10d6fbd1ac3b6e165eda76effe77cfd5bdf89189"
SRC_URI[deb0.sha256sum] = "d00a82054c593a1af09610bfd80100fe7431db4a5bce95d22d3cb99d0a4a285f"

RDEPENDS = " \
    libc6 \
    libelosdlt1 \
    libelosplugin1 \
    libsafu0 \
    libsamconf0 \
"

