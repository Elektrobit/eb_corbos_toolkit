# This was autogenerated! Do not modify
SUMMARY = "OpenWrt micro bus architecture"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "ubus"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/u/ubus/libubus1_20250807_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "73c0a904a7329891421d9bc245b57516"
SRC_URI[deb0.sha1sum] = "1a9f5d517353c7a9831d7620634a34f28bf32dfa"
SRC_URI[deb0.sha256sum] = "1246b28537e032fab202a2a7097dc5eae1c9e29e24ef4941641b4159f0eb6e12"

RDEPENDS = " \
    libc6 \
    libubox1 \
"

