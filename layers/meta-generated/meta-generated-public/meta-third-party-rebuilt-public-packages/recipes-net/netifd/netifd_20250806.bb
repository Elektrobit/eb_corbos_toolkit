# This was autogenerated! Do not modify
SUMMARY = "Network Interface Daemon"
DESCRIPTION = ""
SECTION = "net"
SOURCE_PACKAGE = "netifd"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/n/netifd/netifd_20250806_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "9e27426724b5015839c5ad94cc2df2ad"
SRC_URI[deb0.sha1sum] = "34e2026bc934922173463af56beaf3b6de4d6e4f"
SRC_URI[deb0.sha256sum] = "c1e4485dba05ca7a6184122987c9c8ebeff92185cab90db824672eca471d6292"

RDEPENDS = " \
    libblobmsg-json1 \
    libc6 \
    libjson-c5 \
    libnl-3-200 \
    libubox1 \
    libubus1 \
    libuci1 \
    libucode \
    ubus \
    ucode \
"

