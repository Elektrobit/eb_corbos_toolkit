# This was autogenerated! Do not modify
SUMMARY = "debug symbols for libjson-script1"
DESCRIPTION = ""
SECTION = "debug"
SOURCE_PACKAGE = "libubox"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/libu/libubox/libjson-script1-dbgsym_20250807_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "4bf776618bb38e7e18a40e476747abfa"
SRC_URI[deb0.sha1sum] = "1e189ea9ca8eb4b542066b443010b47f3adb0ea1"
SRC_URI[deb0.sha256sum] = "cf7c9fbb65969805d84dd8720b9e8c4d3b75c0ec5d491dfb48d8c47ec7283524"

RDEPENDS = " \
    libjson-script1 \
"

