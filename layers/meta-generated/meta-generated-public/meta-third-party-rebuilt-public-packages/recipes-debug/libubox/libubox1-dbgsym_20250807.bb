# This was autogenerated! Do not modify
SUMMARY = "debug symbols for libubox1"
DESCRIPTION = ""
SECTION = "debug"
SOURCE_PACKAGE = "libubox"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/libu/libubox/libubox1-dbgsym_20250807_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "eee0af5bf954b703260db5b62009c116"
SRC_URI[deb0.sha1sum] = "c5a93aaf1d7307c470c3a97dcb5cb67c4adc684e"
SRC_URI[deb0.sha256sum] = "f5252bdfe34827fdfda2676087041957383bc7fb50ee2352e77b80547a3d64a3"

RDEPENDS = " \
    libubox1 \
"

