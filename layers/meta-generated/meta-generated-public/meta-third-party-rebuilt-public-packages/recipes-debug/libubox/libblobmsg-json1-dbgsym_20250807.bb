# This was autogenerated! Do not modify
SUMMARY = "debug symbols for libblobmsg-json1"
DESCRIPTION = ""
SECTION = "debug"
SOURCE_PACKAGE = "libubox"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/libu/libubox/libblobmsg-json1-dbgsym_20250807_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "217ea24af6516f4d1f8d0d61f0217bc4"
SRC_URI[deb0.sha1sum] = "25e638875f3d6716ef73c6c368853b74849de92e"
SRC_URI[deb0.sha256sum] = "2b3ba92aac4b8cbbba8bf3e7e3f0f0ddd34abf6601bc67d49fb1bad9b3213715"

RDEPENDS = " \
    libblobmsg-json1 \
"

