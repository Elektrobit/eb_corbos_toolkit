# This was autogenerated! Do not modify
SUMMARY = "debug symbols for libuci1"
DESCRIPTION = ""
SECTION = "debug"
SOURCE_PACKAGE = "uci"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/u/uci/libuci1-dbgsym_20250206_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "79cdd561487a233ccdbb0ae42e5b5c40"
SRC_URI[deb0.sha1sum] = "b79a5d50dacfbe2df35ca6e81244035970bf7829"
SRC_URI[deb0.sha256sum] = "ed0d73a94aa28beeba71789256ede234596b582f54db9e73a8e82afc1de316e9"

RDEPENDS = " \
    libuci1 \
"

