# This was autogenerated! Do not modify
SUMMARY = "debug symbols for libucode"
DESCRIPTION = ""
SECTION = "debug"
SOURCE_PACKAGE = "ucode"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/u/ucode/libucode-dbgsym_0.0.20220322_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "875b4588c3b3f55f368d56990c0cbffc"
SRC_URI[deb0.sha1sum] = "2828ae97acaf89270271bfbdc16be505fff46c19"
SRC_URI[deb0.sha256sum] = "e7cbb51edc1810fa5b0a6b8adbc4a828245acea9f2dfc2a1856aefeb2f69e012"

RDEPENDS = " \
    libucode \
"

