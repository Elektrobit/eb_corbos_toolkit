# This was autogenerated! Do not modify
SUMMARY = "debug symbols for ucode-modules"
DESCRIPTION = ""
SECTION = "debug"
SOURCE_PACKAGE = "ucode"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/u/ucode/ucode-modules-dbgsym_0.0.20220322_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "72b2b9a3af0a0753624aecdf48f14192"
SRC_URI[deb0.sha1sum] = "e664484dc940bcc3ed982708d37ded8d2d8cf4dc"
SRC_URI[deb0.sha256sum] = "d3dca313d9dadd07166aec0b8401fe09c0da47536c883e9226eec3a8daa3c6f0"

RDEPENDS = " \
    ucode-modules \
"

