# This was autogenerated! Do not modify
SUMMARY = "debug symbols for netifd"
DESCRIPTION = ""
SECTION = "debug"
SOURCE_PACKAGE = "netifd"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/n/netifd/netifd-dbgsym_20250806_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "566d157ca71b84c0df883c6245b71b8a"
SRC_URI[deb0.sha1sum] = "6dddab7deaacc8482dbbf9a1a3c4a10c0328a472"
SRC_URI[deb0.sha256sum] = "9d6ec302bb214683dca06ad49e8f25ac52d6c7b9a17bf353c55c4ab76328de7d"

RDEPENDS = " \
    netifd \
"

