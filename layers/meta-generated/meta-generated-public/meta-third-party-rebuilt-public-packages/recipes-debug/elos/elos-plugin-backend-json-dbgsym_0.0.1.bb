# This was autogenerated! Do not modify
SUMMARY = "debug symbols for elos-plugin-backend-json"
DESCRIPTION = ""
SECTION = "debug"
SOURCE_PACKAGE = "elos"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/e/elos/elos-plugin-backend-json-dbgsym_0.0.1_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "ecb86907832c98070b4680530c7f2efa"
SRC_URI[deb0.sha1sum] = "4e2ebff8b3d6880ee6d0271ecfba2797246a221e"
SRC_URI[deb0.sha256sum] = "ca1304e853331f162b6565298a64d0201a5e5e784594af2b8ee0bc7f1a302610"

RDEPENDS = " \
    elos-plugin-backend-json \
"

