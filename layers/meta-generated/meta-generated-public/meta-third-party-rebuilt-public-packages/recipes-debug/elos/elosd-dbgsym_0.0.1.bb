# This was autogenerated! Do not modify
SUMMARY = "debug symbols for elosd"
DESCRIPTION = ""
SECTION = "debug"
SOURCE_PACKAGE = "elos"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/e/elos/elosd-dbgsym_0.0.1_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "e3aed43f7033a917ff7d5766b9d03b9b"
SRC_URI[deb0.sha1sum] = "8b13b2bd77542ae71d4c6a660c967d4fd4d0ed32"
SRC_URI[deb0.sha256sum] = "5cdb6c6f5feabfc9cc92539586f26532b28b0e1518dc4aaa32ff01ae9865fdd9"

RDEPENDS = " \
    elosd \
"

