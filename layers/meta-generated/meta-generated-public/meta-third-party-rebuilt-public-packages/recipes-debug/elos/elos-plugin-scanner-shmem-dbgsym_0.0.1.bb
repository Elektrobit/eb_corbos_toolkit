# This was autogenerated! Do not modify
SUMMARY = "debug symbols for elos-plugin-scanner-shmem"
DESCRIPTION = ""
SECTION = "debug"
SOURCE_PACKAGE = "elos"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/e/elos/elos-plugin-scanner-shmem-dbgsym_0.0.1_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "153d05605519f17183f580248593a26e"
SRC_URI[deb0.sha1sum] = "9f3acb1973f801cba2527d9b54d89181f83fb1f2"
SRC_URI[deb0.sha256sum] = "d34d62600a693bd2b1ee7aed0535bbfabe70782deb53db3a65ce80e186c7194e"

RDEPENDS = " \
    elos-plugin-scanner-shmem \
"

