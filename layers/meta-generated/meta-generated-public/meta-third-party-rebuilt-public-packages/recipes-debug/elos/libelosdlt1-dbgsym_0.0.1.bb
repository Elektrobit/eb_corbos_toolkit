# This was autogenerated! Do not modify
SUMMARY = "debug symbols for libelosdlt1"
DESCRIPTION = ""
SECTION = "debug"
SOURCE_PACKAGE = "elos"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/e/elos/libelosdlt1-dbgsym_0.0.1_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "232ed7b6592eebbc6475ff3c2588e236"
SRC_URI[deb0.sha1sum] = "4df9d5bca63893892f4825d3a6e2ca78b080b903"
SRC_URI[deb0.sha256sum] = "7cfa9c03a2ef7904425ec69e4fab3493d6bfcaf65788d576060539c38a4980f8"

RDEPENDS = " \
    libelosdlt1 \
"

