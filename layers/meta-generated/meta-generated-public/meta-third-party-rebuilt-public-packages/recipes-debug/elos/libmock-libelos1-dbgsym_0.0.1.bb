# This was autogenerated! Do not modify
SUMMARY = "debug symbols for libmock-libelos1"
DESCRIPTION = ""
SECTION = "debug"
SOURCE_PACKAGE = "elos"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/e/elos/libmock-libelos1-dbgsym_0.0.1_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "f9823033cdda8419e5987839b8d57233"
SRC_URI[deb0.sha1sum] = "b61418bda719fa1f87bc8a908f4a28b3b15d2ca0"
SRC_URI[deb0.sha256sum] = "e063b5cdf82c3fb3f1ab59579f4cbaa67e5db7f61267f0a28bfe8d8d90e6c99e"

RDEPENDS = " \
    libmock-libelos1 \
"

