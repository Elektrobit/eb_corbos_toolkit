# This was autogenerated! Do not modify
SUMMARY = "debug symbols for elos-coredump"
DESCRIPTION = ""
SECTION = "debug"
SOURCE_PACKAGE = "elos"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/e/elos/elos-coredump-dbgsym_0.0.1_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "3791480dc8b15df95eadbe14dd1160a6"
SRC_URI[deb0.sha1sum] = "fee3539b4d53583f82b228b5f2612cc1fc343ee9"
SRC_URI[deb0.sha256sum] = "a95bf87da21f98dd2751ec85a760d53595c8d7dd0113894618a9aae851600633"

RDEPENDS = " \
    elos-coredump \
"

