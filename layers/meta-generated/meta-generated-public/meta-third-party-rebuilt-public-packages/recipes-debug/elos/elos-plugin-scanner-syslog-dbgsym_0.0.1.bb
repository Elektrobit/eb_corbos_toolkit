# This was autogenerated! Do not modify
SUMMARY = "debug symbols for elos-plugin-scanner-syslog"
DESCRIPTION = ""
SECTION = "debug"
SOURCE_PACKAGE = "elos"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/e/elos/elos-plugin-scanner-syslog-dbgsym_0.0.1_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "51c014ea9a2d6063785c798990541e1a"
SRC_URI[deb0.sha1sum] = "ddac0013b6ac4ffc38f74b4b33938d9ec1a686c7"
SRC_URI[deb0.sha256sum] = "2bb6f14a05858978d3b776f17108e94f0dbbbf37705a4d153e7fa138520e65e2"

RDEPENDS = " \
    elos-plugin-scanner-syslog \
"

