# This was autogenerated! Do not modify
SUMMARY = "debug symbols for elos-plugin-backend-dlt"
DESCRIPTION = ""
SECTION = "debug"
SOURCE_PACKAGE = "elos"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/e/elos/elos-plugin-backend-dlt-dbgsym_0.0.1_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "84f5b1a5f72acd7b267eb6e47faa5f64"
SRC_URI[deb0.sha1sum] = "8ac1a7f56e4aaf0f1af1a3f4140130872c2ec4e6"
SRC_URI[deb0.sha256sum] = "53c9a583bc5339de2eedc0bef1525a781a898d1113c754d5070361fd279e79fe"

RDEPENDS = " \
    elos-plugin-backend-dlt \
"

