# This was autogenerated! Do not modify
SUMMARY = "debug symbols for elos-plugin-backend-dummy"
DESCRIPTION = ""
SECTION = "debug"
SOURCE_PACKAGE = "elos"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/e/elos/elos-plugin-backend-dummy-dbgsym_0.0.1_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "04bbea3c83f239c142b49f874f0e2091"
SRC_URI[deb0.sha1sum] = "cc1ba993e64d1817921a6a53ffa382fd3a3c02be"
SRC_URI[deb0.sha256sum] = "b312873702129c57c813cd6cf78b9204d2b1301c360afd47390a63c80136a9b7"

RDEPENDS = " \
    elos-plugin-backend-dummy \
"

