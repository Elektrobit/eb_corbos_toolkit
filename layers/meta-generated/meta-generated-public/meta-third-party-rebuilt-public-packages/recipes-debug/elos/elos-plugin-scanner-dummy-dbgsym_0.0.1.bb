# This was autogenerated! Do not modify
SUMMARY = "debug symbols for elos-plugin-scanner-dummy"
DESCRIPTION = ""
SECTION = "debug"
SOURCE_PACKAGE = "elos"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/e/elos/elos-plugin-scanner-dummy-dbgsym_0.0.1_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "d36c2a65b3178b9a66bbad36437e9009"
SRC_URI[deb0.sha1sum] = "316097723b8886d6f064ebc77d1e8b0bac4da222"
SRC_URI[deb0.sha256sum] = "a8032f5e70fe3a548b07fcfd2ee8826fa05c29c82ff88f9c610d3ca8db41b46b"

RDEPENDS = " \
    elos-plugin-scanner-dummy \
"

