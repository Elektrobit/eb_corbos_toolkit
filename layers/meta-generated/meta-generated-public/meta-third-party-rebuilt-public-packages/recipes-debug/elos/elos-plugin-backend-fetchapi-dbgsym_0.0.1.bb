# This was autogenerated! Do not modify
SUMMARY = "debug symbols for elos-plugin-backend-fetchapi"
DESCRIPTION = ""
SECTION = "debug"
SOURCE_PACKAGE = "elos"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/e/elos/elos-plugin-backend-fetchapi-dbgsym_0.0.1_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "34f7fb4851949451ce433f4a77c090d3"
SRC_URI[deb0.sha1sum] = "c8a06806fc981ac8950f6017873b7a5b4a04eb80"
SRC_URI[deb0.sha256sum] = "7dfb0902683172c2892835e6f102e274dab5c15506aabb5fc21a2d9c157b5a43"

RDEPENDS = " \
    elos-plugin-backend-fetchapi \
"

