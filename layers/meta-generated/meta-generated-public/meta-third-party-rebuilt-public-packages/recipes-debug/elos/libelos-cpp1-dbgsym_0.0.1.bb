# This was autogenerated! Do not modify
SUMMARY = "debug symbols for libelos-cpp1"
DESCRIPTION = ""
SECTION = "debug"
SOURCE_PACKAGE = "elos"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/e/elos/libelos-cpp1-dbgsym_0.0.1_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "13d9200fc066a7dd3f6b1c77ba8e5561"
SRC_URI[deb0.sha1sum] = "0afed7e5b7dff9a50f75b6e9ddfe351d56c544ea"
SRC_URI[deb0.sha256sum] = "03b541835a3dd1dd59f599ecf5b50778a2c5b42569c44b24ca42b65899f05df4"

RDEPENDS = " \
    libelos-cpp1 \
"

