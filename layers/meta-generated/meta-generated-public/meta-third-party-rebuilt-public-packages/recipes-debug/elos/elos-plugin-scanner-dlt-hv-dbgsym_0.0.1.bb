# This was autogenerated! Do not modify
SUMMARY = "debug symbols for elos-plugin-scanner-dlt-hv"
DESCRIPTION = ""
SECTION = "debug"
SOURCE_PACKAGE = "elos"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/e/elos/elos-plugin-scanner-dlt-hv-dbgsym_0.0.1_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "b4ce817f18f4d0b007734654dc19e717"
SRC_URI[deb0.sha1sum] = "8607b632815cc7e8d4de9633aac57ae2efc49231"
SRC_URI[deb0.sha256sum] = "98b48c553a84e23a5933532269d57786a8868f9dadcad90ed45f76b8ac35c045"

RDEPENDS = " \
    elos-plugin-scanner-dlt-hv \
"

