# This was autogenerated! Do not modify
SUMMARY = "debug symbols for elos-plugin-scanner-oomkiller"
DESCRIPTION = ""
SECTION = "debug"
SOURCE_PACKAGE = "elos"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/e/elos/elos-plugin-scanner-oomkiller-dbgsym_0.0.1_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "71475400e609e1a1145e99fec27a7539"
SRC_URI[deb0.sha1sum] = "5a92732e173452ca9a916eed40c5b2e12bb39ede"
SRC_URI[deb0.sha256sum] = "fda040f959a8bc2879ce35e7a8e0faf45be0a9beb2d43d7548d7e524b299f5ff"

RDEPENDS = " \
    elos-plugin-scanner-oomkiller \
"

