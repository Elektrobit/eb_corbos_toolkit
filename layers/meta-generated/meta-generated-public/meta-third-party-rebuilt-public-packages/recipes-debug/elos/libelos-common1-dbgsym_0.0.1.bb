# This was autogenerated! Do not modify
SUMMARY = "debug symbols for libelos-common1"
DESCRIPTION = ""
SECTION = "debug"
SOURCE_PACKAGE = "elos"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/e/elos/libelos-common1-dbgsym_0.0.1_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "bacecbfa45df5d497f11fbd461877a39"
SRC_URI[deb0.sha1sum] = "6c398371c74ca2305f7a4a75c48887f0a796f4cf"
SRC_URI[deb0.sha256sum] = "7b4dffd245e892be67886b81feba09447fecd8e8294687fb66e30e7b339c5916"

RDEPENDS = " \
    libelos-common1 \
"

