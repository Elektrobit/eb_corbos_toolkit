# This was autogenerated! Do not modify
SUMMARY = "debug symbols for elos-plugin-client-dummy"
DESCRIPTION = ""
SECTION = "debug"
SOURCE_PACKAGE = "elos"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/e/elos/elos-plugin-client-dummy-dbgsym_0.0.1_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "42ad35f1b462f050cc244cc4eee9a534"
SRC_URI[deb0.sha1sum] = "8c580e453e82a5ceb147cc44ab92fefcffd8a2aa"
SRC_URI[deb0.sha256sum] = "754d65e7154bf43351e6b012ab001c20e5310ffb04db946787f9aced9aa0f09c"

RDEPENDS = " \
    elos-plugin-client-dummy \
"

