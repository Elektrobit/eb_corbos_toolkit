# This was autogenerated! Do not modify
SUMMARY = "debug symbols for libsamconf0"
DESCRIPTION = ""
SECTION = "debug"
SOURCE_PACKAGE = "samconf"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/s/samconf/libsamconf0-dbgsym_0.0.1_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "0235e96bf4dfabf0b083c32be7b530cd"
SRC_URI[deb0.sha1sum] = "8f6a16091f7e693ac99d93d45576adca93b08524"
SRC_URI[deb0.sha256sum] = "487d80e254e1e6bd80ed4ecd2d3cd21c7e80c7632688db8d562d9b413bf17d50"

RDEPENDS = " \
    libsamconf0 \
"

