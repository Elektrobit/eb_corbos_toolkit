# This was autogenerated! Do not modify
SUMMARY = "debug symbols for libsamconf-test-utils0"
DESCRIPTION = ""
SECTION = "debug"
SOURCE_PACKAGE = "samconf"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/s/samconf/libsamconf-test-utils0-dbgsym_0.0.1_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "c878473f569f2898ef08d4a4488e6721"
SRC_URI[deb0.sha1sum] = "89fdbb22ded0cce14655427dcd59b309961c77fc"
SRC_URI[deb0.sha256sum] = "b80181b93beb663410c1fd220e63076aed2c3682b3b10d0b0429f7af77a645ce"

RDEPENDS = " \
    libsamconf-test-utils0 \
"

