# This was autogenerated! Do not modify
SUMMARY = "debug symbols for libsafu0"
DESCRIPTION = ""
SECTION = "debug"
SOURCE_PACKAGE = "safu"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/s/safu/libsafu0-dbgsym_0.0.1_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "6e7396640e2a7133b95980a2754cb155"
SRC_URI[deb0.sha1sum] = "ed72f2ca566048bda04039c7db5dc0e2ae20ac01"
SRC_URI[deb0.sha256sum] = "570d971a748ddb5d183d35534e5709c6787e794c7f700901965fb29882a46b65"

RDEPENDS = " \
    libsafu0 \
"

