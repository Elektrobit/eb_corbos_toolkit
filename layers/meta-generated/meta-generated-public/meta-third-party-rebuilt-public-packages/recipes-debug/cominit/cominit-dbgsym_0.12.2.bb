# This was autogenerated! Do not modify
SUMMARY = "debug symbols for cominit"
DESCRIPTION = ""
SECTION = "debug"
SOURCE_PACKAGE = "cominit"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/c/cominit/cominit-dbgsym_0.12.2_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "c080e2bdde93bb6a5dcdb8121a008a08"
SRC_URI[deb0.sha1sum] = "bd45eb8e50fc3b91a6e1889dbd822da2bbfe2e6a"
SRC_URI[deb0.sha256sum] = "884c8e0d9f5f7ded74f8c85f4db7785e7ae3e97cee73a735c7169967b34e8858"

RDEPENDS = " \
    cominit \
"

