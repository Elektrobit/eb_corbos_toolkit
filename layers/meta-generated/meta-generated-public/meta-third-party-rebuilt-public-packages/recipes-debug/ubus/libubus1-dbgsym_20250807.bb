# This was autogenerated! Do not modify
SUMMARY = "debug symbols for libubus1"
DESCRIPTION = ""
SECTION = "debug"
SOURCE_PACKAGE = "ubus"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/u/ubus/libubus1-dbgsym_20250807_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "b3085e3961c22dd0ca0c2ec2c566ab0b"
SRC_URI[deb0.sha1sum] = "b9780bbe64bbc23df4df3c5507db5fa47eb0d220"
SRC_URI[deb0.sha256sum] = "b796967cc784e0afc0ed20b961502ab6ee256f8525e23bd6a3ccd27e07b604ec"

RDEPENDS = " \
    libubus1 \
"

