# This was autogenerated! Do not modify
SUMMARY = "debug symbols for ubus"
DESCRIPTION = ""
SECTION = "debug"
SOURCE_PACKAGE = "ubus"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/u/ubus/ubus-dbgsym_20250807_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "a9989e7b2cbe64c889da754fd1597b3c"
SRC_URI[deb0.sha1sum] = "0139de520bafbe0093f3402d9779b2125634f02d"
SRC_URI[deb0.sha256sum] = "8262a74e6d507238a5eb017a73f37137bb930c80b8afeb9305c4481902162447"

RDEPENDS = " \
    ubus \
"

