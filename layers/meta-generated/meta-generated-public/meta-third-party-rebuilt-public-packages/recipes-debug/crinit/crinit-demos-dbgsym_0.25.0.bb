# This was autogenerated! Do not modify
SUMMARY = "debug symbols for crinit-demos"
DESCRIPTION = ""
SECTION = "debug"
SOURCE_PACKAGE = "crinit"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/c/crinit/crinit-demos-dbgsym_0.25.0_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "a19ecaf7c9b2c93a426d725cc5b8a92a"
SRC_URI[deb0.sha1sum] = "bdac8c9b64ad5a904eceef24355ecfc8bcd625eb"
SRC_URI[deb0.sha256sum] = "b877bb7e959f4f870dbc951d1a1473fbb18dc82a57230fb85109e6aebadb3bed"

RDEPENDS = " \
    crinit-demos \
"

