# This was autogenerated! Do not modify
SUMMARY = "debug symbols for crinit-ctl"
DESCRIPTION = ""
SECTION = "debug"
SOURCE_PACKAGE = "crinit"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/c/crinit/crinit-ctl-dbgsym_0.25.3_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "cf5db396c70bd6dac6f789cf42269083"
SRC_URI[deb0.sha1sum] = "6f3f9a29bdc49cd8c9924fb4c66688b14f46c92f"
SRC_URI[deb0.sha256sum] = "cae8e3fe8df99c0336082e576c3b5a954c32fc093a89cec69941583236fea887"

RDEPENDS = " \
    crinit-ctl \
"

