# This was autogenerated! Do not modify
SUMMARY = "debug symbols for crinit-ctl"
DESCRIPTION = ""
SECTION = "debug"
SOURCE_PACKAGE = "crinit"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/c/crinit/crinit-ctl-dbgsym_0.25.0_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "8b9732e3e8fa2348ed98ecefb9b72635"
SRC_URI[deb0.sha1sum] = "9609bc4ed5efe1d2768c5fecccba13ddbcccbf0f"
SRC_URI[deb0.sha256sum] = "b6890efd29944a529871a1b9b771422b0ff8c2de6200a3307487bf159261d23e"

RDEPENDS = " \
    crinit-ctl \
"

