# This was autogenerated! Do not modify
SUMMARY = "debug symbols for libcrinit-client0"
DESCRIPTION = ""
SECTION = "debug"
SOURCE_PACKAGE = "crinit"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/c/crinit/libcrinit-client0-dbgsym_0.25.0_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "c121af6532f1188946d776d4ebe98fb3"
SRC_URI[deb0.sha1sum] = "38b78eb745948636e0827798119a6c5fcb950dcd"
SRC_URI[deb0.sha256sum] = "21959006e8c8ecb6ca5aa5c8ff7797f2a2393dfadd702e15719b230fc0de6571"

RDEPENDS = " \
    libcrinit-client0 \
"

