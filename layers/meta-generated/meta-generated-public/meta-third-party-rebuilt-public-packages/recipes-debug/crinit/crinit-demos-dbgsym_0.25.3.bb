# This was autogenerated! Do not modify
SUMMARY = "debug symbols for crinit-demos"
DESCRIPTION = ""
SECTION = "debug"
SOURCE_PACKAGE = "crinit"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/c/crinit/crinit-demos-dbgsym_0.25.3_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "d5f464aac2385e60252fa9b6fb010c76"
SRC_URI[deb0.sha1sum] = "0df50ed1061edaf864f28bd6abd75f5efd90e6d7"
SRC_URI[deb0.sha256sum] = "13e406d9b6a23ccf19fccdf00aaf432c4add576816ab82ff93d7f1327ba8ca70"

RDEPENDS = " \
    crinit-demos \
"

