# This was autogenerated! Do not modify
SUMMARY = "debug symbols for crinit"
DESCRIPTION = ""
SECTION = "debug"
SOURCE_PACKAGE = "crinit"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/c/crinit/crinit-dbgsym_0.25.0_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "41f23f1c9080b278ee7d84544864eec2"
SRC_URI[deb0.sha1sum] = "87f6ebff250524d5868f1847a164072927cf30e1"
SRC_URI[deb0.sha256sum] = "55513cb58b1c761d3dd6d14dc53fbd078922bbfe4113ed6a54dc9bd2dee2ccaa"

RDEPENDS = " \
    crinit \
"

