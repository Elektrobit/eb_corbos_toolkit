# This was autogenerated! Do not modify
SUMMARY = "debug symbols for libcrinit-client0"
DESCRIPTION = ""
SECTION = "debug"
SOURCE_PACKAGE = "crinit"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/c/crinit/libcrinit-client0-dbgsym_0.25.3_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "967456d88692813573180e67e0eebb7f"
SRC_URI[deb0.sha1sum] = "58662921d9b848dc11a862d27600714e6fc3b09e"
SRC_URI[deb0.sha256sum] = "b7a506f451f0c212b8b6533a50a6d382fab2066966d9f6bd315ebca5405edbb1"

RDEPENDS = " \
    libcrinit-client0 \
"

