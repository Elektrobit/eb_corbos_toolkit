# This was autogenerated! Do not modify
SUMMARY = "debug symbols for libmock-jsonc0"
DESCRIPTION = ""
SECTION = "debug"
SOURCE_PACKAGE = "cmocka-mocks"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/c/cmocka-mocks/libmock-jsonc0-dbgsym_0.0.1_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "e8a51f61db8e32e0bbc30eacb164dba3"
SRC_URI[deb0.sha1sum] = "ccda9d33e4046d6b14c8c948f9da2d66e323724a"
SRC_URI[deb0.sha256sum] = "0fafa9b5e5ec1c5c10998214cb829561d72250d906eca9eb5c51363624e9ece1"

RDEPENDS = " \
    libmock-jsonc0 \
"

