# This was autogenerated! Do not modify
SUMMARY = "debug symbols for libmock-openssl0"
DESCRIPTION = ""
SECTION = "debug"
SOURCE_PACKAGE = "cmocka-mocks"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/c/cmocka-mocks/libmock-openssl0-dbgsym_0.0.1_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "17a4a3261262f6fb495b571565837cfd"
SRC_URI[deb0.sha1sum] = "e7b93d06edc15d6a888d396201b68956fdb5b66b"
SRC_URI[deb0.sha256sum] = "401dac8ec43c6270fcb0459680381e42cef72b48670ba14f4be2e9d822a34901"

RDEPENDS = " \
    libmock-openssl0 \
"

