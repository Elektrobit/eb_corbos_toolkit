# This was autogenerated! Do not modify
SUMMARY = "debug symbols for libmock-libc0"
DESCRIPTION = ""
SECTION = "debug"
SOURCE_PACKAGE = "cmocka-mocks"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/c/cmocka-mocks/libmock-libc0-dbgsym_0.0.1_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "12dd8f9987c84e845c222a3be9c2ca75"
SRC_URI[deb0.sha1sum] = "6d2fbaefb2d2f523bf93c7a7e6b72beab394c8ab"
SRC_URI[deb0.sha256sum] = "e8cc1b20d5e03a72c34817ddf461a28f3baed5f08925089549caf5f417f64c6a"

RDEPENDS = " \
    libmock-libc0 \
"

