# This was autogenerated! Do not modify
SUMMARY = "debug symbols for libmock-libmnl0"
DESCRIPTION = ""
SECTION = "debug"
SOURCE_PACKAGE = "cmocka-mocks"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/c/cmocka-mocks/libmock-libmnl0-dbgsym_0.0.1_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "a8bb287ebb382680988a8c4d28f45a7f"
SRC_URI[deb0.sha1sum] = "4823e01c8b1ea42b52bc5a636cedc6ef25ea8f3c"
SRC_URI[deb0.sha256sum] = "6cd5e38a9e12b6c6edb9e3a98a903938b5b9eaf1ca199e928a7259dff98e386c"

RDEPENDS = " \
    libmock-libmnl0 \
"

