# This was autogenerated! Do not modify
SUMMARY = "Documentation for cmocka-mocks"
DESCRIPTION = "Library to mock common C functions, like libc and jsonc, for testing purposes. \
This collection of ready to use mocks is based on cmocka_extensions. \
 \
Documentation package."
SECTION = "doc"
SOURCE_PACKAGE = "cmocka-mocks"
HOMEPAGE = "https://github.com/Elektrobit/cmocka_mocks"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/c/cmocka-mocks/cmocka-mocks-doc_0.0.1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "fb8fa80bd648d2677b25b218932a809e"
SRC_URI[deb0.sha1sum] = "ddc8adf34ffc2746ebfdccd071c5cd798520a1fe"
SRC_URI[deb0.sha256sum] = "e97db15b62c0ce4e834af4c020fd13fe3d2745bdf161676f6939692ee7ef8963"


