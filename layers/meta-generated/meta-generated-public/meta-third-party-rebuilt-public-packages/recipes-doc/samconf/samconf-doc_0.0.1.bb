# This was autogenerated! Do not modify
SUMMARY = "Documentation package for signed and mergable configuration"
DESCRIPTION = "It stands for signed and mergable configuration. It is used by elos. The \
goal of the library is to manage program configuration options from various \
sources including support for verification of the configuration sources. \
 \
Documentation package."
SECTION = "doc"
SOURCE_PACKAGE = "samconf"
HOMEPAGE = "https://github.com/Elektrobit/samconf"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/s/samconf/samconf-doc_0.0.1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "333d5ede3390b6b76a4deabafdc39a8d"
SRC_URI[deb0.sha1sum] = "753a67d6ceb6dc86f49eaff50a6ef37eca87ea96"
SRC_URI[deb0.sha256sum] = "8681b0f6eaeb1af2fadf282e027d25515e0ffbb3e23a0bb4b2ae315299f27fbe"


