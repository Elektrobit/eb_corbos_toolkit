# This was autogenerated! Do not modify
SUMMARY = "Document package for elos"
DESCRIPTION = "elos is a tool to collect, store and publish various system events (i.e. \
syslogs, core dumps, measurements obtained from proc- and sys-fs, ...) \
while providing easy access to the collected data. \
 \
Documentation package."
SECTION = "doc"
SOURCE_PACKAGE = "elos"
HOMEPAGE = "https://github.com/Elektrobit/elos"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/e/elos/elos-doc_0.0.1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "b80303dd8f3d8df24aff3e7b6ec218ee"
SRC_URI[deb0.sha1sum] = "efc28a9ca9fcf7163e5adb6208f3b612d555015d"
SRC_URI[deb0.sha256sum] = "b7253047c7dc282f6e8c33ddafa32a4200f5e38426537ac51145d3fdf786d8c1"


