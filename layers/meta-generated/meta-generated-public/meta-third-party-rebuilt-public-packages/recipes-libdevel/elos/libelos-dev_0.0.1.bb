# This was autogenerated! Do not modify
SUMMARY = "Development package for libelos"
DESCRIPTION = "elos is a tool to collect, store and publish various system events (i.e. \
syslogs, core dumps, measurements obtained from proc- and sys-fs, ...) \
while providing easy access to the collected data. \
 \
Development package."
SECTION = "libdevel"
SOURCE_PACKAGE = "elos"
HOMEPAGE = "https://github.com/Elektrobit/elos"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/e/elos/libelos-dev_0.0.1_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "75e580dd3f8b55be7eb92e015619baab"
SRC_URI[deb0.sha1sum] = "7e81d9f99aa3a6a6f6d7aa2ca10ac6c9284fc951"
SRC_URI[deb0.sha256sum] = "b0ef91107548403007ebbd0e6bcb93c4ed28865b5bef0abc7510ba462a5cb6f7"

RDEPENDS = " \
    libelos-common-dev \
    libelos1 \
    libelosdlt-dev \
    libelosplugin-dev \
    libsamconf-dev \
"

