# This was autogenerated! Do not modify
SUMMARY = "Development package for libelosdlt"
DESCRIPTION = "elos is a tool to collect, store and publish various system events (i.e. \
syslogs, core dumps, measurements obtained from proc- and sys-fs, ...) \
while providing easy access to the collected data. \
 \
Development package for libelosdlt."
SECTION = "libdevel"
SOURCE_PACKAGE = "elos"
HOMEPAGE = "https://github.com/Elektrobit/elos"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/e/elos/libelosdlt-dev_0.0.1_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "a99b5207be1f4a4ede3bdc0a3e193196"
SRC_URI[deb0.sha1sum] = "ccb90dd344452d13218f4af814206b7942917d9b"
SRC_URI[deb0.sha256sum] = "5b9b86303a15c1eabf734b7f3897ea6a407be4364d13737853c42b539df354ac"

RDEPENDS = " \
    libelos-common-dev \
    libelosdlt1 \
"

