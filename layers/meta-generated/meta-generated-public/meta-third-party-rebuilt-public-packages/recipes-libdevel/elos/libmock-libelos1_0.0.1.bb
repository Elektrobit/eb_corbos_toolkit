# This was autogenerated! Do not modify
SUMMARY = "Event logging and management with normalized output-format library (mocks)"
DESCRIPTION = "elos is a tool to collect, store and publish various system events (i.e. \
syslogs, core dumps, measurements obtained from proc- and sys-fs, ...) \
while providing easy access to the collected data. \
 \
Mock library package."
SECTION = "libdevel"
SOURCE_PACKAGE = "elos"
HOMEPAGE = "https://github.com/Elektrobit/elos"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/e/elos/libmock-libelos1_0.0.1_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "cd4fc33414b71965183504e2b5615870"
SRC_URI[deb0.sha1sum] = "859e43fffade2158bd669e12015625be9149b602"
SRC_URI[deb0.sha256sum] = "55dfde5abbfc1297a42199ac242d249dfa74666add7d2240844bb170c3761ee1"

RDEPENDS = " \
    libc6 \
    libcmocka0 \
    libelos-common1 \
    libjson-c5 \
    libsafu0 \
"

