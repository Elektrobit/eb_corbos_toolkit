# This was autogenerated! Do not modify
SUMMARY = "Mock library for libjsonc"
DESCRIPTION = "Mock library for libjsonc generated by cmocka-cmocks."
SECTION = "libdevel"
SOURCE_PACKAGE = "cmocka-mocks"
HOMEPAGE = "https://github.com/Elektrobit/cmocka_mocks"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/c/cmocka-mocks/libmock-jsonc0_0.0.1_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "f706475031c5efaecc49e123e98b199e"
SRC_URI[deb0.sha1sum] = "835d50b2c85277a97ddcc0cace7fb6411f44c43e"
SRC_URI[deb0.sha256sum] = "61587e0ce4bf4096e538a50d01d500d71972e614dd09358fe58f0ae2a2ec635f"

RDEPENDS = " \
    libc6 \
    libcmocka0 \
    libjson-c-dev \
    libjson-c5 \
"

