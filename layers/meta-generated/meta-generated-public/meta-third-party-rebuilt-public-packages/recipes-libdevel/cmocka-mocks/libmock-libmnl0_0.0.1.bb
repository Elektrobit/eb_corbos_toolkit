# This was autogenerated! Do not modify
SUMMARY = "Mock library for libmnl"
DESCRIPTION = "Mock library for libmnl generated by cmocka-cmocks."
SECTION = "libdevel"
SOURCE_PACKAGE = "cmocka-mocks"
HOMEPAGE = "https://github.com/Elektrobit/cmocka_mocks"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/c/cmocka-mocks/libmock-libmnl0_0.0.1_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "e4cfdf1de043f42429b04be8e0cb677f"
SRC_URI[deb0.sha1sum] = "04fb3a65b195fa94c1ae8af0fe5ba0d04779ab0d"
SRC_URI[deb0.sha256sum] = "580c2adf0bb50082a589e9b4ac31f5f0e9162bcb19793ab2c2004e81a8642362"

RDEPENDS = " \
    libcmocka0 \
    libmnl-dev \
    libmnl0 \
"

