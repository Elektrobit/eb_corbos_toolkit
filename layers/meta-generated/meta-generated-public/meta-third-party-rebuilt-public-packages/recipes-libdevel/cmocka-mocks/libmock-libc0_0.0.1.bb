# This was autogenerated! Do not modify
SUMMARY = "Mock library for libc"
DESCRIPTION = "Mock library for libc generated by cmocka-cmocks."
SECTION = "libdevel"
SOURCE_PACKAGE = "cmocka-mocks"
HOMEPAGE = "https://github.com/Elektrobit/cmocka_mocks"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/c/cmocka-mocks/libmock-libc0_0.0.1_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "e74cd5544694413c0cb130d83f0c156a"
SRC_URI[deb0.sha1sum] = "184d4eab9d097717bd53141b1a5660d2d979c106"
SRC_URI[deb0.sha256sum] = "0762c719d3b440021451cd4715b2c29f54bf9f17145e0b8abd1acae1ac3a5cdc"

RDEPENDS = " \
    libc6 \
    libcmocka0 \
"

