# This was autogenerated! Do not modify
SUMMARY = "Mock library for openssl"
DESCRIPTION = "Mock library for openssl generated by cmocka-cmocks."
SECTION = "libdevel"
SOURCE_PACKAGE = "cmocka-mocks"
HOMEPAGE = "https://github.com/Elektrobit/cmocka_mocks"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/c/cmocka-mocks/libmock-openssl0_0.0.1_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "ea25e1e87173f0eee5077450d451af2b"
SRC_URI[deb0.sha1sum] = "2f4a9550524c6293b3c98c261910e2293970df31"
SRC_URI[deb0.sha256sum] = "b896adb58b5662b2e0bdc556581078576e5f72bc7b9d0daf05b81b733cd3b67a"

RDEPENDS = " \
    libcmocka0 \
    libssl-dev \
    libssl3t64 \
"

