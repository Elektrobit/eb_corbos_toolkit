# This was autogenerated! Do not modify
SUMMARY = "A library used by many OpenWrt projects"
DESCRIPTION = ""
SECTION = "libdevel"
SOURCE_PACKAGE = "libubox"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/libu/libubox/libubox-dev_20250807_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "875681f61bbbf59f347b394b012529c4"
SRC_URI[deb0.sha1sum] = "bb1a0fc353c43f7111bc80f2fe318cd7374cd3f7"
SRC_URI[deb0.sha256sum] = "7004c6f4494a667ab87a30aeb9efef7e48ecc111021ae421218b2009df25123b"

RDEPENDS = " \
    libblobmsg-json1 \
    libjson-script1 \
    libubox1 \
"

