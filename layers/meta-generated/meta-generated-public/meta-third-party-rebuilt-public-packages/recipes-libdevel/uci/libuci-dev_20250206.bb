# This was autogenerated! Do not modify
SUMMARY = "Unified Configuration Interface"
DESCRIPTION = ""
SECTION = "libdevel"
SOURCE_PACKAGE = "uci"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/u/uci/libuci-dev_20250206_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "8e83778038314145339b9a414197feb9"
SRC_URI[deb0.sha1sum] = "58dd124631773420c297dce8f350355b74331b44"
SRC_URI[deb0.sha256sum] = "81d80f12faf4f635e99299e1cc5373f38acf40e41bf3fb11a88f3080ae1bbdbf"

RDEPENDS = " \
    libuci1 \
"

