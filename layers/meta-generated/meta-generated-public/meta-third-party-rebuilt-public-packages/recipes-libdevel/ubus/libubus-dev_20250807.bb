# This was autogenerated! Do not modify
SUMMARY = "OpenWrt micro bus architecture"
DESCRIPTION = ""
SECTION = "libdevel"
SOURCE_PACKAGE = "ubus"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/u/ubus/libubus-dev_20250807_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "592456d83fff07b635d14944adebdcdd"
SRC_URI[deb0.sha1sum] = "29d0eb50014a85677d46e350823859d042825150"
SRC_URI[deb0.sha256sum] = "9fb12505c5bda25ed92a8eac1da889e4761b19af5f5d85c80a86d777525a5fa7"

RDEPENDS = " \
    libubus1 \
"

