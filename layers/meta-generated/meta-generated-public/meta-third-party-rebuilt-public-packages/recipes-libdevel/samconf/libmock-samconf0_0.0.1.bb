# This was autogenerated! Do not modify
SUMMARY = "Signed and mergable configuration (mock libraries)"
DESCRIPTION = "It stands for signed and mergable configuration. It is used by elos. The \
goal of the library is to manage program configuration options from various \
sources including support for verification of the configuration sources. \
 \
Mock libraries."
SECTION = "libdevel"
SOURCE_PACKAGE = "samconf"
HOMEPAGE = "https://github.com/Elektrobit/samconf"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/s/samconf/libmock-samconf0_0.0.1_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "cbde1f9a7f58ad1654e37d49e5b5d531"
SRC_URI[deb0.sha1sum] = "83014c6824a60f5f6d102273ad2a75528a7b5c0d"
SRC_URI[deb0.sha256sum] = "1236d0c6c6a5ecc5ff607b9de5afe8a74c72936872901b5f3605f31b0790a681"

RDEPENDS = " \
    libsamconf0 \
"

