# This was autogenerated! Do not modify
SUMMARY = "Development package for signed and mergable configuration"
DESCRIPTION = "It stands for signed and mergable configuration. It is used by elos. The \
goal of the library is to manage program configuration options from various \
sources including support for verification of the configuration sources. \
 \
Development package."
SECTION = "libdevel"
SOURCE_PACKAGE = "samconf"
HOMEPAGE = "https://github.com/Elektrobit/samconf"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/s/samconf/libsamconf-dev_0.0.1_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "7ce149a89a9d3ccf4aee6bed18ee25d2"
SRC_URI[deb0.sha1sum] = "278591a4813a3eb393f257922f34369aef7d3eff"
SRC_URI[deb0.sha256sum] = "ba0de9a85c4906c5a96baa5a42e02300851c489ee9e8192bb03c4a9214cc8a74"

RDEPENDS = " \
    libmock-samconf0 \
    libsafu-dev \
    libsamconf-test-utils0 \
    libsamconf0 \
"

