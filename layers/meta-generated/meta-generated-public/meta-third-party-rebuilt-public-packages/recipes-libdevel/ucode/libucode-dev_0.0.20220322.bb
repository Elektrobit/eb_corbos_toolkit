# This was autogenerated! Do not modify
SUMMARY = "Development files for the ucode VM library"
DESCRIPTION = "Ucode is a tiny script language featuring ECMA script syntax, builtin JSON \
support and templating using Jinja inspired markup. The ucode VM is provided \
as shared library with a C API allowing embedding into host applications and \
interchanging data between ucode and C programs. The ucode VM can also be \
used as stand-alone multi purpose scripting language through the provided \
ucode cli interpreter. \
 \
This package contains the development header to interface with the libucode \
VM runtime, which is required when developing programs or extensions using \
the ucode C API."
SECTION = "libdevel"
SOURCE_PACKAGE = "ucode"
HOMEPAGE = "https://github.com/jow-/ucode"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/u/ucode/libucode-dev_0.0.20220322_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "949d8578e4019e27281eb1fd6b286178"
SRC_URI[deb0.sha1sum] = "451bef5362da7f17e090a74d5608113aa34c1ffe"
SRC_URI[deb0.sha256sum] = "be6aa8baeffec7042f5010d04993e1c6a92fa68484ab0bb32fc1a54249c436ae"

RDEPENDS = " \
    libc6-dev \
    libucode \
"

