# This was autogenerated! Do not modify
SUMMARY = "Advanced oelint"
DESCRIPTION = ""
SECTION = "misc"
SOURCE_PACKAGE = "oelint-adv"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/o/oelint-adv/oelint-adv_8.2.1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "a1e246f6c44e8863820c0388d4fed85c"
SRC_URI[deb0.sha1sum] = "cfcf8d84fac4ac70836ff69a1a61c120de110bf5"
SRC_URI[deb0.sha256sum] = "8188e39ace9fc498cf5c3b124e4fa596824028415c5482ae21cfba008cce9425"

RDEPENDS = " \
    python3 \
    python3-anytree \
    python3-argcomplete \
    python3-colorama \
    python3-oelint-data \
    python3-oelint-parser \
    python3-urllib3 \
"

