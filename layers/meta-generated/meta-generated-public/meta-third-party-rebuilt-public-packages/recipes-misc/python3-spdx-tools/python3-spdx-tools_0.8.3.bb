# This was autogenerated! Do not modify
SUMMARY = "SPDX parser and tools."
DESCRIPTION = ""
SECTION = "misc"
SOURCE_PACKAGE = "python3-spdx-tools"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/p/python3-spdx-tools/python3-spdx-tools_0.8.3_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "6663e379daad8dde433d66de8f56626a"
SRC_URI[deb0.sha1sum] = "bba21b20de26a79dd5bd0fc2d2cc86334bed316f"
SRC_URI[deb0.sha256sum] = "9970364e119ff803e70eeac2270cebd371b7a0216a3a3becc7392becfdcfd914"

RDEPENDS = " \
    python3 \
    python3-beartype \
    python3-click \
    python3-license-expression \
    python3-ply \
    python3-rdflib \
    python3-semantic-version \
    python3-uritools \
    python3-xmltodict \
    python3-yaml \
"

