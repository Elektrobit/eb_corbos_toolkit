# This was autogenerated! Do not modify
SUMMARY = "debsbom generates SBOMs for Debian based distributions."
DESCRIPTION = ""
SECTION = "misc"
SOURCE_PACKAGE = "python3-debsbom"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/p/python3-debsbom/python3-debsbom_0.6.1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "4974edf2adde49015df6b1d81ab40bf3"
SRC_URI[deb0.sha1sum] = "5ebe14d213cf85ba4cc6dd2ec8dba7fac5dc81cb"
SRC_URI[deb0.sha256sum] = "cc1847a33ee5594e690b661c9bc5f0edb212d6d08fd36ae5f7cda74c1540d687"

RDEPENDS = " \
    python3 \
    python3-apt \
    python3-debian \
    python3-packageurl \
"

