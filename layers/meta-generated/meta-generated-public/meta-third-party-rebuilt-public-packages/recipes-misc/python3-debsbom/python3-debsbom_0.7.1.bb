# This was autogenerated! Do not modify
SUMMARY = "debsbom generates SBOMs for Debian based distributions."
DESCRIPTION = ""
SECTION = "misc"
SOURCE_PACKAGE = "python3-debsbom"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/p/python3-debsbom/python3-debsbom_0.7.1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "ce1be3ef50950843868c816e1988a1b9"
SRC_URI[deb0.sha1sum] = "b389812986749141508f5821fc79824fc2f9f05a"
SRC_URI[deb0.sha256sum] = "6021aa270524f839169f35e27824f37b56515274aac46b64cdd618eccd57586d"

RDEPENDS = " \
    python3 \
    python3-apt \
    python3-debian \
    python3-license-expression \
    python3-packageurl \
"

