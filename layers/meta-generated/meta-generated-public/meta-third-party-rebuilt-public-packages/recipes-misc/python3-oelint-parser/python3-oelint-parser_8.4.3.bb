# This was autogenerated! Do not modify
SUMMARY = "Alternative parser for bitbake recipes"
DESCRIPTION = ""
SECTION = "misc"
SOURCE_PACKAGE = "python3-oelint-parser"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/p/python3-oelint-parser/python3-oelint-parser_8.4.3_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "a5dce1b835247e217cc0a6a543b2f457"
SRC_URI[deb0.sha1sum] = "cd1b86b7c29a380cf40762d9c8448dab63e23ea6"
SRC_URI[deb0.sha256sum] = "ef03ee549686f3fc8762b3ba18f08eb45e02a63d3d13e8da53f4a0a8048d50a5"

RDEPENDS = " \
    python3 \
    python3-deprecated \
    python3-regex \
"

