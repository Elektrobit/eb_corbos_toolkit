# This was autogenerated! Do not modify
SUMMARY = "kas and kas-container"
DESCRIPTION = ""
SECTION = "misc"
SOURCE_PACKAGE = "kas"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/k/kas/kas_4.8.1_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "836d2c27c856bac09b7f79356a0251f3"
SRC_URI[deb0.sha1sum] = "949598c6367b7b84897501a7a4e758578878cf99"
SRC_URI[deb0.sha256sum] = "c4ce1c9de346e3ce6f94935aeed7db3f9932360f007f4c7b9301d4c62855cd78"

RDEPENDS = " \
    python3 \
    python3-distro \
    python3-git \
    python3-jsonschema \
    python3-yaml \
"

