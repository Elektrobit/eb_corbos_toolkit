# This was autogenerated! Do not modify
SUMMARY = "Python tree data library"
DESCRIPTION = ""
SECTION = "misc"
SOURCE_PACKAGE = "python3-anytree"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/p/python3-anytree/python3-anytree_2.13.0_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "749139d4223b6382c6d6766150c5eb75"
SRC_URI[deb0.sha1sum] = "20f6e203d80ac00180f3bffea4e40d374d67e889"
SRC_URI[deb0.sha256sum] = "b15337b00ac89acd1a68fc8020b4b573232b7e0632239f56b5e2c4195d813d32"

RDEPENDS = " \
    python3 \
"

