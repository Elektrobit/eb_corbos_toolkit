# This was autogenerated! Do not modify
SUMMARY = "Firmware for the Raspberry Pi 4B platform"
DESCRIPTION = ""
SECTION = "misc"
SOURCE_PACKAGE = "firmware-rpi"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/f/firmware-rpi/firmware-rpi_1.20260408_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "f20048997d2678a7dd4c05830f515ce5"
SRC_URI[deb0.sha1sum] = "ea6677b3af0828692ae71b06abd33c5601a40167"
SRC_URI[deb0.sha256sum] = "eedf3e423cfc1ad30cb74c9aaa2c90bbc74e8f470a8c226f5fb125752f1e2449"


