# This was autogenerated! Do not modify
SUMMARY = "Library for serializing and deserializing Python Objects to and from JSON and XML."
DESCRIPTION = ""
SECTION = "misc"
SOURCE_PACKAGE = "python3-py-serializable"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/p/python3-py-serializable/python3-py-serializable_2.0.0_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "ad2b2b2c22582b48df0337b4889fdcc7"
SRC_URI[deb0.sha1sum] = "7102b44eafe63fdfe1ffa23377a9faa0aa2ac836"
SRC_URI[deb0.sha256sum] = "bd673adda2f4647c68268c062fac041110540cccdf90270d89bc582b3a2f484f"

RDEPENDS = " \
    python3 \
    python3-defusedxml \
"

