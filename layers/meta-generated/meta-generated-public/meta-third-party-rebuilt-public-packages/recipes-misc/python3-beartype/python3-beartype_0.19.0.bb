# This was autogenerated! Do not modify
SUMMARY = "Unbearably fast near-real-time hybrid runtime-static type-checking in pure Python."
DESCRIPTION = ""
SECTION = "misc"
SOURCE_PACKAGE = "python3-beartype"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/p/python3-beartype/python3-beartype_0.19.0_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "bd6b4acacd325779185a10e1a5d7868b"
SRC_URI[deb0.sha1sum] = "c238633de76ebfa734b7bbe32db409c11ea909ed"
SRC_URI[deb0.sha256sum] = "2ed601c3c4c7de6629d0d563b41f9bc37f841f0e1cf97140f0cee3be72c4cbf5"

RDEPENDS = " \
    python3 \
"

