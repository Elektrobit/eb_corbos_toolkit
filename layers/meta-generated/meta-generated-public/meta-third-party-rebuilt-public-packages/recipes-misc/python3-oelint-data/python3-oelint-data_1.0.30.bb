# This was autogenerated! Do not modify
SUMMARY = "Data for oelint-adv"
DESCRIPTION = ""
SECTION = "misc"
SOURCE_PACKAGE = "python3-oelint-data"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/p/python3-oelint-data/python3-oelint-data_1.0.30_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "63614e4bd220834eb7da53d47d53e774"
SRC_URI[deb0.sha1sum] = "b040aacae6cb3aaadf8e682e9f4db6b6086683e8"
SRC_URI[deb0.sha256sum] = "318b81a3759812b3b2e810a9195c4524ef0e4fce89938f3a3781ee179a3bf5b6"

RDEPENDS = " \
    python3 \
    python3-oelint-parser \
"

