# This was autogenerated! Do not modify
SUMMARY = "Tools for signed and mergable configuration"
DESCRIPTION = "It stands for signed and mergable configuration. It is used by elos. The \
goal of the library is to manage program configuration options from various \
sources including support for verification of the configuration sources. \
 \
Package containing tools."
SECTION = "utils"
SOURCE_PACKAGE = "samconf"
HOMEPAGE = "https://github.com/Elektrobit/samconf"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/s/samconf/samconf-tools_0.0.1_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "0c7ff9c06687bdb2ce75fa30309635ad"
SRC_URI[deb0.sha1sum] = "f6dd3fd6ec57dd2e0b5ae228b2777369f3a9726c"
SRC_URI[deb0.sha256sum] = "372612ad88993bc40da2bf7c920b3bb851840681c3da3772a05b03483522fa6f"

RDEPENDS = " \
    libc6 \
    libjson-c5 \
    libsafu0 \
    libsamconf0 \
"

