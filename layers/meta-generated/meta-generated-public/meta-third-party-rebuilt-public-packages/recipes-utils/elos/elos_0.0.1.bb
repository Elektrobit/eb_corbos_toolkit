# This was autogenerated! Do not modify
SUMMARY = "Event logging and management with normalized output-format metapackage"
DESCRIPTION = "elos is a tool to collect, store and publish various system events (i.e. \
syslogs, core dumps, measurements obtained from proc- and sys-fs, ...) \
while providing easy access to the collected data."
SECTION = "utils"
SOURCE_PACKAGE = "elos"
HOMEPAGE = "https://github.com/Elektrobit/elos"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/e/elos/elos_0.0.1_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "ace165d5cc349fb252dead60cd9a2769"
SRC_URI[deb0.sha1sum] = "501c3b45f4e1d540fc5f0c8a8765e90eb7401790"
SRC_URI[deb0.sha256sum] = "5e3ac14b5903ea57e3d37f1ba31c9a0f2b0269746e8fd500ddc5d4da8b89e5b2"

RDEPENDS = " \
    elosc \
    elosd \
"

