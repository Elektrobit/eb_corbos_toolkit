# This was autogenerated! Do not modify
SUMMARY = "Event logging and management with normalized output-format daemon"
DESCRIPTION = "elos is a tool to collect, store and publish various system events (i.e. \
syslogs, core dumps, measurements obtained from proc- and sys-fs, ...) \
while providing easy access to the collected data. \
 \
Daemon package."
SECTION = "utils"
SOURCE_PACKAGE = "elos"
HOMEPAGE = "https://github.com/Elektrobit/elos"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/e/elos/elosd_0.0.1_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "5050c73d8b0600d32fff146924ce3ef6"
SRC_URI[deb0.sha1sum] = "3eafe870322a80db755950a27150b97513abfbb0"
SRC_URI[deb0.sha256sum] = "ce7f57ddb48b375f9e6131944f25060eeef8825bd89cd6f047d2b265a9733808"

RDEPENDS = " \
    libc6 \
    libelos-common1 \
    libsafu0 \
    libsamconf0 \
"

