# This was autogenerated! Do not modify
SUMMARY = "Event logging and management with normalized output-format systemd service"
DESCRIPTION = "elos is a tool to collect, store and publish various system events (i.e. \
syslogs, core dumps, measurements obtained from proc- and sys-fs, ...) \
while providing easy access to the collected data. \
 \
Systemd package."
SECTION = "utils"
SOURCE_PACKAGE = "elos"
HOMEPAGE = "https://github.com/Elektrobit/elos"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/e/elos/elosd-systemd_0.0.1_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "e6fa96a1f3a4f4c83cfc1e496a3eaa98"
SRC_URI[deb0.sha1sum] = "94a2d5f1b2a25e45e5187a64cb7bb643fdfed137"
SRC_URI[deb0.sha256sum] = "76c03133e32bb52c270930658c0fabc53040bbec13dfee24b226f54f6ad79c13"

RDEPENDS = " \
    elosd \
"

