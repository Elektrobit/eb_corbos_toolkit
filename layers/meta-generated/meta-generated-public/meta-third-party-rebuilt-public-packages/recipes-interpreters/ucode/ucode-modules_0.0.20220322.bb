# This was autogenerated! Do not modify
SUMMARY = "Extension modules for the ucode language"
DESCRIPTION = "Ucode is a tiny script language featuring ECMA script syntax, builtin JSON \
support and templating using Jinja inspired markup. The ucode VM is provided \
as shared library with a C API allowing embedding into host applications and \
interchanging data between ucode and C programs. The ucode VM can also be \
used as stand-alone multi purpose scripting language through the provided \
ucode cli interpreter. \
 \
This package contains various native ucode extensions which provide further \
functionality such as filesystem access, math functions etc."
SECTION = "interpreters"
SOURCE_PACKAGE = "ucode"
HOMEPAGE = "https://github.com/jow-/ucode"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/u/ucode/ucode-modules_0.0.20220322_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "9086d735ee0ab29ccae3903366cc9e55"
SRC_URI[deb0.sha1sum] = "62659d7384cde5cbdb681ab12d59a52c977714a8"
SRC_URI[deb0.sha256sum] = "494a75ae4fead1098aa0a365c1eef1c862df3f7ff99f34a7249899342ba39536"

RDEPENDS = " \
    libc6 \
    libucode \
"

