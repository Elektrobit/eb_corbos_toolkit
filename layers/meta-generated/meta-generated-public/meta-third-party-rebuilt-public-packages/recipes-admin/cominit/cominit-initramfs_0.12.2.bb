# This was autogenerated! Do not modify
SUMMARY = "Initramfs-tools integration for cominit"
DESCRIPTION = "The resulting binary (cominit) expects to be run as the system init process \
out of an initramfs. Its purpose is to mount the rootfs partition, switch the \
root and start the rootfs init. The rootfs filesystem may be read-only or \
read-write using any filesystem supported by the Kernel in use. Continuous \
integrity checking is supported through dm-verity for read-only and \
dm-integrity for writable variants. \
 \
If successful, cominit will clean up after itself and exec into the rootfs \
init ([rootfs]/sbin/init). On any fatal error, cominit will try to exec into \
a rescue shell. This will be either [initramfs]/bin/sh if the error occurred \
before switching the root or [rootfs]/bin/sh if it occurred after. \
 \
Initramfs-tools integration package. Install the public key that should be used \
to verify the rootfs to /etc/rootfs_key_pub.pem and this will be copied into \
the initramfs image."
SECTION = "admin"
SOURCE_PACKAGE = "cominit"
HOMEPAGE = "https://github.com/Elektrobit/cominit"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/c/cominit/cominit-initramfs_0.12.2_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "a2c4ba421dfae9ca0398c69227ae574e"
SRC_URI[deb0.sha1sum] = "7494e90188d41c58de3f537962cfe6f26e734282"
SRC_URI[deb0.sha256sum] = "deca481cf917f1118c0c7516a1e5fbb66a6bf99409696d6576ac5a79f4cb32ce"

RDEPENDS = " \
    cominit \
    initramfs-tools \
"

