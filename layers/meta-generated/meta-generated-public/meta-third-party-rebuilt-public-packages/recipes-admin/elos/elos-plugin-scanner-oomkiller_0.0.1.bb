# This was autogenerated! Do not modify
SUMMARY = "Event logging and management with normalized output-format (kmsg scanner plugin)"
DESCRIPTION = "elos is a tool to collect, store and publish various system events (i.e. \
syslogs, core dumps, measurements obtained from proc- and sys-fs, ...) \
while providing easy access to the collected data. \
 \
Oomkiller scanner plugin."
SECTION = "admin"
SOURCE_PACKAGE = "elos"
HOMEPAGE = "https://github.com/Elektrobit/elos"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/e/elos/elos-plugin-scanner-oomkiller_0.0.1_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "e769e7bc1744fbf1d656088b0c569551"
SRC_URI[deb0.sha1sum] = "c9bdf84d9e31c47af1de9d05b34be99259c78d8c"
SRC_URI[deb0.sha256sum] = "299135f74018f8f41c63bf058e2c51a2c72d7b441012131f5a4229a37b67d5d3"

RDEPENDS = " \
    libc6 \
    libelosplugin1 \
    libsafu0 \
"

