# This was autogenerated! Do not modify
SUMMARY = "Event logging and management with normalized output-format (Unix client plugin)"
DESCRIPTION = "elos is a tool to collect, store and publish various system events (i.e. \
syslogs, core dumps, measurements obtained from proc- and sys-fs, ...) \
while providing easy access to the collected data. \
 \
A plugin to communicate with elos via unix connections. It supports client authorization \
for local connections."
SECTION = "admin"
SOURCE_PACKAGE = "elos"
HOMEPAGE = "https://github.com/Elektrobit/elos"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/e/elos/elos-plugin-client-unix_0.0.1_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "e6ff02ed049081b466d056f31eb64157"
SRC_URI[deb0.sha1sum] = "01663ba4b59312abd3115dabe893b50f7af04d07"
SRC_URI[deb0.sha256sum] = "5e1c1a0b6c2f7330e5d7014b32bf1aa4b34bdb25a480e108c9e29a1678786e9e"

RDEPENDS = " \
    libc6 \
    libelosplugin1 \
    libsafu0 \
"

