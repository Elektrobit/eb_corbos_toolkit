# This was autogenerated! Do not modify
SUMMARY = "Unified Configuration Interface"
DESCRIPTION = ""
SECTION = "admin"
SOURCE_PACKAGE = "uci"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/u/uci/uci_20250206_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "c12556128fab791ddee5bcd6be5744cf"
SRC_URI[deb0.sha1sum] = "d90991255122e5321eb0dfd7feae8aca4a518404"
SRC_URI[deb0.sha256sum] = "0b66b772747699f5936222bc67f28391041bcf61b9fcb8b4e8943100a929ffc7"

RDEPENDS = " \
    libc6 \
    libuci1 \
"

