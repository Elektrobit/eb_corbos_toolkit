# This was autogenerated! Do not modify
SUMMARY = "Configurable Rootfs Init"
DESCRIPTION = "Crinit is an init daemon executed as PID 1 by the Linux Kernel. It reads a \
global configuration ("series"-file) either specified on the command line or \
from /etc/crinit/default.series. The series file in turn may reference further \
configuration files or a whole directory from which all configs shall be \
loaded. Each one defines a task potentially containing a set of commands and \
dependencies on other tasks. \
 \
The specified tasks are then started with as much parallelism as dependencies \
allow, i.e. tasks without any dependencies are spawned as soon as possible \
after Crinit has been started. Once a task is spawned, finished, or has \
failed, its dependent tasks are updated and spawned as necessary."
SECTION = "admin"
SOURCE_PACKAGE = "crinit"
HOMEPAGE = "https://github.com/Elektrobit/crinit"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/c/crinit/crinit_0.25.3_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "eff6d0fd3ae160cbba633d4f626c9689"
SRC_URI[deb0.sha1sum] = "e330227a4fc2c2c40382dea93cf211ab6d1e7181"
SRC_URI[deb0.sha256sum] = "1dd79ae02cec73b72cc81667305eb3b509ede26d189feabc90175ef642f379c5"

RDEPENDS = " \
    libc6 \
    libcap2 \
    libmbedcrypto16 \
    libsafu0 \
"

