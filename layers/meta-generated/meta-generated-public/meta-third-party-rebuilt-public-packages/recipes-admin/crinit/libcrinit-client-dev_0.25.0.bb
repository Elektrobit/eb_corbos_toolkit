# This was autogenerated! Do not modify
SUMMARY = "Configurable Rootfs Init client library development package"
DESCRIPTION = "Crinit is an init daemon executed as PID 1 by the Linux Kernel. It reads a \
global configuration ("series"-file) either specified on the command line or \
from /etc/crinit/default.series. The series file in turn may reference further \
configuration files or a whole directory from which all configs shall be \
loaded. Each one defines a task potentially containing a set of commands and \
dependencies on other tasks. \
 \
The specified tasks are then started with as much parallelism as dependencies \
allow, i.e. tasks without any dependencies are spawned as soon as possible \
after Crinit has been started. Once a task is spawned, finished, or has \
failed, its dependent tasks are updated and spawned as necessary. \
 \
Client library development package."
SECTION = "admin"
SOURCE_PACKAGE = "crinit"
HOMEPAGE = "https://github.com/Elektrobit/crinit"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/c/crinit/libcrinit-client-dev_0.25.0_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "ac20de299ea882cd409f083a9f485689"
SRC_URI[deb0.sha1sum] = "21338d7adc3b7db472982137b3fc6a13c66841a3"
SRC_URI[deb0.sha256sum] = "d4c2a382779a88bebb1c1d7f7e098b6d71899d4401a343e04b36d9f3ffbb19f2"

RDEPENDS = " \
    libcrinit-client0 \
"

