# This was autogenerated! Do not modify
SUMMARY = "Use Configurable Rootfs Init as init system"
DESCRIPTION = "Crinit is an init daemon executed as PID 1 by the Linux Kernel. It reads a \
global configuration ("series"-file) either specified on the command line or \
from /etc/crinit/default.series. The series file in turn may reference further \
configuration files or a whole directory from which all configs shall be \
loaded. Each one defines a task potentially containing a set of commands and \
dependencies on other tasks. \
 \
The specified tasks are then started with as much parallelism as dependencies \
allow, i.e. tasks without any dependencies are spawned as soon as possible \
after Crinit has been started. Once a task is spawned, finished, or has \
failed, its dependent tasks are updated and spawned as necessary. \
 \
Init system override package."
SECTION = "admin"
SOURCE_PACKAGE = "crinit"
HOMEPAGE = "https://github.com/Elektrobit/crinit"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/c/crinit/crinit-sysv_0.25.0_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "83b4c92ca3154edd0e58709b6f4d7282"
SRC_URI[deb0.sha1sum] = "77d875f0e9011d7c970574ec0ce7659553401e42"
SRC_URI[deb0.sha256sum] = "87e85129f71d1bfecce769fe05d87676bbcefafa6436e467321402db11a745a7"

RDEPENDS = " \
    crinit \
"

