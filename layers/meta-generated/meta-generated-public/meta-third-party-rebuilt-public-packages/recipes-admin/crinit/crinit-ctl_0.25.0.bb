# This was autogenerated! Do not modify
SUMMARY = "Configurable Rootfs Init control utility package"
DESCRIPTION = "Crinit is an init daemon executed as PID 1 by the Linux Kernel. It reads a \
global configuration ("series"-file) either specified on the command line or \
from /etc/crinit/default.series. The series file in turn may reference further \
configuration files or a whole directory from which all configs shall be \
loaded. Each one defines a task potentially containing a set of commands and \
dependencies on other tasks. \
 \
The specified tasks are then started with as much parallelism as dependencies \
allow, i.e. tasks without any dependencies are spawned as soon as possible \
after Crinit has been started. Once a task is spawned, finished, or has \
failed, its dependent tasks are updated and spawned as necessary. \
 \
Control utility package."
SECTION = "admin"
SOURCE_PACKAGE = "crinit"
HOMEPAGE = "https://github.com/Elektrobit/crinit"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/c/crinit/crinit-ctl_0.25.0_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "abe53e62f8dd218040312d0104bfafeb"
SRC_URI[deb0.sha1sum] = "6bee69d02880a5c3f6b917a34651590ab4184550"
SRC_URI[deb0.sha256sum] = "071500ed7ee00b76e291943a662ce7cfb4d76bbd24b846cbec4ef6880a9f43a2"

RDEPENDS = " \
    crinit \
    libc6 \
    libcrinit-client0 \
"

