# This was autogenerated! Do not modify
SUMMARY = "Configurable Rootfs Init client library development package"
DESCRIPTION = "Crinit is an init daemon executed as PID 1 by the Linux Kernel. It reads a \
global configuration ("series"-file) either specified on the command line or \
from /etc/crinit/default.series. The series file in turn may reference further \
configuration files or a whole directory from which all configs shall be \
loaded. Each one defines a task potentially containing a set of commands and \
dependencies on other tasks. \
 \
The specified tasks are then started with as much parallelism as dependencies \
allow, i.e. tasks without any dependencies are spawned as soon as possible \
after Crinit has been started. Once a task is spawned, finished, or has \
failed, its dependent tasks are updated and spawned as necessary. \
 \
Client library development package."
SECTION = "admin"
SOURCE_PACKAGE = "crinit"
HOMEPAGE = "https://github.com/Elektrobit/crinit"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/c/crinit/libcrinit-client-dev_0.25.3_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "3ff3c8f62710b871e43f2d6e0c210a50"
SRC_URI[deb0.sha1sum] = "d9d24d28aa410e4ee224852b3730802f15e6088d"
SRC_URI[deb0.sha256sum] = "073a481fa2c57704bb39668634bed0e277de55a981ba856521d439da9cfa08c6"

RDEPENDS = " \
    libcrinit-client0 \
"

