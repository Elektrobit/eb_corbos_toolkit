# This was autogenerated! Do not modify
SUMMARY = "Documentation for Configurable Rootfs Init"
DESCRIPTION = "Crinit is an init daemon executed as PID 1 by the Linux Kernel. It reads a \
global configuration ("series"-file) either specified on the command line or \
from /etc/crinit/default.series. The series file in turn may reference further \
configuration files or a whole directory from which all configs shall be \
loaded. Each one defines a task potentially containing a set of commands and \
dependencies on other tasks. \
 \
The specified tasks are then started with as much parallelism as dependencies \
allow, i.e. tasks without any dependencies are spawned as soon as possible \
after Crinit has been started. Once a task is spawned, finished, or has \
failed, its dependent tasks are updated and spawned as necessary. \
 \
Documentation package."
SECTION = "admin"
SOURCE_PACKAGE = "crinit"
HOMEPAGE = "https://github.com/Elektrobit/crinit"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/c/crinit/crinit-doc_0.25.3_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "defac3a44ca517a2cacc43aa41cf9f73"
SRC_URI[deb0.sha1sum] = "7e09da33d248170f50300093d88b053f29162459"
SRC_URI[deb0.sha256sum] = "5ce9a0e28f4b00ef86db0d4ad983a25788c96a48fc435f63ae22a7a4cc70f97d"


