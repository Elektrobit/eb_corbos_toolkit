# This was autogenerated! Do not modify
SUMMARY = "Configurable Rootfs Init"
DESCRIPTION = "Crinit is an init daemon executed as PID 1 by the Linux Kernel. It reads a \
global configuration ("series"-file) either specified on the command line or \
from /etc/crinit/default.series. The series file in turn may reference further \
configuration files or a whole directory from which all configs shall be \
loaded. Each one defines a task potentially containing a set of commands and \
dependencies on other tasks. \
 \
The specified tasks are then started with as much parallelism as dependencies \
allow, i.e. tasks without any dependencies are spawned as soon as possible \
after Crinit has been started. Once a task is spawned, finished, or has \
failed, its dependent tasks are updated and spawned as necessary."
SECTION = "admin"
SOURCE_PACKAGE = "crinit"
HOMEPAGE = "https://github.com/Elektrobit/crinit"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/c/crinit/crinit_0.25.0_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "22367178c1908b217ed61da7c43a87bd"
SRC_URI[deb0.sha1sum] = "cdedb3aea97154ca9570c1e161bdedf2c795b26a"
SRC_URI[deb0.sha256sum] = "49e5a70496ef81e3513fe9b0f53d21903ba2e425438625ebb7d160c5da56f071"

RDEPENDS = " \
    libc6 \
    libcap2 \
    libmbedcrypto16 \
    libsafu0 \
"

