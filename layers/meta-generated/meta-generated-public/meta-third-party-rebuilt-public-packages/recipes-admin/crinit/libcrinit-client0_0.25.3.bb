# This was autogenerated! Do not modify
SUMMARY = "Configurable Rootfs Init client library"
DESCRIPTION = "Crinit is an init daemon executed as PID 1 by the Linux Kernel. It reads a \
global configuration ("series"-file) either specified on the command line or \
from /etc/crinit/default.series. The series file in turn may reference further \
configuration files or a whole directory from which all configs shall be \
loaded. Each one defines a task potentially containing a set of commands and \
dependencies on other tasks. \
 \
The specified tasks are then started with as much parallelism as dependencies \
allow, i.e. tasks without any dependencies are spawned as soon as possible \
after Crinit has been started. Once a task is spawned, finished, or has \
failed, its dependent tasks are updated and spawned as necessary. \
 \
Client library package."
SECTION = "admin"
SOURCE_PACKAGE = "crinit"
HOMEPAGE = "https://github.com/Elektrobit/crinit"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/c/crinit/libcrinit-client0_0.25.3_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "3e27943428fbedbf622875abf8125fd9"
SRC_URI[deb0.sha1sum] = "cfb9ddbab58d82f922344d20e62bd56e8ee725e8"
SRC_URI[deb0.sha256sum] = "e58663d73dc2ffef6f709f99641a5ddff0e1bc333d2cd098b85d93c00a50b183"

RDEPENDS = " \
    libc6 \
"

