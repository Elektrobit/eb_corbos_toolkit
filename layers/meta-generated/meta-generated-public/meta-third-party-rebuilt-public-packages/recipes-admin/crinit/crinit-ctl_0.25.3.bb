# This was autogenerated! Do not modify
SUMMARY = "Configurable Rootfs Init control utility package"
DESCRIPTION = "Crinit is an init daemon executed as PID 1 by the Linux Kernel. It reads a \
global configuration ("series"-file) either specified on the command line or \
from /etc/crinit/default.series. The series file in turn may reference further \
configuration files or a whole directory from which all configs shall be \
loaded. Each one defines a task potentially containing a set of commands and \
dependencies on other tasks. \
 \
The specified tasks are then started with as much parallelism as dependencies \
allow, i.e. tasks without any dependencies are spawned as soon as possible \
after Crinit has been started. Once a task is spawned, finished, or has \
failed, its dependent tasks are updated and spawned as necessary. \
 \
Control utility package."
SECTION = "admin"
SOURCE_PACKAGE = "crinit"
HOMEPAGE = "https://github.com/Elektrobit/crinit"

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/c/crinit/crinit-ctl_0.25.3_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "0227bb7fd0de376d99643f4094fc3c5c"
SRC_URI[deb0.sha1sum] = "2c2db263dcba0c7a313fdaa75f0efdc956b7ee80"
SRC_URI[deb0.sha256sum] = "3dd1959f5c870429dc420ff961c33cc35a4ddd3d8007133623c628d879938a94"

RDEPENDS = " \
    crinit \
    libc6 \
    libcrinit-client0 \
"

