# This was autogenerated! Do not modify
SUMMARY = "OpenWrt micro bus architecture"
DESCRIPTION = ""
SECTION = "admin"
SOURCE_PACKAGE = "ubus"
HOMEPAGE = ""

inherit dpkg-prebuilt

DPKG_ARCH = "arm64"
SRC_URI = " \
    ${REPO_THIRD_PARTY_REBUILT_BY_ELEKTROBIT}/pool/main/u/ubus/ubus_20250807_arm64.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "dfe5681f3bc75ac95ecc54f535515e25"
SRC_URI[deb0.sha1sum] = "a13acad9b75efd705db2d7344dc91517a7e88112"
SRC_URI[deb0.sha256sum] = "ab9da62354084fb6181184c095e5d0100ccc0ff581c560e4f19df9338efbf0d3"

RDEPENDS = " \
    libblobmsg-json1 \
    libc6 \
    libubox1 \
    libubus1 \
"

