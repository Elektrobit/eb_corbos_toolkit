# Break circular dependency
RDEPENDS:remove = "libssl3t64"
