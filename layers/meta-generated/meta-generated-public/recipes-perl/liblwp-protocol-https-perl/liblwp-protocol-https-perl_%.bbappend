# Break circular dependency
RDEPENDS:remove = "libwww-perl"
