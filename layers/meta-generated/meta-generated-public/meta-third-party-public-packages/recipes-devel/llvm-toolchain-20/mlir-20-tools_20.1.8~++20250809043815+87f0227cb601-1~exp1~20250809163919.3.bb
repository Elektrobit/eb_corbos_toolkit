# This was autogenerated! Do not modify
SUMMARY = "Multi-Level Intermediate Representation tools"
DESCRIPTION = "Novel approach to building reusable and extensible compiler infrastructure. \
MLIR aims to address software fragmentation, improve compilation for \
heterogeneous hardware, significantly reduce the cost of building domain \
specific compilers, and aid in connecting existing compilers together. \
 \
This package provides tools."
SECTION = "devel"
SOURCE_PACKAGE = "llvm-toolchain-20"
HOMEPAGE = "https://www.llvm.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_LLVM}/pool/llvm_20/l/llvm-toolchain-20/mlir-20-tools_20.1.8~++20250809043815+87f0227cb601-1~exp1~20250809163919.3_amd64.deb;name=deb0 \
    ${REPO_LLVM}/pool/llvm_20/l/llvm-toolchain-20/mlir-20-tools_20.1.8~++20250809043815+87f0227cb601-1~exp1~20250809163919.3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "56f509a09095a13619bc34254c0bc05e"
SRC_URI[deb0.sha1sum] = "8e79ce0d2b74fdb91295e13c6ad553934124f9a5"
SRC_URI[deb0.sha256sum] = "b680f90680eaaa40e6cca9dd9013f9462ef6a0d972c820db01b8354b3375fa43"
SRC_URI[deb0.sha512sum] = "fd33a975fde4d04c805a1e493f47671cdb8b51f338421ab0e3b98df2535036bf9935840bcbfa227fc3abf94b2f931cf6664908102ac1aa7f16ed0b2172306c37"
SRC_URI[deb1.md5sum] = "7e3aeb38d55cbfafa1e7a71929230242"
SRC_URI[deb1.sha1sum] = "67705cd935c6aaaafb04415502834490a4d1527c"
SRC_URI[deb1.sha256sum] = "db05596a7c026cc08700b80343e96362615c3ec547223f91d23c6c8dc7b7a376"
SRC_URI[deb1.sha512sum] = "aa81f0129e650a0feba373c8d9ddf88c81642f30d5eaf772f981030b3b025a6540ff12d9153c16c90aee50ed314d6c1470348733d10e991ce781ae3674cc0848"

RDEPENDS = " \
    libc6 \
    libgcc-s1 \
    libllvm20 \
    libmlir-20 \
    libstdc++6 \
    libz3-4 \
    libzstd1 \
    zlib1g \
"

