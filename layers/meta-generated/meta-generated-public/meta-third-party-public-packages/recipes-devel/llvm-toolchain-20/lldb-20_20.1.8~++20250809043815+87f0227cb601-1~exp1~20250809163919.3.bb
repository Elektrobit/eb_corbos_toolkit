# This was autogenerated! Do not modify
SUMMARY = "Next generation, high-performance debugger"
DESCRIPTION = "LLDB is a next generation, high-performance debugger. It is built as a set of \
reusable components which highly leverage existing libraries in the larger LLVM \
Project, such as the Clang expression parser and LLVM disassembler."
SECTION = "devel"
SOURCE_PACKAGE = "llvm-toolchain-20"
HOMEPAGE = "https://www.llvm.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_LLVM}/pool/llvm_20/l/llvm-toolchain-20/lldb-20_20.1.8~++20250809043815+87f0227cb601-1~exp1~20250809163919.3_amd64.deb;name=deb0 \
    ${REPO_LLVM}/pool/llvm_20/l/llvm-toolchain-20/lldb-20_20.1.8~++20250809043815+87f0227cb601-1~exp1~20250809163919.3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "e345e2cf11a56721791169bbd8f4614b"
SRC_URI[deb0.sha1sum] = "3caa88b7072e1c4f4bb69990b4d576477c94d707"
SRC_URI[deb0.sha256sum] = "77ecc63371e460f1233f498143c8e4274e68011386f11dfdfc4cc31214fb8ebe"
SRC_URI[deb0.sha512sum] = "3dd9e2c19bfb59dfc3f046e49ce501bc1ca05603da249e01987107835ab1a80e801ff73ec2b81bb4fbc2d5cb96d2f64bd2f1962d3a0ac9ccd38cce3698d10388"
SRC_URI[deb1.md5sum] = "5d7df07618c26d3a7f9303d0f32cfc39"
SRC_URI[deb1.sha1sum] = "28eaf435f43d682fb93d138ed80d86c19869874e"
SRC_URI[deb1.sha256sum] = "e7cb161c8e6827006a31a1c360fc9bdab027f41c6cc116fb7044bd76463b9ab7"
SRC_URI[deb1.sha512sum] = "4390f55f9c376e894ceb2336b733fc474af7f8b0e07962686370b99b6db80d68d9b856a4b18d11af37cf991ac270ad2a700414778be4dcfed40ee1e7d63bcc00"

RDEPENDS = " \
    libc6 \
    libclang-cpp20 \
    libedit2 \
    libgcc-s1 \
    liblldb-20 \
    libllvm20 \
    libncurses6 \
    libstdc++6 \
    libtinfo6 \
    libxml2 \
    python3-lldb-20 \
    zlib1g \
"

