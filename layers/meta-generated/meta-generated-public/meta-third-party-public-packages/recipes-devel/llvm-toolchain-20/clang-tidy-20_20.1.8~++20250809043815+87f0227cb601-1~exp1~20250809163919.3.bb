# This was autogenerated! Do not modify
SUMMARY = "clang-based C++ linter tool"
DESCRIPTION = "Provide an extensible framework for diagnosing and fixing typical programming \
errors, like style violations, interface misuse, or bugs that can be deduced \
via static analysis. clang-tidy is modular and provides a convenient interface \
for writing new checks."
SECTION = "devel"
SOURCE_PACKAGE = "llvm-toolchain-20"
HOMEPAGE = "https://www.llvm.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_LLVM}/pool/llvm_20/l/llvm-toolchain-20/clang-tidy-20_20.1.8~++20250809043815+87f0227cb601-1~exp1~20250809163919.3_amd64.deb;name=deb0 \
    ${REPO_LLVM}/pool/llvm_20/l/llvm-toolchain-20/clang-tidy-20_20.1.8~++20250809043815+87f0227cb601-1~exp1~20250809163919.3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "e54e9e68c5ba9c1c7940d8a4da7aae16"
SRC_URI[deb0.sha1sum] = "2ec1186f6f82bf464f93202d249aba5139cb98fa"
SRC_URI[deb0.sha256sum] = "8e498e375ae49bb9ec5bf796482e41f4d183391b5c906e50752b45a07f0b2113"
SRC_URI[deb0.sha512sum] = "dcffc070df4f5eb924797dbf6faa06fafd4e97fca6d4c676957be22754101a9875e4e1f78a9efc6280e61d873f6694b6e14e25865bce52c0fc3f61a955f5cd39"
SRC_URI[deb1.md5sum] = "0dcfab6f6b2f19261243e321ec71aa8c"
SRC_URI[deb1.sha1sum] = "1dc40ded52e2de388c2354944e5b1a0d18748eba"
SRC_URI[deb1.sha256sum] = "e116e6bd4ce4e9f20435647e81ba765d85491ff5f79aaae514a16d41f8f64e29"
SRC_URI[deb1.sha512sum] = "2d6f1b95efc1c00ecec1df1f81c7f2b203e6555b1536246a502b8635641006c4a3a5ca6cb6d14dd75165964695da691e0e847ed83b8d589928771812dfe84243"

RDEPENDS = " \
    clang-tools-20 \
    libc6 \
    libclang-common-20-dev \
    libclang-cpp20 \
    libgcc-s1 \
    libllvm20 \
    libstdc++6 \
    python3 \
    python3-yaml \
"

