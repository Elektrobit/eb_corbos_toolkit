# This was autogenerated! Do not modify
SUMMARY = "Modular compiler and toolchain technologies - Plugins"
DESCRIPTION = "LLVM is a collection of libraries and tools that make it easy to build \
compilers, optimizers, just-in-time code generators, and many other \
compiler-related programs. \
 \
This package contains the LLVMgold and LLVMPolly linker plugins."
SECTION = "devel"
SOURCE_PACKAGE = "llvm-toolchain-20"
HOMEPAGE = "https://www.llvm.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_LLVM}/pool/llvm_20/l/llvm-toolchain-20/llvm-20-linker-tools_20.1.8~++20250809043815+87f0227cb601-1~exp1~20250809163919.3_amd64.deb;name=deb0 \
    ${REPO_LLVM}/pool/llvm_20/l/llvm-toolchain-20/llvm-20-linker-tools_20.1.8~++20250809043815+87f0227cb601-1~exp1~20250809163919.3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "abf54a2139770993a437e0edcb33bbe6"
SRC_URI[deb0.sha1sum] = "70b340677add596284ecb9685cfaf06c49951cbc"
SRC_URI[deb0.sha256sum] = "c30840c1f7205501ba8d297079bf8817197aad1b9c4ff781a3cff751b3702576"
SRC_URI[deb0.sha512sum] = "5f6cbceb2ef1d79f976fe8acc0bd028d990ff860d57ade58ba6be5762e75bc6c0ed36061969b8fac96ed05da1e595557bcba44949837e59ad034af9387d5dac8"
SRC_URI[deb1.md5sum] = "92f7ee3d5e47836ee27f2d3d0bcbb7b7"
SRC_URI[deb1.sha1sum] = "1c23c0911c1aef85e241f72b19f45035a467a8d2"
SRC_URI[deb1.sha256sum] = "3e0b68cdac94442ffc4e94ac61ccb3f29118ebe988dc752cafbd30f48b3ef0f0"
SRC_URI[deb1.sha512sum] = "4d6722da6cdea1e7830ef0fb9eb9820ccb415b66e5629d8f01c94fa5e9ff0d8243cf948cc992e7c9e1b6fa41ebf825f5aeb93401a19d79957be9590dd5040031"

RDEPENDS = " \
    libc6 \
    libgcc-s1 \
    libllvm20 \
    libstdc++6 \
"

