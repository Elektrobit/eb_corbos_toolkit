# This was autogenerated! Do not modify
SUMMARY = "Post-link optimizer"
DESCRIPTION = "It achieves the improvements by optimizing application's code layout based on \
execution profile gathered by sampling profiler."
SECTION = "devel"
SOURCE_PACKAGE = "llvm-toolchain-20"
HOMEPAGE = "https://www.llvm.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_LLVM}/pool/llvm_20/l/llvm-toolchain-20/bolt-20_20.1.8~++20250809043815+87f0227cb601-1~exp1~20250809163919.3_amd64.deb;name=deb0 \
    ${REPO_LLVM}/pool/llvm_20/l/llvm-toolchain-20/bolt-20_20.1.8~++20250809043815+87f0227cb601-1~exp1~20250809163919.3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "fff4040e6cfd934c0bda05e04c11cf0f"
SRC_URI[deb0.sha1sum] = "d5c1a6ff445e93b674ac2ef19ad53abc12d00f60"
SRC_URI[deb0.sha256sum] = "158dd8eca87bc44f364dac1d4f6f91f998d5b8fbb6db611243c22809ffb7a5b7"
SRC_URI[deb0.sha512sum] = "c1d6704ca494374695d7168d278de7db8ca3503065cd9319bbabf7e206bfd0495c58d211399f730cf950dd4dc5e61664b6f91ac704ee3c73821cbb9f746aa556"
SRC_URI[deb1.md5sum] = "09b59d1f57b55cc0474e2d70a6988351"
SRC_URI[deb1.sha1sum] = "f75f410c7935616fe93fff165063e1717053e9eb"
SRC_URI[deb1.sha256sum] = "4a40686fa9617c319579b1a2ffe3dc421de0bede3e54c27609fb4657b4de9742"
SRC_URI[deb1.sha512sum] = "e2a55ebe8ffaa89143207aa048ba1a9c4c4d64d9feeeab6dab80e78b249c4c9665dd2a4d9fc5b7ff5dec9017e4a422e28ce97f9ca1e83282b4004d016e34d26e"

RDEPENDS = " \
    libbolt-20-dev \
    libc6 \
    libgcc-s1 \
    libstdc++6 \
    libz3-4 \
    libzstd1 \
    zlib1g \
"

