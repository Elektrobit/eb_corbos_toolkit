# This was autogenerated! Do not modify
SUMMARY = "LLVM-based linker"
DESCRIPTION = "LLD is a new, high-performance linker. It is built as a set of reusable \
components which highly leverage existing libraries in the larger LLVM \
Project."
SECTION = "devel"
SOURCE_PACKAGE = "llvm-toolchain-20"
HOMEPAGE = "https://www.llvm.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_LLVM}/pool/llvm_20/l/llvm-toolchain-20/lld-20_20.1.8~++20250809043815+87f0227cb601-1~exp1~20250809163919.3_amd64.deb;name=deb0 \
    ${REPO_LLVM}/pool/llvm_20/l/llvm-toolchain-20/lld-20_20.1.8~++20250809043815+87f0227cb601-1~exp1~20250809163919.3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "696b1671ffd8485f0e8e7c4c399e28ac"
SRC_URI[deb0.sha1sum] = "30b1986c36656d2a49319108bc89895fa1c8181e"
SRC_URI[deb0.sha256sum] = "468ba32f8a0c7dc351fa3c06f2c4e3ef87099eb8101cc83088e1d065c0f222f1"
SRC_URI[deb0.sha512sum] = "c6812c6933be67190520cc93f2f18e61c9e7d53a2972684c26ecad3d7c49c068430f236ebfc7607913a81272a0b1729c70a015a7de3baa461fbb63202aa70570"
SRC_URI[deb1.md5sum] = "50d3c7170c281bf33809328ae1fbe5c9"
SRC_URI[deb1.sha1sum] = "d61ac308ba2747385307ee0bd4aecb7273c6701e"
SRC_URI[deb1.sha256sum] = "80dfc12c66a29a60c81ce4d9ccfcfb024c133c2ec3bc15d6d0f0e3879a825e3f"
SRC_URI[deb1.sha512sum] = "659b02e558149f9bda1d83c33dc0a303a2f7b58cfb10344ee554fe75107e211f33bd9f8491c89cc23731d5851afd6f4a7b85f09a5838b3ae1732f8aafdc5870d"

RDEPENDS = " \
    libc6 \
    libgcc-s1 \
    libllvm20 \
    libstdc++6 \
    libzstd1 \
    zlib1g \
"

