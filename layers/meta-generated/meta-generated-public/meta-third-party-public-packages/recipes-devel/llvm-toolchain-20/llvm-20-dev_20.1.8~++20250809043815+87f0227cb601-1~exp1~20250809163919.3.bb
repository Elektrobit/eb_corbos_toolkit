# This was autogenerated! Do not modify
SUMMARY = "Modular compiler and toolchain technologies, libraries and headers"
DESCRIPTION = "LLVM is a collection of libraries and tools that make it easy to build \
compilers, optimizers, just-in-time code generators, and many other \
compiler-related programs. \
 \
LLVM uses a single, language-independent virtual instruction set both \
as an offline code representation (to communicate code between \
compiler phases and to run-time systems) and as the compiler internal \
representation (to analyze and transform programs). This persistent \
code representation allows a common set of sophisticated compiler \
techniques to be applied at compile-time, link-time, install-time, \
run-time, or "idle-time" (between program runs). \
 \
This package provides the libraries and headers to develop applications \
using llvm."
SECTION = "devel"
SOURCE_PACKAGE = "llvm-toolchain-20"
HOMEPAGE = "https://www.llvm.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_LLVM}/pool/llvm_20/l/llvm-toolchain-20/llvm-20-dev_20.1.8~++20250809043815+87f0227cb601-1~exp1~20250809163919.3_amd64.deb;name=deb0 \
    ${REPO_LLVM}/pool/llvm_20/l/llvm-toolchain-20/llvm-20-dev_20.1.8~++20250809043815+87f0227cb601-1~exp1~20250809163919.3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "a042385a9c6568713ede5001ca04bc53"
SRC_URI[deb0.sha1sum] = "12708b9d8469f2fc2176e8e2063c4e30c7130842"
SRC_URI[deb0.sha256sum] = "2c2a4e02addaeba8a0936866fcae17b1edac0cca621fb09f74708db0ccc04dbd"
SRC_URI[deb0.sha512sum] = "25125e251a9fbe2c623829d79a95291aba32ff77eb93f5b90baa2486bba28be58fddf4ca8ad9d85f6926033933a47004c1f8397c4b476ddb8cd6752ad4fbc972"
SRC_URI[deb1.md5sum] = "e33dadaef6a6cc483637bd09d91ff7fc"
SRC_URI[deb1.sha1sum] = "665bfb5379635bb14ba6836570a98eae4206b88b"
SRC_URI[deb1.sha256sum] = "8d7e4d99f39cc1b45b1a44e4e768568c2d4f9e8bc67bbdac57a9ff103d94e7e1"
SRC_URI[deb1.sha512sum] = "fc84056202cd7987fd97fd2396511c43a92f559744a0491798749f6867f93aa88654bfa660874fdc516609987f28e382b0f3ee75e98491bdc5152925639fa934"

RDEPENDS = " \
    libc6 \
    libclang-cpp20 \
    libffi-dev \
    libgcc-s1 \
    libllvm20 \
    libncurses-dev \
    libstdc++6 \
    libxml2-dev \
    libz3-dev \
    llvm-20 \
    llvm-20-tools \
"

