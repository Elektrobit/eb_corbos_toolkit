# This was autogenerated! Do not modify
SUMMARY = "Modular compiler and toolchain technologies"
DESCRIPTION = "LLVM is a collection of libraries and tools that make it easy to build \
compilers, optimizers, just-in-time code generators, and many other \
compiler-related programs. \
 \
LLVM uses a single, language-independent virtual instruction set both \
as an offline code representation (to communicate code between \
compiler phases and to run-time systems) and as the compiler internal \
representation (to analyze and transform programs). This persistent \
code representation allows a common set of sophisticated compiler \
techniques to be applied at compile-time, link-time, install-time, \
run-time, or "idle-time" (between program runs). \
 \
The strengths of the LLVM infrastructure are its extremely \
simple design (which makes it easy to understand and use), \
source-language independence, powerful mid-level optimizer, automated \
compiler debugging support, extensibility, and its stability and \
reliability. LLVM is currently being used to host a wide variety of \
academic research projects and commercial projects. LLVM includes C \
and C++ front-ends, a front-end for a Forth-like language (Stacker), \
a young scheme front-end, and Java support is in development. LLVM can \
generate code for X96, SparcV10, PowerPC or many other architectures."
SECTION = "devel"
SOURCE_PACKAGE = "llvm-toolchain-20"
HOMEPAGE = "https://www.llvm.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_LLVM}/pool/llvm_20/l/llvm-toolchain-20/llvm-20_20.1.8~++20250809043815+87f0227cb601-1~exp1~20250809163919.3_amd64.deb;name=deb0 \
    ${REPO_LLVM}/pool/llvm_20/l/llvm-toolchain-20/llvm-20_20.1.8~++20250809043815+87f0227cb601-1~exp1~20250809163919.3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "b66ea9fcd751d6dec6db2cd582fb8636"
SRC_URI[deb0.sha1sum] = "2e50d9bac57dbaa506a6b5253b3aa833e9ca1603"
SRC_URI[deb0.sha256sum] = "3b21ca96e6ef8471550b57693a7809e39f10e54aad84681e4ae6f967d07984e3"
SRC_URI[deb0.sha512sum] = "925c94444b0097b36606ddce4e2a8d061df65bf562bb87b446d59724f48b9c9e084964f5cc03f1b66cd58f71be29f6b0cef5cfcfcd3e3560d989fae52654e889"
SRC_URI[deb1.md5sum] = "3e40e685d08d1a4250fcf55db4c2158f"
SRC_URI[deb1.sha1sum] = "4153e7adeccd68419ac5c07e39c2f35581d39fa1"
SRC_URI[deb1.sha256sum] = "69d1c370083ab59fe53d5b62c5fbb21f7c6cdec726392ff0290c999a70d86ebe"
SRC_URI[deb1.sha512sum] = "fbf79c16f9147e187aa04dd828dea3c4453d0c2aa7f4acca64010b8389522490b3406c510751bf6022c5dabac4d72ad4fad94201a603aa4ada9ca4d9bb303b94"

RDEPENDS = " \
    libc6 \
    libcurl4t64 \
    libgcc-s1 \
    libllvm20 \
    libpfm4 \
    libstdc++6 \
    libz3-4 \
    libzstd1 \
    llvm-20-linker-tools \
    llvm-20-runtime \
    zlib1g \
"

