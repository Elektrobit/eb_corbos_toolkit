# This was autogenerated! Do not modify
SUMMARY = "Fortran compiler"
DESCRIPTION = "Ground-up implementation of a Fortran front end written in \
modern C++. \
 \
While it is capable of generating executables for a number \
of examples, some functionalities are still missing."
SECTION = "devel"
SOURCE_PACKAGE = "llvm-toolchain-20"
HOMEPAGE = "https://www.llvm.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_LLVM}/pool/llvm_20/l/llvm-toolchain-20/flang-20_20.1.8~++20250809043815+87f0227cb601-1~exp1~20250809163919.3_amd64.deb;name=deb0 \
    ${REPO_LLVM}/pool/llvm_20/l/llvm-toolchain-20/flang-20_20.1.8~++20250809043815+87f0227cb601-1~exp1~20250809163919.3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "947207e1ca42ca06f0e8ba5fb3527c3a"
SRC_URI[deb0.sha1sum] = "dc725cc6f5f705770dfce2db84df0b2c46e32505"
SRC_URI[deb0.sha256sum] = "b1b8335b18025f74c2d442546b78b16f2a8b73aac34ae35c7232465f4b77138c"
SRC_URI[deb0.sha512sum] = "fcb516f92e970b171158db05b0bb52ab7c2c4bbcabb1e9410a6955318d9b4e6725e70e5b71f5d6f555807af5b112d774a18f83158bb275a8037bd37eba2188cd"
SRC_URI[deb1.md5sum] = "1fffc8c8529159eab605eec9d4f8d658"
SRC_URI[deb1.sha1sum] = "44d38564559a7f68c607b549f6aca15ca7a84788"
SRC_URI[deb1.sha256sum] = "a5c5cc82bbb6a650ce56960bd06e2ff47c84938d5811d09318728d7f67c60b25"
SRC_URI[deb1.sha512sum] = "420982cb29f528849fb3af71b03eaa52cccccc10bce69c010523077c7be2509d2e1c166d20e79613cda482cd938ac55c829c6c40c7049447420c0d2109cb9d21"

RDEPENDS = " \
    libc6 \
    libclang-cpp20 \
    libflang-20-dev \
    libgcc-14-dev \
    libgcc-s1 \
    libllvm20 \
    libmlir-20 \
    libstdc++-14-dev \
    libstdc++6 \
"

RPROVIDES = " \
    fortran-compiler \
    gfortran-mod-15 \
"
