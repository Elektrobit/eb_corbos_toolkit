# This was autogenerated! Do not modify
SUMMARY = "LLVM OpenMP runtime"
DESCRIPTION = "The runtime is the part of the OpenMP implementation that your code is \
linked against, and that manages the multiple threads in an OpenMP program \
while it is executing."
SECTION = "devel"
SOURCE_PACKAGE = "llvm-toolchain-20"
HOMEPAGE = "https://www.llvm.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_LLVM}/pool/llvm_20/l/llvm-toolchain-20/libomp5-20_20.1.8~++20250809043815+87f0227cb601-1~exp1~20250809163919.3_amd64.deb;name=deb0 \
    ${REPO_LLVM}/pool/llvm_20/l/llvm-toolchain-20/libomp5-20_20.1.8~++20250809043815+87f0227cb601-1~exp1~20250809163919.3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "6ef46374cb4d32567ed33ad1d693db72"
SRC_URI[deb0.sha1sum] = "33c6faef1def273c9e532b82fbf86909086feb05"
SRC_URI[deb0.sha256sum] = "f15a3d2b798779b5db265dedad31093c828923f600ca326e852c7a3acf16a9e1"
SRC_URI[deb0.sha512sum] = "190fd04dc2a650f18c630637511ea1b5754880abc1d2f118b12b2e59d62aa5022e19889a46efa0a924c63c85e799514dc7e0ceb247909ab7ae177c5eb431cb91"
SRC_URI[deb1.md5sum] = "86274a62d1019c8d99e96a42e8c56677"
SRC_URI[deb1.sha1sum] = "123518a1358408c3b89ef0c781f4a030f1c7012b"
SRC_URI[deb1.sha256sum] = "dca22a6b7ec65db444258c174d678717d78b85ed2e904433b92370a38d5e27a0"
SRC_URI[deb1.sha512sum] = "a1a1d70f52adc54acca5e480c6323d114b6f9113a831b91d62eaac77d80d4b7b7e61f36adde6929be9a83b77eb76d4844b0408e96da2503b1f084280c3e75a0b"

RDEPENDS = " \
    libc6 \
    libgcc-s1 \
    libllvm20 \
    libstdc++6 \
"

RPROVIDES = " \
    libomp-x.y \
"
