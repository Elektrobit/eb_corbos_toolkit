# This was autogenerated! Do not modify
SUMMARY = "Modular compiler and toolchain technologies, IR interpreter"
DESCRIPTION = "LLVM is a collection of libraries and tools that make it easy to build \
compilers, optimizers, just-in-time code generators, and many other \
compiler-related programs. \
 \
LLVM uses a single, language-independent virtual instruction set both \
as an offline code representation (to communicate code between \
compiler phases and to run-time systems) and as the compiler internal \
representation (to analyze and transform programs). This persistent \
code representation allows a common set of sophisticated compiler \
techniques to be applied at compile-time, link-time, install-time, \
run-time, or "idle-time" (between program runs). \
 \
This package provides the minimal required to execute programs in LLVM \
format."
SECTION = "devel"
SOURCE_PACKAGE = "llvm-toolchain-20"
HOMEPAGE = "https://www.llvm.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_LLVM}/pool/llvm_20/l/llvm-toolchain-20/llvm-20-runtime_20.1.8~++20250809043815+87f0227cb601-1~exp1~20250809163919.3_amd64.deb;name=deb0 \
    ${REPO_LLVM}/pool/llvm_20/l/llvm-toolchain-20/llvm-20-runtime_20.1.8~++20250809043815+87f0227cb601-1~exp1~20250809163919.3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "92a963ab19c9ad145ee0fb968c98349b"
SRC_URI[deb0.sha1sum] = "bffc674459cdee7360dc638db606f6ea2c5e301b"
SRC_URI[deb0.sha256sum] = "d91aaf4814c2b494f130f8cced292310d91647f941ab6ffd2d4e9cb84ea31681"
SRC_URI[deb0.sha512sum] = "a1f6ad0426c03d999f1bda19fd4ee320e12d450e788e48f20f08acf391fe74f133428bf649528c3d483a1cbb03040de1288ae4134bd94b7d30d9f904600b7f7d"
SRC_URI[deb1.md5sum] = "a36192af491beeb9912e9d162afcbe66"
SRC_URI[deb1.sha1sum] = "c4aa0c7c9f33e182e474ffb9a1898e3cc0128060"
SRC_URI[deb1.sha256sum] = "af8d40613290081107ecc70f2053d116cdc95a91cb7e709f38405e7bae44669c"
SRC_URI[deb1.sha512sum] = "e5f25328758b50097ce86ad22925e03a12c5e1420bf96ca4ca224f643e34e22e54805a139a1f9432e1a8e66a5d5994c0588bd86f53894cbf8c44445def54bf2c"

RDEPENDS = " \
    libc6 \
    libgcc-s1 \
    libllvm20 \
    libstdc++6 \
    libz3-4 \
    libzstd1 \
    zlib1g \
"

