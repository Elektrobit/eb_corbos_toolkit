# This was autogenerated! Do not modify
SUMMARY = "Modular compiler and toolchain technologies, tools"
DESCRIPTION = "LLVM is a collection of libraries and tools that make it easy to build \
compilers, optimizers, just-in-time code generators, and many other \
compiler-related programs. \
 \
LLVM uses a single, language-independent virtual instruction set both \
as an offline code representation (to communicate code between \
compiler phases and to run-time systems) and as the compiler internal \
representation (to analyze and transform programs). This persistent \
code representation allows a common set of sophisticated compiler \
techniques to be applied at compile-time, link-time, install-time, \
run-time, or "idle-time" (between program runs). \
 \
This package provides tools for testing."
SECTION = "devel"
SOURCE_PACKAGE = "llvm-toolchain-20"
HOMEPAGE = "https://www.llvm.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_LLVM}/pool/llvm_20/l/llvm-toolchain-20/llvm-20-tools_20.1.8~++20250809043815+87f0227cb601-1~exp1~20250809163919.3_amd64.deb;name=deb0 \
    ${REPO_LLVM}/pool/llvm_20/l/llvm-toolchain-20/llvm-20-tools_20.1.8~++20250809043815+87f0227cb601-1~exp1~20250809163919.3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "7617e37fad797622b0a09708e2a2424d"
SRC_URI[deb0.sha1sum] = "7593e740c97b6c5ce19d889dc195db9d1d7cdf07"
SRC_URI[deb0.sha256sum] = "6caae1385e75adc0e32f3e0985cc2fbae6578f2fc74ce8e93ce2716878eb9773"
SRC_URI[deb0.sha512sum] = "bd4383bd6316926e2d0f966202071ca23e04f6341bec59e2f3ff7cca42a95a73d2fb65f8b0d8a6716d27b613fef90e5fdddaaa002391b47e1f1a6b6456a9e694"
SRC_URI[deb1.md5sum] = "9d6c19f285fef5a9ed31d3fc32a1a583"
SRC_URI[deb1.sha1sum] = "39f9a3b9e98876888e9bd0bbf937f69be27f123d"
SRC_URI[deb1.sha256sum] = "6795bf65202e52e05b186dcc3f69e8f7c6c3bacfeda15110b1458d8e96a6cf4d"
SRC_URI[deb1.sha512sum] = "39d045133ae1131c887655055eca467cfe6e6e4f7928173d1429558a1ff0949f46ba884e0b635e4bda0356b0d172a6835a27b12158a7532f30d922c32d93a048"

RDEPENDS = " \
    libc6 \
    libgcc-s1 \
    libllvm20 \
    libstdc++6 \
    libz3-4 \
    libzstd1 \
    python3 \
    python3-pygments \
    python3-yaml \
    zlib1g \
"

