# This was autogenerated! Do not modify
SUMMARY = "Modular compiler and toolchain technologies, OCaml bindings"
DESCRIPTION = "LLVM is a collection of libraries and tools that make it easy to build \
compilers, optimizers, just-in-time code generators, and many other \
compiler-related programs. \
 \
LLVM uses a single, language-independent virtual instruction set both \
as an offline code representation (to communicate code between \
compiler phases and to run-time systems) and as the compiler internal \
representation (to analyze and transform programs). This persistent \
code representation allows a common set of sophisticated compiler \
techniques to be applied at compile-time, link-time, install-time, \
run-time, or "idle-time" (between program runs). \
 \
This package provides the OCaml bindings to develop applications using llvm."
SECTION = "ocaml"
SOURCE_PACKAGE = "llvm-toolchain-20"
HOMEPAGE = "https://www.llvm.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_LLVM}/pool/llvm_20/l/llvm-toolchain-20/libllvm-20-ocaml-dev_20.1.8~++20250809043815+87f0227cb601-1~exp1~20250809163919.3_amd64.deb;name=deb0 \
    ${REPO_LLVM}/pool/llvm_20/l/llvm-toolchain-20/libllvm-20-ocaml-dev_20.1.8~++20250809043815+87f0227cb601-1~exp1~20250809163919.3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "c281eb8c0b125b728b97b70a3dfa2455"
SRC_URI[deb0.sha1sum] = "b0d9c618266c69c45116600f5cb2989873f0dc47"
SRC_URI[deb0.sha256sum] = "dffa45f05c01865d9c5ff29eac374671ba05b3c0e0e9a55d108fd078c82df521"
SRC_URI[deb0.sha512sum] = "af09a10484eb29ecfccc49380e172e1f56b19c8573fcc7897f0ad87d2d41a090f401f5afb1f32baca4ddcf6cfa441d6238f729de791eeb57b27b81eb5abb24b0"
SRC_URI[deb1.md5sum] = "fddd563746aa2f87a2b4067b493772ae"
SRC_URI[deb1.sha1sum] = "ff9ee82a63c3681a114ba9e44ee4fc706ec6df0a"
SRC_URI[deb1.sha256sum] = "a5daffacae4282bffc9e0b028af4f454bb63ee0274bac849d418e3e2308e84ff"
SRC_URI[deb1.sha512sum] = "a8d4dab7912a395eb13a1821f15817b240d957dfe123911a8a08f97919e50a618ed4ced37ba24c3771661bbe38329a67754152f12486316966218ee1a7630166"

RDEPENDS = " \
    libbigarray-compat-ocaml-dev-hryr0 \
    libintegers-ocaml-dev-vio08 \
    libstdlib-ocaml-dev-m4xw9 \
    llvm-20-dev \
    ocaml-5.3.0 \
"
RDEPENDS:append:amd64 = " \
    libctypes-ocaml-dev-3uda3 \
"
RDEPENDS:append:arm64 = " \
    libctypes-ocaml-dev-gmut9 \
"

RPROVIDES = " \
    libllvm-20-ocaml-dev-t6s07 \
    libllvm-x.y-ocaml-dev \
"
