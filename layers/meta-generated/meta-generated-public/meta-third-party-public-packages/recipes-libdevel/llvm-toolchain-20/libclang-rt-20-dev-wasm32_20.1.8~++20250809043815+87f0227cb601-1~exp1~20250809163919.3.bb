# This was autogenerated! Do not modify
SUMMARY = "Compiler-rt - wasm32 builtins"
DESCRIPTION = "Provides the compiler-rt builtins for WebAssembly 32 bits"
SECTION = "libdevel"
SOURCE_PACKAGE = "llvm-toolchain-20"
HOMEPAGE = "https://www.llvm.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_LLVM}/pool/llvm_20/l/llvm-toolchain-20/libclang-rt-20-dev-wasm32_20.1.8~++20250809043815+87f0227cb601-1~exp1~20250809163919.3_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "49c34245d6c1f51d7607ac533b90bc8e"
SRC_URI[deb0.sha1sum] = "c8c5d468cdc4c7f2a6ff56faef3a2473f75ba1ce"
SRC_URI[deb0.sha256sum] = "90e1854c4edfd950edabee7fe06ff05f156596520d3d751e56ab5016e9f13554"
SRC_URI[deb0.sha512sum] = "71a9877192014b1d3e31fc26e3a108fd3b598e93b0594168123449eda77fe5f6c6132c161360ec05498a26c475bda56eb0b3af3e2114d4d8f3df9c442deda46d"


