# This was autogenerated! Do not modify
SUMMARY = "Library for coverage-guided fuzz testing"
DESCRIPTION = "LibFuzzer is a library for in-process, coverage-guided, evolutionary fuzzing \
of other libraries. \
 \
LibFuzzer is similar in concept to American Fuzzy Lop (AFL), but it performs \
all of its fuzzing inside a single process. This in-process fuzzing can be \
more restrictive and fragile, but is potentially much faster as there is no \
overhead for process start-up. \
 \
The fuzzer is linked with the library under test, and feeds fuzzed inputs to \
the library via a specific fuzzing entrypoint (aka 'target function'); the \
fuzzer then tracks which areas of the code are reached, and generates mutations \
on the corpus of input data in order to maximize the code coverage. The code \
coverage information for libFuzzer is provided by LLVM's SanitizerCoverage \
instrumentation."
SECTION = "libdevel"
SOURCE_PACKAGE = "llvm-toolchain-20"
HOMEPAGE = "https://www.llvm.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_LLVM}/pool/llvm_20/l/llvm-toolchain-20/libfuzzer-20-dev_20.1.8~++20250809043815+87f0227cb601-1~exp1~20250809163919.3_amd64.deb;name=deb0 \
    ${REPO_LLVM}/pool/llvm_20/l/llvm-toolchain-20/libfuzzer-20-dev_20.1.8~++20250809043815+87f0227cb601-1~exp1~20250809163919.3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "f03c880c4d3f2d0422e1fd73a505ae7d"
SRC_URI[deb0.sha1sum] = "89de964d5fa852e76e642d252820e094f6307dde"
SRC_URI[deb0.sha256sum] = "786df445032eaa880ff9a5d8a0001fe8c788bd17e55a16d7e366145d21b47d5e"
SRC_URI[deb0.sha512sum] = "2cf34f924e9040262fdfd9fea75d0da7e93b63d57cf1a2443d1e7c6c8ff90edd7b442f021d98b10645d0df37aa5f411847f3e6b7f264e267e92234047f891d4e"
SRC_URI[deb1.md5sum] = "ce053cf48f01d2c2ec53f2e6184ca606"
SRC_URI[deb1.sha1sum] = "3ff921267aa2897b07097a758698e28686237201"
SRC_URI[deb1.sha256sum] = "3eca2a4825ba060a5008ab3ce1869be26dd001d9d57f6ce38ca0e39d0e87a4c7"
SRC_URI[deb1.sha512sum] = "1ce4b7be91276ee20d75fe6eedee7e4b46ef229fbd3dc72c3d6e79bda261dcac9ae49191326a73d4f06c6393070b48e22844d8ddfa811338a3fa00fe9f72802c"

RDEPENDS = " \
    clang-20 \
"

