# This was autogenerated! Do not modify
SUMMARY = "C++ interface to the Clang library"
DESCRIPTION = "Clang project is a C, C++, Objective C and Objective C++ front-end \
based on the LLVM compiler. Its goal is to offer a replacement to the \
GNU Compiler Collection (GCC). \
 \
Clang implements all of the ISO C++ 1998, 11, 14 and 17 standards and also \
provides most of the support of C++20. \
 \
This package contains the Clang C++ library. \
 \
The C++ Interface to Clang provides an API that exposes \
facilities for parsing source code into an abstract syntax tree (AST), \
loading already-parsed ASTs, traversing the AST, associating physical source \
locations with elements within the AST, and other facilities that support \
Clang-based development tools. \
 \
This package contains symlinks without a version number, which needed by \
linker at build time."
SECTION = "libdevel"
SOURCE_PACKAGE = "llvm-toolchain-20"
HOMEPAGE = "https://www.llvm.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_LLVM}/pool/llvm_20/l/llvm-toolchain-20/libclang-cpp20-dev_20.1.8~++20250809043815+87f0227cb601-1~exp1~20250809163919.3_amd64.deb;name=deb0 \
    ${REPO_LLVM}/pool/llvm_20/l/llvm-toolchain-20/libclang-cpp20-dev_20.1.8~++20250809043815+87f0227cb601-1~exp1~20250809163919.3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "65468323426a29fcbe1e56faaa37a3e1"
SRC_URI[deb0.sha1sum] = "06a2d84187f6209d0dd784f765e7621760813988"
SRC_URI[deb0.sha256sum] = "a4ad230488e46541b422846c871106ef9df043faea568e9ff4f8560dfc0684de"
SRC_URI[deb0.sha512sum] = "a8252398add7d337ce531f7392564c09b5a30ee56678954e25c3bde24e2c5c3b78bce601048d7e86cb87e3d90aca2351c7637fcefe070a8a5ca6a700fcaffeea"
SRC_URI[deb1.md5sum] = "32bab25ff8a5549382c4b30263f39f9d"
SRC_URI[deb1.sha1sum] = "fb32d32994c71610d2dd0d91a5d639751ae62f37"
SRC_URI[deb1.sha256sum] = "7b5b42845449e0d55ac8e5ee8562de3debef3ecb64c15838813d191faf42f50b"
SRC_URI[deb1.sha512sum] = "e57746f5bc32a497e87ee25b3a9017cb1a54adb455f46bcb234cf4591e96bff5be2090e8eccecfbf207462a4a4d3da6233f6c732e49a511ba87a0f6789e97812"

RDEPENDS = " \
    libclang-cpp20 \
    libgcc-14-dev \
    libstdc++-14-dev \
"

