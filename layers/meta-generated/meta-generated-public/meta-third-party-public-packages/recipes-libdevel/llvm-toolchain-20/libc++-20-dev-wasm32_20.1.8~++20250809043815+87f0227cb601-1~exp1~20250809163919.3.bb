# This was autogenerated! Do not modify
SUMMARY = "LLVM C++ Standard library (WASI)"
DESCRIPTION = "libc++ is another implementation of the C++ standard library \
 \
Features and Goals \
 \
  * Correctness as defined by the C++ standards. \
  * Fast execution. \
  * Minimal memory use. \
  * Fast compile times. \
  * ABI compatibility with gcc's libstdc++ for some low-level features such \
    as exception objects, rtti and memory allocation. \
  * Extensive unit tests. \
 \
This package provides a version for the 32-bit WebAssembly System Interface."
SECTION = "libdevel"
SOURCE_PACKAGE = "llvm-toolchain-20"
HOMEPAGE = "https://www.llvm.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_LLVM}/pool/llvm_20/l/llvm-toolchain-20/libc++-20-dev-wasm32_20.1.8~++20250809043815+87f0227cb601-1~exp1~20250809163919.3_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "e952702cd3ccae9748e4944e43d3816e"
SRC_URI[deb0.sha1sum] = "daa220cb0621f70f92d5ad17049f6a003994da6e"
SRC_URI[deb0.sha256sum] = "6120cb3f700bc12a78b4afab39e4f05b5a54e2e2cfc66d698b568608318c0b2c"
SRC_URI[deb0.sha512sum] = "8d7ae9d7bb0c5b866a50ae8783665559c4f15a17c9ee05502e8665c481c3097765c1d0526fe4d371e0d3bd31163cc476c84b176c12c86dde4ae842ec99fd737d"

RDEPENDS = " \
    libc++abi-20-dev-wasm32 \
    wasi-libc \
"

RPROVIDES = " \
    libc++-x.y-dev-wasm32 \
"
