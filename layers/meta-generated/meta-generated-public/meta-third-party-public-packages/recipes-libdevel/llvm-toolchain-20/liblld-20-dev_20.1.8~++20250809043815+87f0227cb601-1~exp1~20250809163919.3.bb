# This was autogenerated! Do not modify
SUMMARY = "LLVM-based linker, header files"
DESCRIPTION = "LLD is a new, high-performance linker. It is built as a set of reusable \
components which highly leverage existing libraries in the larger LLVM \
Project. \
 \
This package provides the header files to build extension over lld."
SECTION = "libdevel"
SOURCE_PACKAGE = "llvm-toolchain-20"
HOMEPAGE = "https://www.llvm.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_LLVM}/pool/llvm_20/l/llvm-toolchain-20/liblld-20-dev_20.1.8~++20250809043815+87f0227cb601-1~exp1~20250809163919.3_amd64.deb;name=deb0 \
    ${REPO_LLVM}/pool/llvm_20/l/llvm-toolchain-20/liblld-20-dev_20.1.8~++20250809043815+87f0227cb601-1~exp1~20250809163919.3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "f7c1d488f62b3a4393661b1093091c87"
SRC_URI[deb0.sha1sum] = "5ec3c0aaaf806e92ee3263f1ea183d89f384b5f5"
SRC_URI[deb0.sha256sum] = "da82d9e383be4208dfe08bf27f18d5749861ee11f233e6db989be7db546424a3"
SRC_URI[deb0.sha512sum] = "77b5145a30ee08de597626ca2791e5958df90f415637820459b302df7c3e03c4bd4b6786015efd8e7a5c2de059fc113f215f7e036b709efb3583d1db965373cb"
SRC_URI[deb1.md5sum] = "b1247762c9e24bf688c8600b542cc19d"
SRC_URI[deb1.sha1sum] = "9a8833b209e9d8413c2fcd247fcd7b13227777db"
SRC_URI[deb1.sha256sum] = "093e53733eab94704f1e0471eaa8a18af1fc2f1faae42523cb440ad0f54100da"
SRC_URI[deb1.sha512sum] = "c210693a76b40ab474e8a4e6d3a6520409f95b2dfc320af42f6e88779496e440404e1aa87b2dc254a003d3912a767f5a4d2635ca45732663dee21e9941309af8"

RDEPENDS = " \
    liblld-20 \
    libzstd-dev \
    lld-20 \
    zlib1g-dev \
"

