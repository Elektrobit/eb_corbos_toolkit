# This was autogenerated! Do not modify
SUMMARY = "Offload Library - Development Package"
DESCRIPTION = "The offload library facilitates efficient task distribution by offloading \
specific computational tasks from the CPU to alternative hardware accelerators \
such as GPUs or FPGAs. \
 \
This development package includes headers and other resources needed for building \
applications that utilize the offload runtime."
SECTION = "libdevel"
SOURCE_PACKAGE = "llvm-toolchain-20"
HOMEPAGE = "https://www.llvm.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_LLVM}/pool/llvm_20/l/llvm-toolchain-20/liboffload-20-dev_20.1.8~++20250809043815+87f0227cb601-1~exp1~20250809163919.3_amd64.deb;name=deb0 \
    ${REPO_LLVM}/pool/llvm_20/l/llvm-toolchain-20/liboffload-20-dev_20.1.8~++20250809043815+87f0227cb601-1~exp1~20250809163919.3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "bfd532b2ba6257cb384bf69baff4e246"
SRC_URI[deb0.sha1sum] = "00ab469896d3629acf5e5648c29840837b342d9f"
SRC_URI[deb0.sha256sum] = "a1a4c4750a8e0996d49d9404ce0f0d543c7e0511aaee77acd7fe0b69206615d3"
SRC_URI[deb0.sha512sum] = "c7c05f9378d53b2d8b51d4936e30e752622e24d137bc8510147faf14e37e30b1296f27c85434535c8a05be6f2caa283eed63380d9b136649fdbc8954739234fa"
SRC_URI[deb1.md5sum] = "572661562d8e3a7a1723431b37e412ba"
SRC_URI[deb1.sha1sum] = "00d4e014dad0ebca9451dc246e42c55ecdc78d86"
SRC_URI[deb1.sha256sum] = "56aaab03af2b3fc1f42739bc36b9e4c77dbeb02b2500f0ba4d31c4bf86652acc"
SRC_URI[deb1.sha512sum] = "a2d90d412cf284526e1ff49bdca3c243df518622dfef77328e05055b8fea98f7aeb77c4e46e12d30ae48fce91c1c44884d5dd37ab726fb06246aa4394a401e51"

RDEPENDS = " \
    libc6 \
    libgcc-s1 \
    libllvm20 \
    liboffload-20 \
    libomp5-20 \
    libstdc++6 \
    libz3-4 \
    libzstd1 \
    zlib1g \
"

RPROVIDES = " \
    liboffload-x.y-dev \
"
