# This was autogenerated! Do not modify
SUMMARY = "OpenCL C language implementation - development files"
DESCRIPTION = "libclc is an open implementation of the OpenCL C programming language, \
as specified by the OpenCL 1.1 Specification. \
 \
This package contains development header files."
SECTION = "libdevel"
SOURCE_PACKAGE = "llvm-toolchain-20"
HOMEPAGE = "https://www.llvm.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_LLVM}/pool/llvm_20/l/llvm-toolchain-20/libclc-20-dev_20.1.8~++20250809043815+87f0227cb601-1~exp1~20250809163919.3_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "ce9c180ec58f08ab8ff6d446853027b4"
SRC_URI[deb0.sha1sum] = "4803b20c52063c817cfac220044f2b7feb167536"
SRC_URI[deb0.sha256sum] = "95e16214ddae9d52827c18aa6ab647ead750e83203e5fd7f012b73b120741e53"
SRC_URI[deb0.sha512sum] = "476e6895ef84af6d36d31ae2c9c0f25290d9dd7ad3d10ef59c7acf6d272d99c6e60c3256f9fed1fae4f8124a65c465c4949f2ec9a699ca52650978db45d84ae9"


RPROVIDES = " \
    libclc-x.y-dev \
"
