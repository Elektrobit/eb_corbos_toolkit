# This was autogenerated! Do not modify
SUMMARY = "LLVM OpenMP runtime - dev package"
DESCRIPTION = "The runtime is the part of the OpenMP implementation that your code is \
linked against, and that manages the multiple threads in an OpenMP program \
while it is executing."
SECTION = "libdevel"
SOURCE_PACKAGE = "llvm-toolchain-20"
HOMEPAGE = "https://www.llvm.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_LLVM}/pool/llvm_20/l/llvm-toolchain-20/libomp-20-dev_20.1.8~++20250809043815+87f0227cb601-1~exp1~20250809163919.3_amd64.deb;name=deb0 \
    ${REPO_LLVM}/pool/llvm_20/l/llvm-toolchain-20/libomp-20-dev_20.1.8~++20250809043815+87f0227cb601-1~exp1~20250809163919.3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "133475b8dd064c1be32bffb5cc72fd29"
SRC_URI[deb0.sha1sum] = "64dc3867ccc10cedb866bf2408e755eb25d7823c"
SRC_URI[deb0.sha256sum] = "d975d6bcae5eafce3fcf6819c961a8c2c5a07fa17cc3d7ee0071b2ffd5f4fee7"
SRC_URI[deb0.sha512sum] = "eaec08b1ac2a62581bf0eb274ee105378b89e23c26e4f0806f31b5f45d1f37bd8962753aaa52b353d6d84d5de0497e2b70b7b547929cc8419e02adb0a17f768c"
SRC_URI[deb1.md5sum] = "613db5397aabc47a60b530143dfff89e"
SRC_URI[deb1.sha1sum] = "7226c3363c44ff6c79b8388a48176e3aa161b5bb"
SRC_URI[deb1.sha256sum] = "21c5f33b0808a96f740fedd476f0674234bf6cd7bf9c946f29c3c6ccd9dc203a"
SRC_URI[deb1.sha512sum] = "f4c1dc39d15d20d148ac65d77015cd98c5c186036105d4dd67f32b5b7a12a65ab7fd6a257abd77bdc9375e17b515f02de59eaa5ef9a3702bbea504b1dc690115"

RDEPENDS = " \
    libc6 \
    libgcc-s1 \
    libomp5-20 \
    libpython3.13 \
    libstdc++6 \
"

RPROVIDES = " \
    libomp-x.y-dev \
"
