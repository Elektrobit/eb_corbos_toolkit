# This was autogenerated! Do not modify
SUMMARY = "Post-link optimizer"
DESCRIPTION = "It achieves the improvements by optimizing application's code layout based on \
execution profile gathered by sampling profiler."
SECTION = "libdevel"
SOURCE_PACKAGE = "llvm-toolchain-20"
HOMEPAGE = "https://www.llvm.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_LLVM}/pool/llvm_20/l/llvm-toolchain-20/libbolt-20-dev_20.1.8~++20250809043815+87f0227cb601-1~exp1~20250809163919.3_amd64.deb;name=deb0 \
    ${REPO_LLVM}/pool/llvm_20/l/llvm-toolchain-20/libbolt-20-dev_20.1.8~++20250809043815+87f0227cb601-1~exp1~20250809163919.3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "d4514a2766a227cc9d5f771753b287bd"
SRC_URI[deb0.sha1sum] = "7c487a06c1917a1d285d1e29d3a8e4d420cf8d63"
SRC_URI[deb0.sha256sum] = "d31f3c559d90e8924c1bae95f7d2cb307d19c283a823b186a7f55e7d8a7c245d"
SRC_URI[deb0.sha512sum] = "179bd856c54944bc37140868765d89e004b88129e3f2340ae953a8cf522a3ed2bef7be7f5aa4f3da88cb07514db1ea065d49b4258c00433f3873b956a94123fa"
SRC_URI[deb1.md5sum] = "7b7b38862b18c40c1e0c436501053610"
SRC_URI[deb1.sha1sum] = "f3106becd7ebf804891636582f2fe3e6cf71c21b"
SRC_URI[deb1.sha256sum] = "833188636f444e518b8cf8f38afe288a44a55504b6162498b8cbd6bb7d1d25ea"
SRC_URI[deb1.sha512sum] = "4d1e8080bac3c6f6d646d442bad07cb17848ea1fe9b6e7c730bd5b811c9d941fcc0ad650a7f345699606d6eae3a4d7d802c17b1c49b716f3ec17dcc0c288d626"


