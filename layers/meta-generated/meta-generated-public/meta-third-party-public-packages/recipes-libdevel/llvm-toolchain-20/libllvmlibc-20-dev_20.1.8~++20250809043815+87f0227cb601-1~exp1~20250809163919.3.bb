# This was autogenerated! Do not modify
SUMMARY = "LLVM C Library - dev package"
DESCRIPTION = "Implementation of the C standard library targeting C17 and above. \
 \
This is an experimental project. Don't use in production."
SECTION = "libdevel"
SOURCE_PACKAGE = "llvm-toolchain-20"
HOMEPAGE = "https://www.llvm.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_LLVM}/pool/llvm_20/l/llvm-toolchain-20/libllvmlibc-20-dev_20.1.8~++20250809043815+87f0227cb601-1~exp1~20250809163919.3_amd64.deb;name=deb0 \
    ${REPO_LLVM}/pool/llvm_20/l/llvm-toolchain-20/libllvmlibc-20-dev_20.1.8~++20250809043815+87f0227cb601-1~exp1~20250809163919.3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "b74a4c1820ad6180519d29c413a62ab2"
SRC_URI[deb0.sha1sum] = "8f5dbcf522b6b984a5d78e93ba89d3b9568dc303"
SRC_URI[deb0.sha256sum] = "ca3355702e97f04b94be327bb1c15ec061d5c276f8215b8478417135bc9faf95"
SRC_URI[deb0.sha512sum] = "00c1b9bb768c54bb1f8cb4ce6f0f6bea25f4efd9a2ea115faf8ecf0689ef39a3af54f176b0e195f1282de721e014fd04a845592589ea86533103c84bc7bc21eb"
SRC_URI[deb1.md5sum] = "e0e6439d685cacf731a6142ef61e0f53"
SRC_URI[deb1.sha1sum] = "5a196a757f5e2b97b059fcf498da5cc309d92a53"
SRC_URI[deb1.sha256sum] = "17a805624dbcddf116ac0d88ee53a2a57019045ee2e5a2cbb33933b81ad4294a"
SRC_URI[deb1.sha512sum] = "a3e9a12cc1adc747e830ecc7d3e45c1c074c259c65baa56bd336bd6dc84fcebcc03574dba14e78c8dd888a8b2c5bd4dc5914adbdb00734a06ce27efedeaabb2c"


