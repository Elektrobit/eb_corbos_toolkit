# This was autogenerated! Do not modify
SUMMARY = "Compiler-rt - wasm64 builtins"
DESCRIPTION = "Provides the compiler-rt builtins for WebAssembly 64 bits"
SECTION = "libdevel"
SOURCE_PACKAGE = "llvm-toolchain-20"
HOMEPAGE = "https://www.llvm.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_LLVM}/pool/llvm_20/l/llvm-toolchain-20/libclang-rt-20-dev-wasm64_20.1.8~++20250809043815+87f0227cb601-1~exp1~20250809163919.3_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "6dbd9f6d4f91a9c5c1e387eb130e8c65"
SRC_URI[deb0.sha1sum] = "80f2114ec885965d21d7d4902295045deef6f802"
SRC_URI[deb0.sha256sum] = "31f19d878847c2284b581f5a980e2e9761314f93fe2f770f40b01bb05f5f7928"
SRC_URI[deb0.sha512sum] = "d2f39fa36da1b6efd18a1df766de3099a52f8157a101074933f422520ae33cce40f78f5aea6fab27f1cea140642e1fb8ee6626da74a2994c4c563fb78399c7a0"


