# This was autogenerated! Do not modify
SUMMARY = "Clang library - Common development package"
DESCRIPTION = "Clang project is a C, C++, Objective C and Objective C++ front-end \
based on the LLVM compiler. Its goal is to offer a replacement to the \
GNU Compiler Collection (GCC). \
 \
Clang implements all of the ISO C++ 1998, 11, 14 and 17 standards and also \
provides most of the support of C++20. \
 \
This package contains the Clang generic headers."
SECTION = "libdevel"
SOURCE_PACKAGE = "llvm-toolchain-20"
HOMEPAGE = "https://www.llvm.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_LLVM}/pool/llvm_20/l/llvm-toolchain-20/libclang-common-20-dev_20.1.8~++20250809043815+87f0227cb601-1~exp1~20250809163919.3_amd64.deb;name=deb0 \
    ${REPO_LLVM}/pool/llvm_20/l/llvm-toolchain-20/libclang-common-20-dev_20.1.8~++20250809043815+87f0227cb601-1~exp1~20250809163919.3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "e043e5cb66f2037bee415300a6cfed5d"
SRC_URI[deb0.sha1sum] = "73cd8af159fbf256f54103052078853a3c62bdce"
SRC_URI[deb0.sha256sum] = "d8e8c76744be99ed008b55a0f05920e5b71f3a5962ed7936aa407bc56563ab70"
SRC_URI[deb0.sha512sum] = "b1bfa9fb186bdb133e8274e20881be121bfea45e0a74a1aa8e73206aeebf651f465189cd576bebb72248aa238c6b6ba59f5d367eebe1a825e5be7a7bdd2aa151"
SRC_URI[deb1.md5sum] = "83d61fef29b342a70463c91ebe05bc22"
SRC_URI[deb1.sha1sum] = "827eb4234d4264760068dfdd723855214cb23499"
SRC_URI[deb1.sha256sum] = "b7963aa8774504c07f4108305faa5915ac9262f1652d9e6999b2f8778f1c4ad9"
SRC_URI[deb1.sha512sum] = "9dea8d57d0d67e086d547b738b840679c3ec78de435d285dc5dff12c5a7f12b093e300fcac36eab024d62cc4b37f2e94508b0700a154ca3277c1c7e5003e7a55"


