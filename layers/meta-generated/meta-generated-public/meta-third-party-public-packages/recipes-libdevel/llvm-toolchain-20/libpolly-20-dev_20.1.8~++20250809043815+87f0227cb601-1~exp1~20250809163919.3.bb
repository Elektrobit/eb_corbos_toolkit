# This was autogenerated! Do not modify
SUMMARY = "High-level loop and data-locality optimizer"
DESCRIPTION = "Uses an abstract mathematical representation based on integer polyhedra \
to analyze and optimize the memory access pattern of a program"
SECTION = "libdevel"
SOURCE_PACKAGE = "llvm-toolchain-20"
HOMEPAGE = "https://www.llvm.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_LLVM}/pool/llvm_20/l/llvm-toolchain-20/libpolly-20-dev_20.1.8~++20250809043815+87f0227cb601-1~exp1~20250809163919.3_amd64.deb;name=deb0 \
    ${REPO_LLVM}/pool/llvm_20/l/llvm-toolchain-20/libpolly-20-dev_20.1.8~++20250809043815+87f0227cb601-1~exp1~20250809163919.3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "a88d3ba75114817b2bee3db03303f66a"
SRC_URI[deb0.sha1sum] = "76af617482535035e9e17f5874b618742e20db2b"
SRC_URI[deb0.sha256sum] = "090467d3a9b267919da4932fcaced73809651cbb7b3100d58dcc7657d517b83f"
SRC_URI[deb0.sha512sum] = "fb71129d54680501e09edaa277005b86d2a3999c3d88015f705beb750bd360139a9f0c1ca62d02e6d76e6c1c05891977b137bfb7a783b2216f1dfb3c3dcbb921"
SRC_URI[deb1.md5sum] = "e7347a512802ae661a0929acb1c5e24a"
SRC_URI[deb1.sha1sum] = "55a5d334f9388af3543deac613628a0d646296e1"
SRC_URI[deb1.sha256sum] = "b2bc156e76e6012778e41f4c7cf8dbf404d75a570dbc310b69140f950abd0ae5"
SRC_URI[deb1.sha512sum] = "f3abee2d219f628660218119d867ac484e1511fd1bff74f9f47141fcc1d4d5ea705f067e97edcf83ac783a5ad217f5ac1d253455adeff1fca1c04ffb9c88abba"


