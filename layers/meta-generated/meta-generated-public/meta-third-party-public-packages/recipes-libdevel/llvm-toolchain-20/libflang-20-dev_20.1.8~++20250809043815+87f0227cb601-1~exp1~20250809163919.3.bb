# This was autogenerated! Do not modify
SUMMARY = "Flang library - Development package"
DESCRIPTION = "Ground-up implementation of a Fortran front end written in \
modern C++. \
 \
While it is capable of generating executables for a number \
of examples, some functionalities are still missing. \
 \
This package contains the flang libraries and headers."
SECTION = "libdevel"
SOURCE_PACKAGE = "llvm-toolchain-20"
HOMEPAGE = "https://www.llvm.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_LLVM}/pool/llvm_20/l/llvm-toolchain-20/libflang-20-dev_20.1.8~++20250809043815+87f0227cb601-1~exp1~20250809163919.3_amd64.deb;name=deb0 \
    ${REPO_LLVM}/pool/llvm_20/l/llvm-toolchain-20/libflang-20-dev_20.1.8~++20250809043815+87f0227cb601-1~exp1~20250809163919.3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "c33140ec5db59fcd5307aefaa72dc2ac"
SRC_URI[deb0.sha1sum] = "200a884ecb316b77da0473a2ae86c1dfb5daba78"
SRC_URI[deb0.sha256sum] = "ce0c92e691884928e009dfc60b821bbf62d021ef0948df28c4dba72439b65dae"
SRC_URI[deb0.sha512sum] = "a349b597ee1eab8752bc4a15fd4d9d70f0bfc2a13015880970d3ca35dde39c43908ccd7792098eab1b134cae478437bd6dcac9fd8b2ba133e858e27ec7a11526"
SRC_URI[deb1.md5sum] = "2dda511652ecb13648f3f60784a6a9ad"
SRC_URI[deb1.sha1sum] = "02aa3701fad8288e4eb7b079f552eedcdd6798ef"
SRC_URI[deb1.sha256sum] = "b65a56d84ee6e93cf0948e5fba3410476c827a5b64b66114ee3de6cd87a70503"
SRC_URI[deb1.sha512sum] = "d68ec8ace81436ae2740f642c1fba8080a15377e6eea6b652f8b432ddc276575949fd708d9493cea01fc03fc9cdcb64338e774bb4768cf6f06e5cc164bdcb7d0"

RDEPENDS = " \
    libgcc-14-dev \
    libstdc++-14-dev \
"

