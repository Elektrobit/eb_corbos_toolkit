# This was autogenerated! Do not modify
SUMMARY = "Compiler-rt - development package"
DESCRIPTION = "This package provides various libraries: \
 \
  * builtins - Simple libraries that provide implementation of the \
    low-level target-specific hooks required by code generation \
    and other runtime components. \
  * sanitizer runtimes - AddressSanitizer, ThreadSanitizer, \
    UndefinedBehaviorSanitizer, MemorySanitizer, LeakSanitizer \
    DataFlowSanitizer, etc \
  * profile - Library which is used to collect coverage information."
SECTION = "libdevel"
SOURCE_PACKAGE = "llvm-toolchain-20"
HOMEPAGE = "https://www.llvm.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_LLVM}/pool/llvm_20/l/llvm-toolchain-20/libclang-rt-20-dev_20.1.8~++20250809043815+87f0227cb601-1~exp1~20250809163919.3_amd64.deb;name=deb0 \
    ${REPO_LLVM}/pool/llvm_20/l/llvm-toolchain-20/libclang-rt-20-dev_20.1.8~++20250809043815+87f0227cb601-1~exp1~20250809163919.3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "8fe1c0aabb926ecb34cfcda0daa31ac3"
SRC_URI[deb0.sha1sum] = "7c638d27be979a3153977112d1a81ccd4361d43a"
SRC_URI[deb0.sha256sum] = "dcfc9914f21f78daa416818a461cffb5db566dd6cc686b58f365cbbec43acd88"
SRC_URI[deb0.sha512sum] = "51056b6ad793723fe0db313b2393db13f7d56afe0f0cac502c7ce37be033381aa548fd82f133b08b9e751bb3d9c897f855ba313bccb13d7554c2e7ed023917f5"
SRC_URI[deb1.md5sum] = "32b7c1c7c18fc221ea091eb18f08c463"
SRC_URI[deb1.sha1sum] = "b1dcbcb9b5c44a900d68a10192687998e068dec1"
SRC_URI[deb1.sha256sum] = "688b8bd8b87944575b17c4d070bd6e9c6d8fff124e15df06f6362311110a0233"
SRC_URI[deb1.sha512sum] = "fd9e9aad9553cb5fb527577852fa4252e379053e1797799b053a0d6ff16cc9c605a2cf20c2cfc676052d8ab4b2a20997e0876a135ead0d22be779943f6479b60"

RDEPENDS = " \
    libc6 \
    libstdc++6 \
"
RDEPENDS:append:amd64 = " \
    lib32stdc++6 \
    libc6-i386 \
"

