# This was autogenerated! Do not modify
SUMMARY = "C, C++ and Objective-C compiler - Documentation"
DESCRIPTION = "Clang project is a C, C++, Objective C and Objective C++ front-end \
based on the LLVM compiler. Its goal is to offer a replacement to the \
GNU Compiler Collection (GCC). \
 \
Clang implements all of the ISO C++ 1998, 11, 14 and 17 standards and also \
provides most of the support of C++20. \
 \
This package contains the documentation."
SECTION = "doc"
SOURCE_PACKAGE = "llvm-toolchain-20"
HOMEPAGE = "https://www.llvm.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_LLVM}/pool/llvm_20/l/llvm-toolchain-20/clang-20-doc_20.1.8~++20250809043815+87f0227cb601-1~exp1~20250809163919.3_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "d427b2244c7e486556d23d7e0a8e9844"
SRC_URI[deb0.sha1sum] = "62a042ce9586e4a53591ba8863093f0fa6871144"
SRC_URI[deb0.sha256sum] = "9106da1d1281076b8edd5eea795d12e37bfd1c8c0852547e6ba8ab583907a548"
SRC_URI[deb0.sha512sum] = "5b0b2aec40662ab1f7445a04bfb17050321a28c6c7194fe08fcd4e0da21fcc423009831bebf12807874eec9e105dd8016eb589da81691b1664c90072d63776b2"

RDEPENDS = " \
    libjs-mathjax \
"

