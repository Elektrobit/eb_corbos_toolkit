# This was autogenerated! Do not modify
SUMMARY = "Modular compiler and toolchain technologies, examples"
DESCRIPTION = "LLVM is a collection of libraries and tools that make it easy to build \
compilers, optimizers, just-in-time code generators, and many other \
compiler-related programs. \
 \
LLVM uses a single, language-independent virtual instruction set both \
as an offline code representation (to communicate code between \
compiler phases and to run-time systems) and as the compiler internal \
representation (to analyze and transform programs). This persistent \
code representation allows a common set of sophisticated compiler \
techniques to be applied at compile-time, link-time, install-time, \
run-time, or "idle-time" (between program runs). \
 \
This package contains examples for using LLVM, both in developing \
extensions to LLVM and in using it to compile code."
SECTION = "doc"
SOURCE_PACKAGE = "llvm-toolchain-20"
HOMEPAGE = "https://www.llvm.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_LLVM}/pool/llvm_20/l/llvm-toolchain-20/llvm-20-examples_20.1.8~++20250809043815+87f0227cb601-1~exp1~20250809163919.3_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "2805f1ce727fc3a076f98b43dbf1c980"
SRC_URI[deb0.sha1sum] = "6239a4631694f2670b09960d05af7aa98528621d"
SRC_URI[deb0.sha256sum] = "0e5c4915c50132a631a457c77310001b011bb712057b5af9d6a4cef8d25b14ce"
SRC_URI[deb0.sha512sum] = "f20896046bf465850befff73090d0750e81bb0868dfe682f30c526633e83de8449ac5a78c874e930d06e0cdec1fb96deffea68b765d996fcd70172d1b0026e2a"

RDEPENDS = " \
    llvm-20-dev \
"

