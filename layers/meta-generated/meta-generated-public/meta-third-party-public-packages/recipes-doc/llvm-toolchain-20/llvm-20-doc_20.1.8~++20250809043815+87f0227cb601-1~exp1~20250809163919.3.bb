# This was autogenerated! Do not modify
SUMMARY = "Modular compiler and toolchain technologies, documentation"
DESCRIPTION = "LLVM is a collection of libraries and tools that make it easy to build \
compilers, optimizers, just-in-time code generators, and many other \
compiler-related programs. \
 \
LLVM uses a single, language-independent virtual instruction set both \
as an offline code representation (to communicate code between \
compiler phases and to run-time systems) and as the compiler internal \
representation (to analyze and transform programs). This persistent \
code representation allows a common set of sophisticated compiler \
techniques to be applied at compile-time, link-time, install-time, \
run-time, or "idle-time" (between program runs). \
 \
This package contains all documentation (extensive)."
SECTION = "doc"
SOURCE_PACKAGE = "llvm-toolchain-20"
HOMEPAGE = "https://www.llvm.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_LLVM}/pool/llvm_20/l/llvm-toolchain-20/llvm-20-doc_20.1.8~++20250809043815+87f0227cb601-1~exp1~20250809163919.3_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "3ebafff03149b7dda73486f85bce22e0"
SRC_URI[deb0.sha1sum] = "bdd6106436bc716cac9b26c554d771ac8890cc91"
SRC_URI[deb0.sha256sum] = "21348b3d239dbf2a2ee0d49c13196f16c0725cc006f549b6dbdf14df9d8af6d9"
SRC_URI[deb0.sha512sum] = "9ae81ec95efc38a3f5ec8b883539357ac0504b136b22d1ce2b0dcb00b889f7676057e95a28c96205bc82b2ca9a0088f5f4645308d0d5ea24d9f66016b920bf61"

RDEPENDS = " \
    libjs-jquery \
    libjs-underscore \
"

