# This was autogenerated! Do not modify
SUMMARY = "Clang examples"
DESCRIPTION = "Clang project is a C, C++, Objective C and Objective C++ front-end \
based on the LLVM compiler. Its goal is to offer a replacement to the \
GNU Compiler Collection (GCC). \
 \
Clang implements all of the ISO C++ 1998, 11, 14 and 17 standards and also \
provides most of the support of C++20. \
 \
This package contains the Clang examples."
SECTION = "doc"
SOURCE_PACKAGE = "llvm-toolchain-20"
HOMEPAGE = "https://www.llvm.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_LLVM}/pool/llvm_20/l/llvm-toolchain-20/clang-20-examples_20.1.8~++20250809043815+87f0227cb601-1~exp1~20250809163919.3_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "9250db8083fc30189c76e57e200515b2"
SRC_URI[deb0.sha1sum] = "4d560e45cdf88d07d98752f13ad870de7e16c325"
SRC_URI[deb0.sha256sum] = "cc5cf039c393e1d211955d5cd30d30151e915c29336bf5ba71330f6ace8de611"
SRC_URI[deb0.sha512sum] = "8e0fa528baaf605734269421e6cd9f54b5225430fb7d6b3e76edee86abe183ba03f906360965fa77be5fe65acee197b1dbbb9e02d4c4acb00b210694b7751a89"


