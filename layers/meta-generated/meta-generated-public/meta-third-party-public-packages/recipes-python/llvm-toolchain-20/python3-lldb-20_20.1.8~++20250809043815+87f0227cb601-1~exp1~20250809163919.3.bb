# This was autogenerated! Do not modify
SUMMARY = "Next generation, high-performance debugger, python3 lib"
DESCRIPTION = "LLDB is a next generation, high-performance debugger. It is built as a set of \
reusable components which highly leverage existing libraries in the larger LLVM \
Project, such as the Clang expression parser and LLVM disassembler. \
 \
This binding package provides access to lldb."
SECTION = "python"
SOURCE_PACKAGE = "llvm-toolchain-20"
HOMEPAGE = "https://www.llvm.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_LLVM}/pool/llvm_20/l/llvm-toolchain-20/python3-lldb-20_20.1.8~++20250809043815+87f0227cb601-1~exp1~20250809163919.3_amd64.deb;name=deb0 \
    ${REPO_LLVM}/pool/llvm_20/l/llvm-toolchain-20/python3-lldb-20_20.1.8~++20250809043815+87f0227cb601-1~exp1~20250809163919.3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "55ed6621136aabecf0998301d50537ae"
SRC_URI[deb0.sha1sum] = "fcc5a9ab9623a01b71e3692b6f8b285eb78c8b95"
SRC_URI[deb0.sha256sum] = "f957fab4913f3219af22d1d77b009a1ee953825561b165e99247b3be7b6e63d3"
SRC_URI[deb0.sha512sum] = "ed6a257edd3548e1c534fd207d8dd78d183909d9de45759d92274e7b951c6e148705ebde2b144ffa6235f9bb81721352f5c473b43388f8e7ffbc0d7c3fcae947"
SRC_URI[deb1.md5sum] = "7d8b04e280a39a7cd4f5f3edb47b4f0b"
SRC_URI[deb1.sha1sum] = "c0570002fb555ef5c2b799ca859002e957562b43"
SRC_URI[deb1.sha256sum] = "30af26cbe62de9658a451f019f888bffaa671b7f5540231291534c6a332d02a0"
SRC_URI[deb1.sha512sum] = "6e6cf2dd64a900973577ca7dbd231bc70c5af9a1bd58832493326e5e342a77732f509699bca7185427c7172d4ac58c96c6ae7faba04712de02c96d69dbda4202"

RDEPENDS = " \
    liblldb-20 \
"

RPROVIDES = " \
    python3-lldb-x.y \
"
