# This was autogenerated! Do not modify
SUMMARY = "Clang Python Bindings"
DESCRIPTION = "Clang project is a C, C++, Objective C and Objective C++ front-end \
based on the LLVM compiler. Its goal is to offer a replacement to the \
GNU Compiler Collection (GCC). \
 \
Clang implements all of the ISO C++ 1998, 11, 14 and 17 standards and also \
provides most of the support of C++20. \
 \
This binding package provides access to the Clang compiler and libraries."
SECTION = "python"
SOURCE_PACKAGE = "llvm-toolchain-20"
HOMEPAGE = "https://www.llvm.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_LLVM}/pool/llvm_20/l/llvm-toolchain-20/python3-clang-20_20.1.8~++20250809043815+87f0227cb601-1~exp1~20250809163919.3_amd64.deb;name=deb0 \
    ${REPO_LLVM}/pool/llvm_20/l/llvm-toolchain-20/python3-clang-20_20.1.8~++20250809043815+87f0227cb601-1~exp1~20250809163919.3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "7d182e936bdfd41a8643b38882313f56"
SRC_URI[deb0.sha1sum] = "7efefc0aa44e4b95adaa236773372ac35fee683b"
SRC_URI[deb0.sha256sum] = "6786b9e0a455a753eaf523aa6a60a8abd98ab7d0710a56c2e92065c41a64e2a7"
SRC_URI[deb0.sha512sum] = "13e71766c350f1570470c37dc5d91ab6443da507ef2a7181762e0491b9a47863f39dd8d7ed2cb263bb416043025a1747c8d5da4892dbc2fdcc0e2954e20d60b4"
SRC_URI[deb1.md5sum] = "9e7a0d2a307065ad7c6391e2eb327504"
SRC_URI[deb1.sha1sum] = "fa024f775d286991f0e953982e5a6693500b84bb"
SRC_URI[deb1.sha256sum] = "fdba19d2d75055841bef40aa5e770e1cccac45f80c9b00e42c364503111dfd33"
SRC_URI[deb1.sha512sum] = "d46b7625da49977d1db8f0a0f806d97071b08c5922ff3fca02c15db9f6324c3393def6756a67b0658b1cbc93a760c00ccf31ef5db39aca875590f8249f9928b7"

RDEPENDS = " \
    libclang-20-dev \
    python3 \
"

RPROVIDES = " \
    python-clang-x.y \
"
