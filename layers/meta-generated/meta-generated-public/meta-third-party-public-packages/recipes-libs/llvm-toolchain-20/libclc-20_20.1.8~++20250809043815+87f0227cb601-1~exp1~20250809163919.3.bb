# This was autogenerated! Do not modify
SUMMARY = "OpenCL C language implementation - platform support"
DESCRIPTION = "libclc is an open implementation of the OpenCL C programming language, \
as specified by the OpenCL 1.1 Specification. \
 \
This package contains support for the amdgcn (AMD GPU), PTX and r600 \
platforms."
SECTION = "libs"
SOURCE_PACKAGE = "llvm-toolchain-20"
HOMEPAGE = "https://www.llvm.org/"

inherit dpkg-prebuilt

DPKG_ARCH = "all"
SRC_URI = " \
    ${REPO_LLVM}/pool/llvm_20/l/llvm-toolchain-20/libclc-20_20.1.8~++20250809043815+87f0227cb601-1~exp1~20250809163919.3_all.deb;name=deb0 \
"

SRC_URI[deb0.md5sum] = "12ff52305a72194c4918f56fce9cacae"
SRC_URI[deb0.sha1sum] = "99fd6beea30807792af146113daa7cf90fb5c346"
SRC_URI[deb0.sha256sum] = "a4d5e938090d4dfa3bb4250cc9b1a12364484d717a6c3577f69a5db49da82b1c"
SRC_URI[deb0.sha512sum] = "488260ed712994afa6df5e975290306de1f956c674f06c623313fb503017a501979bdcc77bc5c85e594d49ea3e289a5ce466260e9ff3b1b72e8f16e56b51caef"

RDEPENDS = " \
    libclang-common-20-dev \
    libclc-20-dev \
"

RPROVIDES = " \
    libclc-x.y \
"
