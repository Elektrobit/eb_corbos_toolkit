# This was autogenerated! Do not modify
SUMMARY = "C++ interface to the Clang library"
DESCRIPTION = "Clang project is a C, C++, Objective C and Objective C++ front-end \
based on the LLVM compiler. Its goal is to offer a replacement to the \
GNU Compiler Collection (GCC). \
 \
Clang implements all of the ISO C++ 1998, 11, 14 and 17 standards and also \
provides most of the support of C++20. \
 \
This package contains the Clang C++ library. \
 \
The C++ Interface to Clang provides an API that exposes \
facilities for parsing source code into an abstract syntax tree (AST), \
loading already-parsed ASTs, traversing the AST, associating physical source \
locations with elements within the AST, and other facilities that support \
Clang-based development tools."
SECTION = "libs"
SOURCE_PACKAGE = "llvm-toolchain-20"
HOMEPAGE = "https://www.llvm.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_LLVM}/pool/llvm_20/l/llvm-toolchain-20/libclang-cpp20_20.1.8~++20250809043815+87f0227cb601-1~exp1~20250809163919.3_amd64.deb;name=deb0 \
    ${REPO_LLVM}/pool/llvm_20/l/llvm-toolchain-20/libclang-cpp20_20.1.8~++20250809043815+87f0227cb601-1~exp1~20250809163919.3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "38951da64f772939c20c889237c294ee"
SRC_URI[deb0.sha1sum] = "c30ed66eba2e111078dea983545ed9d2076cf07d"
SRC_URI[deb0.sha256sum] = "7148d287471537734aa7a653adccee5d34134f556e7791704fca96467c8e5b54"
SRC_URI[deb0.sha512sum] = "29d94a68cb0f0a3a807d6f49ec9b5fcc12e4ab9830609b9d9902ebc9c2cb1d43b10f8fecd83343de7a7555e7c1001d7adb5edcac606871bc43d105788959c483"
SRC_URI[deb1.md5sum] = "ee93ac9d70e206b25e0a16d48bdd1d7f"
SRC_URI[deb1.sha1sum] = "33e21a54a0e9588476022fb56984c0aad580a64e"
SRC_URI[deb1.sha256sum] = "9445766d02240b71c2556545560f4cb997cf5d587c3480c79c476113492f5d73"
SRC_URI[deb1.sha512sum] = "15f0ba578a5679f71f4637397e102aca0fd4a2eb235f05711f597160caa8dbbb887ed5a2689dc13e795dd740eed8e4cb962f21da48557ff1200e25c6dc72cbe3"

RDEPENDS = " \
    libc6 \
    libgcc-s1 \
    libllvm20 \
    libstdc++6 \
"

