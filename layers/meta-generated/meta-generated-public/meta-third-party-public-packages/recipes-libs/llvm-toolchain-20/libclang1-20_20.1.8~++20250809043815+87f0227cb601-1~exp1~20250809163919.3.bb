# This was autogenerated! Do not modify
SUMMARY = "C interface to the Clang library"
DESCRIPTION = "Clang project is a C, C++, Objective C and Objective C++ front-end \
based on the LLVM compiler. Its goal is to offer a replacement to the \
GNU Compiler Collection (GCC). \
 \
Clang implements all of the ISO C++ 1998, 11, 14 and 17 standards and also \
provides most of the support of C++20. \
 \
This package contains the Clang library. \
 \
The C Interface to Clang provides a relatively small API that exposes \
facilities for parsing source code into an abstract syntax tree (AST), \
loading already-parsed ASTs, traversing the AST, associating physical source \
locations with elements within the AST, and other facilities that support \
Clang-based development tools."
SECTION = "libs"
SOURCE_PACKAGE = "llvm-toolchain-20"
HOMEPAGE = "https://www.llvm.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_LLVM}/pool/llvm_20/l/llvm-toolchain-20/libclang1-20_20.1.8~++20250809043815+87f0227cb601-1~exp1~20250809163919.3_amd64.deb;name=deb0 \
    ${REPO_LLVM}/pool/llvm_20/l/llvm-toolchain-20/libclang1-20_20.1.8~++20250809043815+87f0227cb601-1~exp1~20250809163919.3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "94b80b1013a2ad331e66628319581ff7"
SRC_URI[deb0.sha1sum] = "25b9831811c8b91194198c388ab451003551ea1c"
SRC_URI[deb0.sha256sum] = "326dfda8a2d7972cab83675b9d7e3b22bad9ef64e7071f4c76b63d826ae1a037"
SRC_URI[deb0.sha512sum] = "419e77f3a6d4ee09cccae93a7a1f30bdf7223ed7bf9b410720fdb57a5a663e0a3dd57452c013652eb2c3f0365c50003b21885cc8e38195131d6463b01aec365e"
SRC_URI[deb1.md5sum] = "842c24dd3602dbb091a0cf11462fa8e0"
SRC_URI[deb1.sha1sum] = "9d3b4816beeb3bb17a53f289daa073ad7a3d3158"
SRC_URI[deb1.sha256sum] = "759f77ecf2b13a5b4ad3b9e1283770546ded4434dd2316616ca2e7a96c844cae"
SRC_URI[deb1.sha512sum] = "a73c31e05ae8a603121cbcce2acc96003b7b764b6e8b575f59a6b9fe8067834ac558640274d71a0f97ff18ec9859d9c063f9bb74fb67aa0dc4d917c2262022df"

RDEPENDS = " \
    libc6 \
    libgcc-s1 \
    libllvm20 \
    libstdc++6 \
"

