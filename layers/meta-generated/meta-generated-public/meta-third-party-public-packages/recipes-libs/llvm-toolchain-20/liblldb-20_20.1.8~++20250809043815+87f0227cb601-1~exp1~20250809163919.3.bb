# This was autogenerated! Do not modify
SUMMARY = "Next generation, high-performance debugger, library"
DESCRIPTION = "LLDB is a next generation, high-performance debugger. It is built as a set of \
reusable components which highly leverage existing libraries in the larger LLVM \
Project, such as the Clang expression parser and LLVM disassembler. \
 \
This package contains the LLDB runtime library."
SECTION = "libs"
SOURCE_PACKAGE = "llvm-toolchain-20"
HOMEPAGE = "https://www.llvm.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_LLVM}/pool/llvm_20/l/llvm-toolchain-20/liblldb-20_20.1.8~++20250809043815+87f0227cb601-1~exp1~20250809163919.3_amd64.deb;name=deb0 \
    ${REPO_LLVM}/pool/llvm_20/l/llvm-toolchain-20/liblldb-20_20.1.8~++20250809043815+87f0227cb601-1~exp1~20250809163919.3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "601dd592b672c51162bc48c0026add36"
SRC_URI[deb0.sha1sum] = "3529adef7026e8ca1c20d9772df2184d8d779708"
SRC_URI[deb0.sha256sum] = "d87d1faae01d5f976aaa7c6f3758257d4505cfe288f628ad86262e4482bbd8dc"
SRC_URI[deb0.sha512sum] = "de0889643c01033b583752c05cb2b001d1a2193ecf53a01bd82f5b2be2eece835fb247fb1ad2459ab92140fe384b2903b1a41e0d046fb3313902cf6c9be47bb0"
SRC_URI[deb1.md5sum] = "28d80333b029d112815da67eeb0753fe"
SRC_URI[deb1.sha1sum] = "a2999e1784c3a4942b57e90bb665d4e2b40cf4bf"
SRC_URI[deb1.sha256sum] = "4b4378908d2c16e285097913d6c07d36cd81a76d785a1362fb75a343b6b4ac9d"
SRC_URI[deb1.sha512sum] = "a3cfc35ac90300ca6cdbb524949b83953d7d621f36e1104a51813fc123c805d04e46575157420b58364cc31b5615cb458b1cb82826488a66fecf35946884c42b"

RDEPENDS = " \
    libc6 \
    libclang-cpp20 \
    libcurl4t64 \
    libedit2 \
    libgcc-s1 \
    libllvm20 \
    libncurses6 \
    libpython3.13 \
    libstdc++6 \
    libtinfo6 \
    libxml2 \
    zlib1g \
"
RDEPENDS:append:amd64 = " \
    libipt2 \
"

