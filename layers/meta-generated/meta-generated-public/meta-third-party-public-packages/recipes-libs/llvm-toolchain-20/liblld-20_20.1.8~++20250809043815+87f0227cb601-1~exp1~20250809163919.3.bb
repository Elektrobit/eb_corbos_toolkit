# This was autogenerated! Do not modify
SUMMARY = "LLVM-based linker, library"
DESCRIPTION = "LLD is a new, high-performance linker. It is built as a set of reusable \
components which highly leverage existing libraries in the larger LLVM \
Project. \
 \
This package contains the LLD runtime library."
SECTION = "libs"
SOURCE_PACKAGE = "llvm-toolchain-20"
HOMEPAGE = "https://www.llvm.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_LLVM}/pool/llvm_20/l/llvm-toolchain-20/liblld-20_20.1.8~++20250809043815+87f0227cb601-1~exp1~20250809163919.3_amd64.deb;name=deb0 \
    ${REPO_LLVM}/pool/llvm_20/l/llvm-toolchain-20/liblld-20_20.1.8~++20250809043815+87f0227cb601-1~exp1~20250809163919.3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "d967166d7ef1273be370f83f0e342808"
SRC_URI[deb0.sha1sum] = "e81185a6f3068c838f2ffb9f8b76cb785d95dd15"
SRC_URI[deb0.sha256sum] = "5018171c96c813925dc691ced420dbccd63628da1c35c83b3497c39392b4976a"
SRC_URI[deb0.sha512sum] = "299b94d9e65503db3705d94f268cadb5355dd8eeef3c188a12ba21890512104b8c2391228fc9418df908ae6669b6fae676f2716927b143bc2961c38bc3038814"
SRC_URI[deb1.md5sum] = "7830b1c1686186dcc6da77c2ed09297e"
SRC_URI[deb1.sha1sum] = "3eef2b384cd7474dea671d65f117acb158b0e4bc"
SRC_URI[deb1.sha256sum] = "2d4e492e298a2d03dff8a53e778b34525bb754e0f11589df9f4f611d0b97389b"
SRC_URI[deb1.sha512sum] = "5366ef5d4effd1ef80db7e672facfe0cad6fc1e13bd92f0866d4e34a090021918928aee74e8581411ad5f7e76cd0053e6dc66dc4827ebb09f5ee15f6e9eee626"

RDEPENDS = " \
    libllvm20 \
"

