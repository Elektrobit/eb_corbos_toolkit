# This was autogenerated! Do not modify
SUMMARY = "LLVM C++ Standard library"
DESCRIPTION = "libc++ is another implementation of the C++ standard library. \
 \
Features and Goals \
 \
  * Correctness as defined by the C++ standards. \
  * Fast execution. \
  * Minimal memory use. \
  * Fast compile times. \
  * ABI compatibility with gcc's libstdc++ for some low-level features such \
    as exception objects, rtti and memory allocation. \
  * Extensive unit tests."
SECTION = "libs"
SOURCE_PACKAGE = "llvm-toolchain-20"
HOMEPAGE = "https://www.llvm.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_LLVM}/pool/llvm_20/l/llvm-toolchain-20/libc++1_20.1.8~++20250809043815+87f0227cb601-1~exp1~20250809163919.3_amd64.deb;name=deb0 \
    ${REPO_LLVM}/pool/llvm_20/l/llvm-toolchain-20/libc++1_20.1.8~++20250809043815+87f0227cb601-1~exp1~20250809163919.3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "b1120023cfcc92e5a9a9b366d0061a23"
SRC_URI[deb0.sha1sum] = "5d22ea0d185c65cdd914a00e794a9cfd5162a8d3"
SRC_URI[deb0.sha256sum] = "deb15e0c657e2d62ca2418d3696ac2828f3fc368daf720c70134c3e4cc5e227f"
SRC_URI[deb0.sha512sum] = "3d9173612d6106ffa4dd4a052aef1fbfcc85d0018521b58761d1f7bc0ecf3feecc9ce902e692947b3ba74ff0f0b17ea427e32f405a213cb460df03be1a9d5842"
SRC_URI[deb1.md5sum] = "21c29adabf18418524d86d6d5b4e3c35"
SRC_URI[deb1.sha1sum] = "0f00208f66d668d98f676daf804ab631fd364522"
SRC_URI[deb1.sha256sum] = "faccc8c91420e87950a4e34b8c3073c2f63a40baf5522342457914e0cd1dd517"
SRC_URI[deb1.sha512sum] = "ef23efee2db262a1aefcfa0a83a8827fdcb67f67843d2517dc7419a0ba40749381c0f122b068a90d82d9dbef15a1f8dc089a7c2d7cc43427276305f2a695af13"

RDEPENDS = " \
    libc++abi1 \
    libc6 \
    libunwind \
"

RPROVIDES = " \
    libc++-x.y \
"
