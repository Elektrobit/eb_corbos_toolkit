# This was autogenerated! Do not modify
SUMMARY = "production-quality unwinder"
DESCRIPTION = "libunwind is a production-quality unwinder, with platform support for DWARF \
unwind info, SjLj, and ARM EHABI. \
 \
The low level libunwind API was designed to work either in-process (aka local) \
or to operate on another process (aka remote), but only the local path has \
been implemented. Remote unwinding remains as future work."
SECTION = "libs"
SOURCE_PACKAGE = "llvm-toolchain-20"
HOMEPAGE = "https://www.llvm.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_LLVM}/pool/llvm_20/l/llvm-toolchain-20/libunwind_20.1.8~++20250809043815+87f0227cb601-1~exp1~20250809163919.3_amd64.deb;name=deb0 \
    ${REPO_LLVM}/pool/llvm_20/l/llvm-toolchain-20/libunwind_20.1.8~++20250809043815+87f0227cb601-1~exp1~20250809163919.3_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "4db41945c9dc23681e11ffe9106b51c1"
SRC_URI[deb0.sha1sum] = "d1f002f8a81816aab179ccbb7d09450e7f11b3e5"
SRC_URI[deb0.sha256sum] = "981f93ca99da5b31bef9c7d43bbe745116e4da50bf606a389a187c3d4aa9bbf3"
SRC_URI[deb0.sha512sum] = "284ef34b51b0ed8d437d3df1c9deb695db50f8df9138d4aa448b4d5907d7cbb9c229539b6653146034b9beaeeac00231aada345b598922cb3634c29f686f97ec"
SRC_URI[deb1.md5sum] = "fbf5225c7cd53e52117cdcf0f2fe225d"
SRC_URI[deb1.sha1sum] = "e50ab6cc93b4e0c7bf6b6e8d50fc9716f3c3303d"
SRC_URI[deb1.sha256sum] = "70ec97bc93dad3782def46c49d404b64c67f3a869bbad73473f843618e578dae"
SRC_URI[deb1.sha512sum] = "7eeeb08676142fc58480ded73ed9e6e5fda292e5c3f17206455d8f9dbf3f14485ddf051aca95fc1576e1b35feee0998a3414a537eb76822403ff3f497bc9f9e6"

RDEPENDS = " \
    libc6 \
"

RPROVIDES = " \
    libunwind-x.y \
"
