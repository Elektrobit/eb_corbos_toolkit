# Break circular dependency
RDEPENDS:remove = "libheif1"
