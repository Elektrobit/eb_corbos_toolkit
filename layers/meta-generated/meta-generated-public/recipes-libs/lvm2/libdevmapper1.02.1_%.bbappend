# Break circular dependency
RDEPENDS:remove = "dmsetup"
