# Break circular dependency
RDEPENDS:remove = "libgcc-s1"
