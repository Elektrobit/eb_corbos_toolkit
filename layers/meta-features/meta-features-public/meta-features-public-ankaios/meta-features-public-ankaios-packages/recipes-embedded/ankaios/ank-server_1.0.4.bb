# This was autogenerated! Do not modify
SUMMARY = "Server application of Eclipse Ankaios"
DESCRIPTION = "Eclipse Ankaios provides workload and container orchestration for automotive \
High Performance Computing Platforms (HPCs). It offers a slim yet powerful \
solution to manage containerized applications across multiple nodes and \
virtual machines via a single API. \
 \
This package contains the Ankaios server, which acts as the central control \
point for managing workloads running on connected Ankaios agents."
SECTION = "embedded"
SOURCE_PACKAGE = "ankaios"
HOMEPAGE = "https://github.com/eclipse-ankaios/ankaios"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_ANKAIOS_APT}/pool/a/ank-server/ank-server_1.0.4_amd64.deb;name=deb0 \
    ${REPO_ANKAIOS_APT}/pool/a/ank-server/ank-server_1.0.4_arm64.deb;name=deb1 \
"

SRC_URI[deb0.sha1sum] = "cf5f54a9cd3752e4ac6f1e9619b460fb268cb9e6"
SRC_URI[deb0.sha256sum] = "e1b3a63e21af691ecfca6a9629886048c675757c0d33ed7f4a62ed66fae2939e"
SRC_URI[deb1.sha1sum] = "fde5564a6f63c6bda5e0b9f09e72ad74afedde10"
SRC_URI[deb1.sha256sum] = "1d0935d70d8b1df245d7027cab5ffd798f6cf8affcdc97a6863b42da7f653652"

RDEPENDS = " \
    libc6 \
    libgcc-s1 \
"

