# This was autogenerated! Do not modify
SUMMARY = "Agent application of Eclipse Ankaios"
DESCRIPTION = "Eclipse Ankaios provides workload and container orchestration for automotive \
High Performance Computing Platforms (HPCs). It offers a slim yet powerful \
solution to manage containerized applications across multiple nodes and \
virtual machines via a single API. \
 \
This package contains the Ankaios agent, which acts as an intermediate \
between the server and the workloads, being responsible with managing \
the workloads that are registered under it."
SECTION = "embedded"
SOURCE_PACKAGE = "ankaios"
HOMEPAGE = "https://github.com/eclipse-ankaios/ankaios"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_ANKAIOS_APT}/pool/a/ank-agent/ank-agent_1.0.4_amd64.deb;name=deb0 \
    ${REPO_ANKAIOS_APT}/pool/a/ank-agent/ank-agent_1.0.4_arm64.deb;name=deb1 \
"

SRC_URI[deb0.sha1sum] = "cab922bb253c4f6f2ebfb670d10d15ac2ca2ba06"
SRC_URI[deb0.sha256sum] = "74500506b2b39cfe8ac158adf70ee37ebabb1a00d75a81067b25c98b6c0f222b"
SRC_URI[deb1.sha1sum] = "1ea74f3ae5cae256e3e44959ff033f0a9fb29253"
SRC_URI[deb1.sha256sum] = "5338d1a39e5da107b26f94477569af2daa38cede91388676662d4a50de4cf46e"

RDEPENDS = " \
    libc6 \
    libgcc-s1 \
"

