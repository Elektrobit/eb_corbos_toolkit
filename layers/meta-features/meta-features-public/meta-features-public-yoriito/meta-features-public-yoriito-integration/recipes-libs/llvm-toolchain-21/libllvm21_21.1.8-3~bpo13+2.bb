# Copyright 2026 Elektrobit. All rights reserved.

# This was autogenerated! Do not modify
SUMMARY = "Modular compiler and toolchain technologies, runtime library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "llvm-toolchain-21"
HOMEPAGE = "https://www.llvm.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_YORIITO_DEBIAN_UPSTREAM_APT}/pool/main/l/llvm-toolchain-21/libllvm21_21.1.8-3~bpo13+2_amd64.deb;name=deb0 \
    ${REPO_YORIITO_DEBIAN_UPSTREAM_APT}/pool/main/l/llvm-toolchain-21/libllvm21_21.1.8-3~bpo13+2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "3e910f8aedfdff9308bd5b6c71c3b661"
SRC_URI[deb0.sha1sum] = "862ea0da64f5210ec243d39ca91ed6a91004e7bf"
SRC_URI[deb0.sha256sum] = "a1e531b0470c5f09abce9812f23960841b1bf9464cdad40d650fb98415e6bc51"
SRC_URI[deb0.sha512sum] = "93c70c411db320b7ba1223eb65622049c65c49230eadb49eb258211143e46798c74bb22a7c576e3c9d616b331482e4d74d6a592278c2fab94b4df3a5b121aa01"
SRC_URI[deb1.md5sum] = "85d54d3bc385122a3b738b337b76d0df"
SRC_URI[deb1.sha1sum] = "b982c2ea6c1a8f08a05c77045d64c76d12bd5e98"
SRC_URI[deb1.sha256sum] = "027ddc62010bc8ebc0c5a65a7839f7ffd9c18411a2c466ed66eaf806e71960e7"
SRC_URI[deb1.sha512sum] = "e0a490a7fa619030c10b60fc97cc69e06f38ab13a1dd60d3b28f94ff8943cb9dd8d02d929047e60b3f8bef42bf4083b5034a4de358d51a8b665bcb70ed3d5937"

RDEPENDS = " \
    libc6 \
    libedit2 \
    libffi8 \
    libgcc-s1 \
    libstdc++6 \
    libxml2 \
    libz3-4 \
    libzstd1 \
    zlib1g \
"
