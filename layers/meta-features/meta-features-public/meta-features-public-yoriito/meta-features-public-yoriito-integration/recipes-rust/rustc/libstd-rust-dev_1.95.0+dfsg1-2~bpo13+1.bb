# Copyright 2026 Elektrobit. All rights reserved.

# This was autogenerated! Do not modify
SUMMARY = "Rust standard libraries - development files"
DESCRIPTION = ""
SECTION = "rust"
SOURCE_PACKAGE = "rustc"
HOMEPAGE = "http://www.rust-lang.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_YORIITO_DEBIAN_UPSTREAM_APT}/pool/main/r/rustc/libstd-rust-dev_1.95.0+dfsg1-2~bpo13+1_amd64.deb;name=deb0 \
    ${REPO_YORIITO_DEBIAN_UPSTREAM_APT}/pool/main/r/rustc/libstd-rust-dev_1.95.0+dfsg1-2~bpo13+1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "d1c6d06313fc7f7142d9ee9e6651ca05"
SRC_URI[deb0.sha1sum] = "76391d72decec93fd270f27c3db143c191310527"
SRC_URI[deb0.sha256sum] = "abf2ded071ebf9e0ebb4364592b94bafd28391ed0ab39df4e2b826dedcf5819d"
SRC_URI[deb0.sha512sum] = "cab6b72bd82314956fe1d69d41517921d187d47e06c5035004d9a785c1ec9693666314c02451d7eb6c1c588f89b5e66177b5302088cfa7254e1e4c0be1b3dc50"
SRC_URI[deb1.md5sum] = "ad52d612a3a6c66f023577efa8eced00"
SRC_URI[deb1.sha1sum] = "f9329cc651711d990d6f9b53a578d59d67c04ccb"
SRC_URI[deb1.sha256sum] = "6fa1445b7d4960768ca61107ea8d07fdd5982d788cf6f42709562a733be0201a"
SRC_URI[deb1.sha512sum] = "3f13c36fa5dff8dd1650874c3e7a9494893c93739a8a4ef28854ef3a195fd8151895aeec906193ce59a498462e276fb1db4e1347beafd88d0c6c8aaf734c0f20"

RDEPENDS = " \
    libstd-rust-1.95 \
"
