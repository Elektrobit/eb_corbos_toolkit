# Copyright 2026 Elektrobit. All rights reserved.

# This was autogenerated! Do not modify
SUMMARY = "Rust standard libraries"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "rustc"
HOMEPAGE = "http://www.rust-lang.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_YORIITO_DEBIAN_UPSTREAM_APT}/pool/main/r/rustc/libstd-rust-1.95_1.95.0+dfsg1-2~bpo13+1_amd64.deb;name=deb0 \
    ${REPO_YORIITO_DEBIAN_UPSTREAM_APT}/pool/main/r/rustc/libstd-rust-1.95_1.95.0+dfsg1-2~bpo13+1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "47dedec18e50d14c33dd0507fcec2364"
SRC_URI[deb0.sha1sum] = "e78542610b5279a7ba552a699cc2ebdbb802e5c8"
SRC_URI[deb0.sha256sum] = "824d775efc241f8b01952b567ff4ba5edee9d667751953c9b7e7be5b76aa121c"
SRC_URI[deb0.sha512sum] = "ad61c204f71e4be6585bfd0c73471b3c534ca58118b0de6a24cdeccfa3a4b521fb427da31040244617c0bbd7fd52018d2d5aeb77bf64da3acf3ca471c2ddc6c3"
SRC_URI[deb1.md5sum] = "f9674b81b5a1092048e0e4143041a2ed"
SRC_URI[deb1.sha1sum] = "a540d1634d11e39ca8744fcad93d0636e17d5b9d"
SRC_URI[deb1.sha256sum] = "c4dcef225b990e11c98c1842f1dbc682f1b1aabe06cc105664e090152e47cb4f"
SRC_URI[deb1.sha512sum] = "7ceeb5dc3349826b5a5851ceb22e64713f46a4a3786c4bc5d079ed8da2b1773067f70d85702b695e84a43af77476e023640dac5f7776bd37d34fb0f7f8a2755b"

RDEPENDS = " \
    libc6 \
    libgcc-s1 \
    libllvm21 \
    libstdc++6 \
"
