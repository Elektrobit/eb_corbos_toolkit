# Copyright 2026 Elektrobit. All rights reserved.

# This was autogenerated! Do not modify
SUMMARY = "Rust package manager"
DESCRIPTION = ""
SECTION = "rust"
SOURCE_PACKAGE = "rustc"
HOMEPAGE = "http://www.rust-lang.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_YORIITO_DEBIAN_UPSTREAM_APT}/pool/main/r/rustc/cargo_1.95.0+dfsg1-2~bpo13+1_amd64.deb;name=deb0 \
    ${REPO_YORIITO_DEBIAN_UPSTREAM_APT}/pool/main/r/rustc/cargo_1.95.0+dfsg1-2~bpo13+1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "3c8492c39492814dc1b88bf4391ad25c"
SRC_URI[deb0.sha1sum] = "ee84bcabd5a148ff75e1ecc2bd2f699b7b644595"
SRC_URI[deb0.sha256sum] = "93824a50ae21c1321581883c187407abdbaa6cf02498ae8c5e5ff98bbf0835ff"
SRC_URI[deb0.sha512sum] = "c9d5c4eb9ad1cd562bfb104c97d35ae4b44f4f7a0ce857a8dca8b72b26f08341fc6402d6b39255f23ca4bfa87e5dd931bba65602d738521d1ec4d74f8205465b"
SRC_URI[deb1.md5sum] = "6b144c5127be5962384b444a590074fc"
SRC_URI[deb1.sha1sum] = "0f21b080600e4e8ed47aa80d1980f1800250bab5"
SRC_URI[deb1.sha256sum] = "e76e5e7c1f42a4ee72d9ee90114dc834e407b3640700302ef86da3c30dd28e25"
SRC_URI[deb1.sha512sum] = "99d70e445402b327ce24fc96d09ce7a981670263afa5236672e48f96b6b7ebf20baf2e12aeb18fc75232d70663e5b9cf2ca5f02c345d3a5e787e59aa50123f87"

RDEPENDS = " \
    binutils \
    gcc \
    libc6 \
    libcurl4t64 \
    libgcc-s1 \
    libgit2-1.9 \
    libsqlite3-0 \
    libssh2-1t64 \
    libssl3t64 \
    rustc \
    zlib1g \
"
