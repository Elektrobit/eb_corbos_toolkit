# This was autogenerated! Do not modify
SUMMARY = "protocol buffers compiler library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "protobuf"
HOMEPAGE = "https://github.com/google/protobuf/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/protobuf/libprotoc32t64_3.21.12-11+deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/protobuf/libprotoc32t64_3.21.12-11+deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "b646e4966af741009a6e00c60ad89dfc"
SRC_URI[deb0.sha1sum] = "2a1daf74d3e7623349249e3132bbf9651353aecb"
SRC_URI[deb0.sha256sum] = "8a96715498f10f8e166411248164448c9a892fa1d5b25f1e02a93ea668fa72aa"
SRC_URI[deb0.sha512sum] = "2a82b71f3b0e03bb5f3ef687d85c4bf4662c20856feb615761352aded11126263bbc75bc0d4b0d4a485d11204b43bc7fe21785a5a5c08ec1e9dc05914d5595ac"
SRC_URI[deb1.md5sum] = "61b53133354473abace6fa7aa371eebe"
SRC_URI[deb1.sha1sum] = "4df67b8a97c3df4dfdf742b97a79fa27a10fae74"
SRC_URI[deb1.sha256sum] = "0cf431ed1f7d48d6acd52e1532bc3f7c17048a737115dc9eb900edfa7a08ed7a"
SRC_URI[deb1.sha512sum] = "b921ad389f77a360d4b26b365d16e840b281ad15e354b2f506dbf576dbba750c863548e421ed4d042124079da3b7f8b9896439595d2010de7c4c6366bd76d3b1"

RDEPENDS = " \
    libc6 \
    libgcc-s1 \
    libprotobuf32t64 \
    libstdc++6 \
"

RPROVIDES = " \
    libprotoc32 \
"
