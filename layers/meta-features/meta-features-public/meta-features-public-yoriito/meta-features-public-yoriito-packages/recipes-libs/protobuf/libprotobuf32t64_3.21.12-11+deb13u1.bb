# This was autogenerated! Do not modify
SUMMARY = "protocol buffers C++ library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "protobuf"
HOMEPAGE = "https://github.com/google/protobuf/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/protobuf/libprotobuf32t64_3.21.12-11+deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/protobuf/libprotobuf32t64_3.21.12-11+deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "cd5ee755782d8108c277d2949bb9d17f"
SRC_URI[deb0.sha1sum] = "1d7aa021c5e717f2f746f5038057d8dbaa9cfaa4"
SRC_URI[deb0.sha256sum] = "38c43ec79a043d2b2659fed321725049a7e457096a66691cf6eb0d3a1a8f0e85"
SRC_URI[deb0.sha512sum] = "e40cae82a3fc1120865d78aa86f31ac0bb34733dd777df7391349cfe83983619f1bc61e0ae665bc54e6fddcb95c16e7416780d60cca9b520a943e7c8c6e9208f"
SRC_URI[deb1.md5sum] = "adb19474adb6dcad5d770f513e89b92b"
SRC_URI[deb1.sha1sum] = "931847d98f9640b623043ac61df26ac395ba9fbd"
SRC_URI[deb1.sha256sum] = "51bf38fcca667be0deef732a903563ee6ffa9bfc04433310c2c49e4c92d06b09"
SRC_URI[deb1.sha512sum] = "84872f9a3740179d559c1e515f3e8278f50ca72ebbeccb9daf441529c57c1d60c37ae75ac93c52202e693780428588deb03e1279645b55521117cd51c754604c"

RDEPENDS = " \
    libc6 \
    libgcc-s1 \
    libstdc++6 \
    zlib1g \
"

RPROVIDES = " \
    libprotobuf32 \
"
