# This was autogenerated! Do not modify
SUMMARY = "protocol buffers C++ library (lite version)"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "protobuf"
HOMEPAGE = "https://github.com/google/protobuf/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/protobuf/libprotobuf-lite32t64_3.21.12-11+deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/protobuf/libprotobuf-lite32t64_3.21.12-11+deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "8d75321f8231d07bc036c249e1970a07"
SRC_URI[deb0.sha1sum] = "52db6f5803c679d0c830e7f255f83977273603c1"
SRC_URI[deb0.sha256sum] = "74ed82b17475a1411ac79b27bd8b0223b3727d55660f77b8a5f6d5598e2dd7c2"
SRC_URI[deb0.sha512sum] = "cce4f4c57148a95958766d7cfddf3b41a95bdb1848eb0af167b14c0368da4c8e39ab6df8df108ae02d3b2ff053eb7ce64b6a17e38ce57a9508feeeee8b1c0bdb"
SRC_URI[deb1.md5sum] = "a1e246c8b23e7d64d12c45f17679770a"
SRC_URI[deb1.sha1sum] = "5a78dcb1bede20b2a8e6c4a931380fd3eb1eced3"
SRC_URI[deb1.sha256sum] = "576ce2ca95e4aa98e135e02594a950e6381189d8b9702295ab8d505d49a503ad"
SRC_URI[deb1.sha512sum] = "84af0ecc5011fe98e719ef537374e5be8fb3368279d344217599f03c6149632bc8e955c197bd7f64caf4c394b60bd2b4572ca4a66ad0df26ef9a288db9a9e9df"

RDEPENDS = " \
    libc6 \
    libgcc-s1 \
    libstdc++6 \
"

RPROVIDES = " \
    libprotobuf-lite32 \
"
