# This was autogenerated! Do not modify
SUMMARY = "low-level Git library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "libgit2"
HOMEPAGE = "https://libgit2.github.com/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libg/libgit2/libgit2-1.9_1.9.0+ds-2_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/libg/libgit2/libgit2-1.9_1.9.0+ds-2_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "354069e35385293acc8dce5088f72416"
SRC_URI[deb0.sha1sum] = "37b6df3c0dbdc5d9efb748fcd8b68e9a81968806"
SRC_URI[deb0.sha256sum] = "a71f03a76ce040ee990709912b5933d455137f9fa6b267449dd3491ea12b2b60"
SRC_URI[deb0.sha512sum] = "063b089716d0ffc8047fad75d59278f2532585f7061dc076a1b27cfe027c4fb107067943b5307e1dc51c0967bc3de23c1b85a43a5a6abcc297c85621ec6bc122"
SRC_URI[deb1.md5sum] = "117bd506ff5ae3a2ee23cb95f852397e"
SRC_URI[deb1.sha1sum] = "64939a4b35a85abc2a71753f9d964ca8235818c0"
SRC_URI[deb1.sha256sum] = "7d9ed1d96b60cf35eace27f5a74bfd4dc646c0fdea646a30046b1165f73297cf"
SRC_URI[deb1.sha512sum] = "06ca80cfed5e86b2155a512dc92343beb20a5d7c6cf8cb131978d99242a7e0996071d25514bafdc078001b3292b434f981a510e8633a42107e30f915289927cd"

RDEPENDS = " \
    libc6 \
    libgssapi-krb5-2 \
    libhttp-parser2.9 \
    libmbedcrypto16 \
    libmbedtls21 \
    libmbedx509-7 \
    libpcre2-8-0 \
    libssh2-1t64 \
    zlib1g \
"

