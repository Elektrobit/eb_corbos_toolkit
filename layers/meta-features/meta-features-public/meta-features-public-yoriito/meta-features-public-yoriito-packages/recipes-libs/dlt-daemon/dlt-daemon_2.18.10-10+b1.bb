# This was autogenerated! Do not modify
SUMMARY = "Diagnostic Log and Trace logging daemon"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "dlt-daemon"
HOMEPAGE = "https://github.com/COVESA/dlt-daemon"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/d/dlt-daemon/dlt-daemon_2.18.10-10+b1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/d/dlt-daemon/dlt-daemon_2.18.10-10+b1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "0a13f792671178fed708324aa9251fa3"
SRC_URI[deb0.sha1sum] = "05acd7529eb04d57bfa8b7844a5289c27c7016ec"
SRC_URI[deb0.sha256sum] = "f3bafc832a16367ce7cfd56a422fb1168b2aad84f57b1e17e911efaf1808edce"
SRC_URI[deb0.sha512sum] = "fb143b681d6c1e36375b2c7a4078c40773fe1c961f3095be4cd7ababa1aed6c97072cc5757af824e2c3aa67cb1785b741dbad0ec3b1c1faf9035f2710d7cb061"
SRC_URI[deb1.md5sum] = "56d272c40327a9ea2eb9e91072bd519b"
SRC_URI[deb1.sha1sum] = "cab3b217f298678210111ca472534c43656d8230"
SRC_URI[deb1.sha256sum] = "b382881dbdfede00b262e9e1f97c36fddbd89be95e0af8e6bda91914c147d341"
SRC_URI[deb1.sha512sum] = "1f019da178d4aa8689325735fa047d11bbcc382452080df0128c75720effa10da6bd74fa143bf15039233e30687cf4b6d2cf2f9497fa1f0a2329612a585d1277"

RDEPENDS = " \
    adduser \
    libc6 \
    zlib1g \
"

