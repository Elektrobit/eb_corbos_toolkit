# This was autogenerated! Do not modify
SUMMARY = "Diagnostic Log and Trace (DLT) library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "dlt-daemon"
HOMEPAGE = "https://github.com/COVESA/dlt-daemon"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/d/dlt-daemon/libdlt2_2.18.10-10+b1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/d/dlt-daemon/libdlt2_2.18.10-10+b1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "8c8b3a5849207cdbcfc46f3e9538503f"
SRC_URI[deb0.sha1sum] = "72d850b4adaff02f2459930ab7621f6bcdd0e60c"
SRC_URI[deb0.sha256sum] = "93c5c2a51d0de4bbaa0a7d2c457d8719bbcb73a1d74210f83f243b55b78aec31"
SRC_URI[deb0.sha512sum] = "626ab38eeb2a3060d363fa518172601e3dec0dc8bfcb70be962e0e3b8f753ba916c0444c41f45f0ee31963090d41a564d7a4d3e099f37bca5396fd0428b57daa"
SRC_URI[deb1.md5sum] = "cf608a35fefba89a1fe34c14ee5e2fb3"
SRC_URI[deb1.sha1sum] = "1f40521e693988c713771dc132a6eb0c75699526"
SRC_URI[deb1.sha256sum] = "e3c98fb15eb7e7aaadc19d580121afce6bf1c802b0ac71c854e27447983c2658"
SRC_URI[deb1.sha512sum] = "05b12a4e04ba87c7ab7222828fb7069efccb5f95c656117b1bb751e7f2e6b268ca7a4e49541720966faac52f15ba8d1af0cf1ea3b47b8fb745e591b4f1b98441"

RDEPENDS = " \
    libc6 \
"

