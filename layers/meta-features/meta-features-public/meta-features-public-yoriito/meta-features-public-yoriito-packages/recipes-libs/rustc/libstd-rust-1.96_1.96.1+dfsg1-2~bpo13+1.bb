# This was autogenerated! Do not modify
SUMMARY = "Rust standard libraries"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "rustc"
HOMEPAGE = "http://www.rust-lang.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_DEBIAN_TRIXIE_BACKPORTS}/pool/main/r/rustc/libstd-rust-1.96_1.96.1+dfsg1-2~bpo13+1_amd64.deb;name=deb0 \
    ${REPO_DEBIAN_TRIXIE_BACKPORTS}/pool/main/r/rustc/libstd-rust-1.96_1.96.1+dfsg1-2~bpo13+1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.sha256sum] = "672f77948e7db14acd9b331a1f880f6d998106f8ecefd3f03adcf0be5b18017f"
SRC_URI[deb1.sha256sum] = "604b9597df37854c151dd715ae7907e38b92519299228f5abb7a70f317bc21d4"

RDEPENDS = " \
    libc6 \
    libgcc-s1 \
    libllvm22 \
    libstdc++6 \
"

