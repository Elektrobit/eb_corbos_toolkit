# This was autogenerated! Do not modify
SUMMARY = "efficient, principled regular expression library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "re2"
HOMEPAGE = "https://github.com/google/re2"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/r/re2/libre2-11_20240702-3+b1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/r/re2/libre2-11_20240702-3+b1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "08a5f30db32ee9bf7253639e48bc995c"
SRC_URI[deb0.sha1sum] = "407813ed6c66a741542941843156632c161cf9fe"
SRC_URI[deb0.sha256sum] = "128136b987e90b41d1ace03348fcf42fbfb9fec8bb9294332b13eaeadfec4062"
SRC_URI[deb0.sha512sum] = "b22810095559f9ef1ed1f6800fecf85373e065427e95cebfa7c1020a8683e4ceb17549fe2298c568311eb527d50a65ed1aa92fd6ced83e72f09196175e8a4841"
SRC_URI[deb1.md5sum] = "9ed123c70a5006bfe666d49e12fc22fd"
SRC_URI[deb1.sha1sum] = "09d2cb4122b182521340aab55ec7248405779b0c"
SRC_URI[deb1.sha256sum] = "7a09b3125b8dacac1a6d8c96e419cd38da5848e48f082b6e54891c5dda00e004"
SRC_URI[deb1.sha512sum] = "f4262f672e0379fbc9007ef77deb735e1908a78aee29857546cafc674a5686f638af5611532c98d4ba7eb4ee64eebef888e529f4cafc7739b246e0ac0bebc6ff"

RDEPENDS = " \
    libabsl20240722 \
    libc6 \
    libgcc-s1 \
    libstdc++6 \
"

RPROVIDES = " \
    libre2-11-absl20240722 \
"
