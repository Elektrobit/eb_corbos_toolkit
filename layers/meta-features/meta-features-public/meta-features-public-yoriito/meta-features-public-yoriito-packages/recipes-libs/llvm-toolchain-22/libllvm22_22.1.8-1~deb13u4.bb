# This was autogenerated! Do not modify
SUMMARY = "Modular compiler and toolchain technologies, runtime library"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "llvm-toolchain-22"
HOMEPAGE = "https://www.llvm.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_DEBIAN_TRIXIE}/pool/main/l/llvm-toolchain-22/libllvm22_22.1.8-1~deb13u4_amd64.deb;name=deb0 \
    ${REPO_DEBIAN_TRIXIE}/pool/main/l/llvm-toolchain-22/libllvm22_22.1.8-1~deb13u4_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "289f9cd05ba1a558f33b021538bd7162"
SRC_URI[deb0.sha256sum] = "4efe6a50efdf239925e27941d53b13b9113f00af7eb2fbd6bfc53e5fec1eb954"
SRC_URI[deb1.md5sum] = "b1b55cf58be5514ef3c021201f662818"
SRC_URI[deb1.sha256sum] = "072f7d7f01a96efff8ed987dd8de80e02d8fa408438ed6b005dd426ad78f10c6"

RDEPENDS = " \
    libc6 \
    libedit2 \
    libffi8 \
    libgcc-s1 \
    libstdc++6 \
    libxml2 \
    libz3-4 \
    libzstd1 \
    zlib1g \
"

