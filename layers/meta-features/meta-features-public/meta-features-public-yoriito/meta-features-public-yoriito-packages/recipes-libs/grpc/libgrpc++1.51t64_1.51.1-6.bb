# This was autogenerated! Do not modify
SUMMARY = "high performance general RPC framework"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "grpc"
HOMEPAGE = "https://www.grpc.io/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/grpc/libgrpc++1.51t64_1.51.1-6_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/grpc/libgrpc++1.51t64_1.51.1-6_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "29be3d6ffc3cd2b89888b0eeaaafe669"
SRC_URI[deb0.sha1sum] = "85ede3f2b83e1ca865bd3cde274168b46e2a2b33"
SRC_URI[deb0.sha256sum] = "af6c139e11d81f828e4e57cc027aeffe3379d3516586408d7fd88a98b1b26ed9"
SRC_URI[deb0.sha512sum] = "942fb932d06b57fe34c1118d8f349f92670dedace5d9985aeedf8a469cfe5df5ee07c5f8403008be2b1337963191d68c0814eeea7b1388c11b5a9c831f7ce1ab"
SRC_URI[deb1.md5sum] = "ad8f2c6ca8974d6d98df11421e918b65"
SRC_URI[deb1.sha1sum] = "077b93f1512744861ee1dea574c4e547d490da7c"
SRC_URI[deb1.sha256sum] = "19e510304dadf3fcc561a3925bbcbff7267c375869349b2b4d7ada650f6e2a23"
SRC_URI[deb1.sha512sum] = "bf11b588af14bd712706ab3f3fcec5e9006ff1e311347bd438501aefd53c283754ad2c01da634d4c657d9566e0e6565989e4b9b76d954fcd58289e8cff8ee664"

RDEPENDS = " \
    libabsl20240722 \
    libc6 \
    libgcc-s1 \
    libgrpc29t64 \
    libprotobuf32t64 \
    libstdc++6 \
"

RPROVIDES = " \
    libgrpc++1.51 \
"
