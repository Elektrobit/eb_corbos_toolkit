# This was autogenerated! Do not modify
SUMMARY = "high performance general RPC framework"
DESCRIPTION = ""
SECTION = "libs"
SOURCE_PACKAGE = "grpc"
HOMEPAGE = "https://www.grpc.io/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/grpc/libgrpc29t64_1.51.1-6_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/grpc/libgrpc29t64_1.51.1-6_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "868f6bc71cce945f8eeeff9203e1cad7"
SRC_URI[deb0.sha1sum] = "4ce04c33e3333385a977f5fd954ccc3595564488"
SRC_URI[deb0.sha256sum] = "8d7dfdca30c13995a76bbbb36a3e4d245056b800c7f23fda8fd80a01b7307fc6"
SRC_URI[deb0.sha512sum] = "8101829bffa3f34712e12c562bee0fb6d9a858344c33223c7281f204134af16bc545c92cb7cdd177d85c1225abbd9eeefa9560b5da5340e3b362274b761dcd1b"
SRC_URI[deb1.md5sum] = "a0f10a8eee969a551e30e50ad112cd93"
SRC_URI[deb1.sha1sum] = "19d2db3b6d3a90bc925b92c0a3a57e2239aec705"
SRC_URI[deb1.sha256sum] = "01ce19bffc10a6eab0f4cc9d5e2e7cdcf86075bbb678179d97b9f10f97db2324"
SRC_URI[deb1.sha512sum] = "01d9ef34197c0eab3a21280b8cc01cb6d44d7c09d5e718fb7833af2869f19938147bf789f38439c20af5a9a250fbe0df5fed85492fd8fb14f9b8ae721f6d7cb3"

RDEPENDS = " \
    libabsl20240722 \
    libc6 \
    libcares2 \
    libgcc-s1 \
    libprotobuf32t64 \
    libprotoc32t64 \
    libre2-11-absl20240722 \
    libssl3t64 \
    libstdc++6 \
    zlib1g \
"

RPROVIDES = " \
    libgrpc29 \
"
