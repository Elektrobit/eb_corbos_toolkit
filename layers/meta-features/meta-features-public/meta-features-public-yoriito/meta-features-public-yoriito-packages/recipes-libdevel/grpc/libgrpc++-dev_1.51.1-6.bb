# This was autogenerated! Do not modify
SUMMARY = "high performance general RPC framework (development)"
DESCRIPTION = ""
SECTION = "libdevel"
SOURCE_PACKAGE = "grpc"
HOMEPAGE = "https://www.grpc.io/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/grpc/libgrpc++-dev_1.51.1-6_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/g/grpc/libgrpc++-dev_1.51.1-6_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "40ba9fd0758d59ee99c9f988f55fb9fd"
SRC_URI[deb0.sha1sum] = "582920a1ee5127ee46e5f68df067e63a59e51816"
SRC_URI[deb0.sha256sum] = "b92acba8691c099306b86469bd88561baa9b787e5aec0ea660ab3d1da2fad12e"
SRC_URI[deb0.sha512sum] = "7e2a2cd185b46eee972681b5ab9ad9e003b2283891b0422f41d49b20da2420ce8e38e6f7d1dd1618ee7376135794cbceb85416a781b149c7e894f7bd63390d02"
SRC_URI[deb1.md5sum] = "75b85c948a10bf71fe367e3ca2d46260"
SRC_URI[deb1.sha1sum] = "ef09cf05fc02bf03ecd0d0a6a7b58b8a232d8bc2"
SRC_URI[deb1.sha256sum] = "350367fa3c04d383941af6540ea2f4f73cf6999aa8db06421b0e25aaaed59cb9"
SRC_URI[deb1.sha512sum] = "51a4aebe32789c624371716bc3ef528dd689f9673757ac3b2c35041ae15392aa0e893328f1afa33deecd50cd823c6d89e03dd09031b8eca08a42c1dc1334a979"

RDEPENDS = " \
    libabsl-dev \
    libc-ares-dev \
    libgrpc++1.51t64 \
    libgrpc-dev \
    libre2-dev \
    libssl-dev \
    pkgconf \
    zlib1g-dev \
"

