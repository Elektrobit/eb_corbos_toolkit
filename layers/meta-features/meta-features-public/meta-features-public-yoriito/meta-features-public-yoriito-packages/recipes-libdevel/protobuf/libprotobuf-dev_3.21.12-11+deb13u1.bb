# This was autogenerated! Do not modify
SUMMARY = "protocol buffers C++ library (development files) and proto files"
DESCRIPTION = ""
SECTION = "libdevel"
SOURCE_PACKAGE = "protobuf"
HOMEPAGE = "https://github.com/google/protobuf/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/protobuf/libprotobuf-dev_3.21.12-11+deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/protobuf/libprotobuf-dev_3.21.12-11+deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "b3de43b29cc9c6394dc0a6518e2a42b6"
SRC_URI[deb0.sha1sum] = "5802289d43d0c7426b69c63d6e3f4119f966a295"
SRC_URI[deb0.sha256sum] = "c0328550b6ccd7b09d4e50bc2b325a43638bf8fa5f74148ab6e63d49af7543f3"
SRC_URI[deb0.sha512sum] = "85926a3b02cd329675fb268f183f09ea9a6ec39910767ba9cc186f29e5b412e9206e3c3280bf75dc1bb74e11af4b986eb7baca96e1763f69ea79d4cdbccb73ba"
SRC_URI[deb1.md5sum] = "11a0c8439c55e2a6177f695b084ef55b"
SRC_URI[deb1.sha1sum] = "5dfb0fdd202ebea6a34dedf99df205c8099ce053"
SRC_URI[deb1.sha256sum] = "26e311a867ef831d2378a33e772b1f21924261eedcefe08f7ce852c6176c2836"
SRC_URI[deb1.sha512sum] = "0489e0c68fbac0d50450d7a6210d1cba9b33095f1e57f5ad56ddf6cb8ef32fd3a6b4517be678b09ed0cda839ef748a31035f0025be9379e7b0c44c07a8c5f93f"

RDEPENDS = " \
    libprotobuf-lite32t64 \
    libprotobuf32t64 \
    zlib1g-dev \
"

RPROVIDES = " \
    protobuf-api-32-0 \
"
