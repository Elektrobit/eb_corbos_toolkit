# This was autogenerated! Do not modify
SUMMARY = "Diagnostic Log and Trace (DLT) library (development)"
DESCRIPTION = ""
SECTION = "libdevel"
SOURCE_PACKAGE = "dlt-daemon"
HOMEPAGE = "https://github.com/COVESA/dlt-daemon"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/d/dlt-daemon/libdlt-dev_2.18.10-10+b1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/d/dlt-daemon/libdlt-dev_2.18.10-10+b1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "eb9c8c140c487995bc8cd1bc8df4b34d"
SRC_URI[deb0.sha1sum] = "63c4699c5e7fbf65b9f08aefe387fa24acea37b7"
SRC_URI[deb0.sha256sum] = "875e0346af8b4b3733108a2b43d135a6d337373936d3dd1e5c2f6e616f139aa0"
SRC_URI[deb0.sha512sum] = "6bc6179afc9852d385b802bd2174dc173359935e28cc9fe651a8fa4dd07263dd9e6114e9ca360891c5dc30de39c5ed256258164e22daf61472978e391ac634d4"
SRC_URI[deb1.md5sum] = "65ba423b88f6cd201ef000a81277b9e3"
SRC_URI[deb1.sha1sum] = "b028ebd1673b277589c93946d114af1bb1e5b4a4"
SRC_URI[deb1.sha256sum] = "addb8058114120f3f5c6de08c102c81647d50d616674971932290839fae7a45c"
SRC_URI[deb1.sha512sum] = "2f8193cc024333ddf6daa9ec83b6edb5865b50b89e99cf5f1f31dfa65239959051b6e4c5474f89194d10a39bcc63884f55721fb5d97931b72d484d1ee78ee0cf"

RDEPENDS = " \
    libdlt2 \
"

