# This was autogenerated! Do not modify
SUMMARY = "Rust standard libraries - development files"
DESCRIPTION = ""
SECTION = "libdevel"
SOURCE_PACKAGE = "rustc"
HOMEPAGE = "http://www.rust-lang.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_DEBIAN_TRIXIE_BACKPORTS}/pool/main/r/rustc/libstd-rust-dev_1.96.1+dfsg1-2~bpo13+1_amd64.deb;name=deb0 \
    ${REPO_DEBIAN_TRIXIE_BACKPORTS}/pool/main/r/rustc/libstd-rust-dev_1.96.1+dfsg1-2~bpo13+1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.sha256sum] = "c95ea7cdd8115bf6b577f0d5dfdc329b1469183ac1bf2d1739d8c4333a9f6151"
SRC_URI[deb1.sha256sum] = "ecd2916cc922b226dbfeb4465edd6336a24c5f4fd8fb69c64c4124a9446d709f"

RDEPENDS = " \
    libstd-rust-1.96 \
"

