# This was autogenerated! Do not modify
SUMMARY = "compiler for protocol buffer definition files"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "protobuf"
HOMEPAGE = "https://github.com/google/protobuf/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/protobuf/protobuf-compiler_3.21.12-11+deb13u1_amd64.deb;name=deb0 \
    ${REPO_EB_UPSTREAM_BASELINE}/pool/trixie_main/p/protobuf/protobuf-compiler_3.21.12-11+deb13u1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.md5sum] = "837a8731f911643b6cab788b93f88e22"
SRC_URI[deb0.sha1sum] = "90204975db5531e345b932e3058e42c5a4aca7c1"
SRC_URI[deb0.sha256sum] = "62c6085aeeb8cbcb16747fcf7170aaddcff344874a3aa60a272e423cbeb89b3a"
SRC_URI[deb0.sha512sum] = "b31420c880dc166a0970c1eded13825f6bc7f214b115c8bbb738b540ab13d638fa1c1e5eddb7ee2801c5c086e80f700eed61001476303112f9c327e0a573337a"
SRC_URI[deb1.md5sum] = "7d454428680090c33c7d3d4ae767d56a"
SRC_URI[deb1.sha1sum] = "a98be689f9da1830a64afff7bb1f49ba755a9c88"
SRC_URI[deb1.sha256sum] = "a873f75cbdf8054a23687e7c9b39ca1a93545edd22a581f4caa560756678f658"
SRC_URI[deb1.sha512sum] = "9cc99fd85d6c75ad822b9b9c507cb6df6f37e8e0c213b3d96e4116f8b87b2380b5edadb1d58cf54e62aece27a05ab5f60f40444045fc614d7dde6c6263e55d6b"

RDEPENDS = " \
    libc6 \
    libgcc-s1 \
    libprotoc32t64 \
    libstdc++6 \
"

