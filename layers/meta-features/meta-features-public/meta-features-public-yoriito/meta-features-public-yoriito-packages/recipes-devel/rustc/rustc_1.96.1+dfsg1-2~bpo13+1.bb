# This was autogenerated! Do not modify
SUMMARY = "Rust systems programming language"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "rustc"
HOMEPAGE = "http://www.rust-lang.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_DEBIAN_TRIXIE_BACKPORTS}/pool/main/r/rustc/rustc_1.96.1+dfsg1-2~bpo13+1_amd64.deb;name=deb0 \
    ${REPO_DEBIAN_TRIXIE_BACKPORTS}/pool/main/r/rustc/rustc_1.96.1+dfsg1-2~bpo13+1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.sha256sum] = "672ad6bb27e69354cc08c10fc583fabdc9a306af19f967a7dab005de6a21409e"
SRC_URI[deb1.sha256sum] = "b07c31c17f0ed2bc780095e73bae775bb20796b232bfec56297fd1ec1660ee71"

RDEPENDS = " \
    binutils \
    gcc \
    libc-dev \
    libc6 \
    libgcc-s1 \
    libstd-rust-dev \
"

