# This was autogenerated! Do not modify
SUMMARY = "Rust package manager"
DESCRIPTION = ""
SECTION = "devel"
SOURCE_PACKAGE = "rustc"
HOMEPAGE = "http://www.rust-lang.org/"

inherit dpkg-prebuilt


SRC_URI = " \
    ${REPO_DEBIAN_TRIXIE_BACKPORTS}/pool/main/r/rustc/cargo_1.96.1+dfsg1-2~bpo13+1_amd64.deb;name=deb0 \
    ${REPO_DEBIAN_TRIXIE_BACKPORTS}/pool/main/r/rustc/cargo_1.96.1+dfsg1-2~bpo13+1_arm64.deb;name=deb1 \
"

SRC_URI[deb0.sha256sum] = "bd97646f93fadf1a473b6d4cf93f4caf3fbda33f039b496dbc2ebec6c8e30aa9"
SRC_URI[deb1.sha256sum] = "8886a0d783d1880eb2ec28106cbaf03f09f297c2aed23a2d9a44963aeed87295"

RDEPENDS = " \
    binutils \
    gcc \
    libc6 \
    libcurl4t64 \
    libgcc-s1 \
    libgit2-1.9 \
    libsqlite3-0 \
    libssh2-1t64 \
    libssl3t64 \
    rustc \
"

